# Allegro board LAD752PR10-0816.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
N31442990: length 4.9
  TOP w0.254: PR5031.2 141.3,144.82 PC5008.1 140.42,144.79 v1(139.9,145.32)
  BOTTOM w0.254: PU507.24 140.15,146.44 v2(139.94,146.23) 139.9,146.18 v1(139.9,145.32)
N31443441: length 5.4
  TOP w0.107: v2(169.73,148.14) 168.73,147.14 PC549.2
  TOP w0.254: PC549.2 168.35,147.11 167.26,146.03 v1(167.26,145.7)
  BOTTOM w0.254: PU503.3 167.41,145.56 v1(167.26,145.7) 167.26,145.77 167.7,146.21 PR5004.1
N31452288: length 1.9
  BOTTOM w0.107: v2(151.1,151.67) 152.05,151.67 PC574.1
N31452345: length 2.6
  BOTTOM w0.107: v2(148.94,149.67) PR591.1
  BOTTOM w0.254: PU510.1 150.39,148.44 150.17,148.67 150.17,148.92 149.91,149.18 PR591.1
N31452390: length 1.6
  BOTTOM w0.254: PR594.1 150.67,149.54 150.67,148.86 150.89,148.64 PU510.2
N31459506: length 3.3
  TOP w0.107: v1(151.26,149.01) 151.26,149.32 v2(151.65,149.7)
  TOP w0.254: v1(151.26,149.01) 151.15,148.89 PC573.2
  BOTTOM w0.254: PR5024.1 151.69,149.62 151.26,149.2 v1(151.26,149.01) 151.39,148.87 PU510.3
N31460044: length 3.5
  TOP w0.107: v1(148.79,146.02) 148.54,146.02 v2(148.28,145.76)
  TOP w0.254: PC5009.1 PR5032.2 149.1,145.71 v1(148.79,146.02)
  BOTTOM w0.254: PU510.24 149.23,146.46 v1(148.79,146.02)
N31466143: length 1.1
  TOP w0.107: v2(79.96,26.32) 79.89,26.38 PR733.1
N31494164: length 1.1
  BOTTOM w0.107: PC586.1 v2(184.19,147.29)
N31494209: length 1.4
  BOTTOM w0.107: v2(186.7,145.13) 186.38,144.82 PR5005.2
N31494627: length 2.8
  BOTTOM w0.254: PU511.12 181.3,142.63 181.05,142.88 181.05,144.3 180.98,144.37 180.98,144.87 PR5001.2
N31495785: length 3.5
  TOP w0.107: v1(182.32,144.3) 181.94,144.3 v2(181.76,144.48)
  TOP w0.254: v1(182.32,144.3) 182.32,143.82 PC588.2
  BOTTOM w0.254: PU511.2 182.93,143.82 182.44,144.3 v1(182.32,144.3) 182.32,144.49 182.69,144.87 PR5025.1
N31495969: length 3.8
  TOP w0.107: v2(180.18,142.32) 180.52,141.99 v1(180.58,141.99)
  TOP w0.254: PR5026.2 182.09,140.83 PC5002.2 180.83,141.73 v1(180.58,141.99)
  BOTTOM w0.254: PU511.11 180.72,142.13 v1(180.58,141.99)
N31535656: length 2.4
  BOTTOM w0.203: PR107.1 50.3,46.32 v2(51.06,46.32) 51.46,46.32 51.71,46.08 PU100.19
N31565200: length 2
  TOP w0.107: v1(157.33,144.87) 157.33,145.23 v2(157.16,145.4)
  TOP w0.254: v1(157.33,144.87) 157.34,144.86 PR599.1
  BOTTOM w0.254: v1(157.33,144.87) PU502.26
N31565645: length 5.5
  TOP w0.107: v1(165.66,144.82) 167.3,144.82 v2(167.69,144.43)
  TOP w0.254: v1(165.66,144.82) 165.67,144.81 165.67,143.73 PR5011.1
  BOTTOM w0.254: v1(165.66,144.82) PU503.26
N31565698: length 5.5
  TOP w0.107: PC5006.1 165.88,139.03 v2(165.73,138.88)
  TOP w0.254: v1(164.79,142.78) 165.29,142.28 165.29,141.5 PR5029.2 165.92,140.02 PC5006.1
  BOTTOM w0.254: v1(164.79,142.78) 165.15,143.15 PU503.24
N31566286: length 2
  TOP w0.107: v1(174,144.85) 174,145.32 173.88,145.45 v2(173.87,145.45)
  TOP w0.254: v1(174,144.85) 174.02,144.83 PR5019.1
  BOTTOM w0.254: v1(174,144.85) PU504.26
N31567454: length 2
  TOP w0.107: v2(141.23,148.75) 141.31,148.67 v1(141.31,148.11)
  TOP w0.254: PR5021.1 141.33,148.1 v1(141.31,148.11)
  BOTTOM w0.254: v1(141.31,148.11) PU507.26
N31567631: length 2.1
  TOP w0.107: v1(149.64,148.13) 149.64,148.78 v2(149.55,148.88)
  TOP w0.254: v1(149.64,148.13) 149.66,148.12 PR5023.1
  BOTTOM w0.254: v1(149.64,148.13) PU510.26
N32073814: length 3.7
  TOP w0.203: PU8200.8 v1(280.23,157.62) 280.7,157.62 PR8208.1
  TOP w0.254: PC8215.1 PR8208.1
  BOTTOM w0.107: v1(280.23,157.62) v2(280.23,156.88)
N32073817: length 6.7
  TOP w0.107: PR8214.2 280.36,154.36 v2(280.07,154.36)
  TOP w0.203: PU8200.7 279.73,157.22 280.09,156.85 PC8217.1
  TOP w0.254: PR8208.2 282,157.78 PC8217.1 PR8211.1 PR8214.2
N32074224: length 2
  BOTTOM w0.107: v2(273.8,159.84) 273.06,159.1 PR8204.2
N32074541: length 1
  TOP w0.107: PC8219.1 v2(263.67,172.13)
N32187709: length 1.4
  BOTTOM w0.107: PU802.10 v2(235.43,35.63)
N32187730: length 1.1
  BOTTOM w0.107: v2(232.1,34.83) 231.83,35.1 PC806.1
N32220030:
  vias: v2(245.31,25.11)
N32220048: length 2.4
  BOTTOM w0.107: PR305.2 254.7,22.85 253.97,22.12 v2(253.97,21.52)
N32273050: length 8.3
  TOP w0.107: v1(288.14,61.06) 288.14,61.09 v2(287.73,61.5)
  TOP w0.254: PR6031.1 288.59,61.51 v1(288.14,61.06)
  BOTTOM w0.203: PU8201.48 287.19,60.52 287.47,60.8 287.88,60.8 v1(288.14,61.06) 288.3,61.22 289.43,61.22 PC6009.1
  BOTTOM w0.254: PR6028.2 PC6007.2 289.96,63.53 PR6025.1 PC6009.1
N32273054: length 3.5
  BOTTOM w0.203: PU8201.47 286.79,60.63 287.35,61.18 287.61,61.18 288.17,61.74 PC6008.2
  BOTTOM w0.254: PC6008.2 289.04,61.74 PC6009.2
N32273056: length 12.4
  TOP w0.254: PR6000.2 297.13,53.18 v2(296.2,53.18) 293.32,53.18 292.34,54.16 v1(290.78,54.16) 289.47,55.47 PC6000.1
  BOTTOM w0.203: PU8201.11 289.92,55.14 290.78,54.28 v1(290.78,54.16)
N32273064: length 12.1
  BOTTOM w0.203: PU8201.24 284.79,53.21 284.48,52.89 284.48,51.02 284.12,50.66 284.12,49.7 283.54,49.12 PR6068.2
  BOTTOM w0.254: PC6026.2 PC6025.2 286.46,47.61 PR6070.2 286.47,47.2 286.22,46.95 284.12,46.95 v2(284.05,47.02) 283.54,47.53 PR6068.2
N32273074: length 8.3
  TOP w0.107: v1(281.42,57.18) v2(280.87,57.18)
  TOP w0.254: PC6004.2 281.74,57.5 v1(281.42,57.18)
  BOTTOM w0.203: 281.42,55.04 281.42,55.29 281.06,55.65 281.06,56.82 v1(281.42,57.18) 281.61,57.37 282.39,57.37 282.63,57.14 PU8201.34
  BOTTOM w0.254: PR6013.1 279.81,55.41 280.17,55.41 PR6012.2 PC6005.2
N32273076: length 13.8
  TOP w0.254: PR6087.2 PR6088.2 297.23,55.54 v2(296.83,55.94) 295.44,55.94 294.74,55.24 293.01,55.24 292.08,56.17 290.85,56.17 290.39,56.63 v1(290.39,57.61) 287.85,57.61 PC6002.2
  BOTTOM w0.203: PU8201.5 290.32,57.54 v1(290.39,57.61)
N32273088: length 11.4
  TOP w0.254: v1(289.25,65.89) 289.76,65.89 290.01,65.64 v2(290.01,64.74) v1(290.01,61.12)
  BOTTOM w0.203: PU8201.50 287.99,60.26 288.62,60.89 289.78,60.89 v1(290.01,61.12)
  BOTTOM w0.254: PR6028.1 288.25,64.48 PR6024.1 288.24,65.64 288.49,65.89 v1(289.25,65.89)
N32273092: length 7.9
  TOP w0.254: v1(290.11,53.09) 290.11,51.68 PC6001.2
  BOTTOM w0.203: PU8201.13 289.72,54.34 289.92,54.13 289.92,53.28 v1(290.11,53.09) 290.62,53.09 v2(290.65,53.05) 290.69,53.02 PR6003.2
N32273102: length 6.7
  BOTTOM w0.203: PR6085.2 282.09,61.59 v2(282.67,61) 282.67,59.48 283.02,59.14 PU8201.39
  BOTTOM w0.254: PR6085.2 PR6026.1 280.77,63.41 PC6010.2 PR6027.2
N32273120: length 49.3
  IN4 w0.254: v1(286.25,64.23) 284.81,64.23 281.91,61.33 279.75,61.33 278.71,62.38 273.83,62.38 273.07,61.62 248.85,61.62 248.39,62.07 247.45,62.07 v1(247.32,61.93)
  BOTTOM w0.203: PU8201.44 285.59,61.09 285.33,61.36 PC6014.1
  BOTTOM w0.254: v1(286.25,64.23) PR6050.2 286.24,63.58 PR6042.1 285.33,63.57 PC6015.1 ; PC6015.1 PC6014.1 ; PC6015.1 286.19,62.64 PR6052.1 PR6047.2 ; PH6000.1 246.63,61.93 v1(247.32,61.93)
N32273126: length 6.8
  TOP w0.254: PC6003.2 288.32,56.13 289.42,56.13 290.84,54.71 v1(291.09,54.71)
  BOTTOM w0.203: PR6017.1 291.72,54.08 v1(291.09,54.71) 290.85,54.95 v2(290.65,54.95) 290.06,55.54 PU8201.10
N32273150: length 6.3
  BOTTOM w0.107: PR6033.1 279.66,61.5 v2(279.36,61.8)
  BOTTOM w0.203: PR6019.2 282,60.69 282.34,60.34 282.34,59.33 282.93,58.74 PU8201.38
  BOTTOM w0.254: PR6033.1 280.54,60.67 PC6006.2 PR6019.2
N32273186: length 2.9
  BOTTOM w0.107: v2(289.57,65.44) 289.57,64.04 289.12,63.6 PC6007.1
  BOTTOM w0.254: PC6007.1 288.25,63.6 PR6024.2
N32273265: length 8.9
  IN4 w0.254: v1(287.16,66.14) 287.16,62.07 286.14,61.06 v1(286.08,61.06)
  BOTTOM w0.107: v1(287.16,66.14) v2(287.16,66.71)
  BOTTOM w0.203: PU8201.45 285.99,60.97 v1(286.08,61.06) 286.2,61.18 PR6052.2
  BOTTOM w0.254: PC6017.1 v1(287.16,66.14)
N32273277: length 9.8
  TOP w0.254: v1(291.03,58.96) 291.66,58.96 v2(291.85,59.15) 291.98,59.28 294.8,59.28 295.5,59.98 PR6005.2
  BOTTOM w0.203: PR6010.2 291.66,58.52 291.22,58.96 v1(291.03,58.96) 290.58,58.96 289.96,58.34 PU8201.3
N32273279: length 0.9
  BOTTOM w0.254: PR6025.2 289,62.66 PC6008.1
N32273281: length 18.3
  TOP w0.254: PC6018.2 283.79,61.07 v1(283.79,61.65) 284.32,62.19 284.32,62.94 v2(283.66,63.6) 283.05,64.21 283.05,65.58 v1(282.51,66.12) 282.51,66.44 v1(283.47,67.41) ; v1(283.47,67.41) 282.18,68.7 v1(281.76,68.7) ; v1(283.47,67.41) 283.54,67.34 v1(285.57,67.34)
  BOTTOM w0.203: PU8201.41 284.39,60.47 283.79,61.08
  BOTTOM w0.254: PR6058.2 281.97,66.8 282.43,66.34 282.43,66.2 v1(282.51,66.12) ; PR6055.2 v1(283.47,67.41) ; v1(285.57,67.34) 285.63,67.41 PR6054.2 ; 283.79,61.08 v1(283.79,61.65) ; v1(281.76,68.7) 281.53,68.93 PR6057.2
N32273283: length 8.5
  BOTTOM w0.107: PC6012.2 291.98,62.95 290.9,64.03 v2(290.9,65.09)
  BOTTOM w0.203: PC6011.2 290.92,61.75 PR6039.2 290.9,61.56 290.52,61.18 290.52,60.94 290.14,60.56 288.76,60.56 288.39,60.2 PU8201.51
  BOTTOM w0.254: PC6012.2 291.98,61.96 PC6011.2
N32273319: length 24.3
  TOP w0.254: v1(285.51,52.74) 285.51,52.65 285.45,52.59 285.45,52.12 PR6072.2
  IN1 w0.254: v1(276.87,60.73) 277.48,60.12 277.48,57.77 277.85,57.4 278.21,57.4 278.86,58.05 282.34,58.05 283.55,56.84 283.55,54.35 284.21,53.69 284.58,53.69 285.51,52.75 v1(285.51,52.74)
  BOTTOM w0.203: PR6077.2 285.57,52.09 PR6078.1 285.51,52.15 v1(285.51,52.74) 285.59,52.82 PU8201.22
  BOTTOM w0.254: PR6077.2 285.2,51.23 284.62,50.64 PR6069.1 PC6025.1 PC6026.1 ; PH6001.1 277,60.6 v1(276.87,60.73)
N32273363: length 7.1
  BOTTOM w0.203: PC6011.1 292.69,61.45 292.49,61.25 291.47,61.25 v2(290.71,60.48) 290.58,60.48 290.33,60.23 289,60.23 288.79,60.03 PU8201.52
  BOTTOM w0.254: PC6013.2 293.05,63.46 PR6041.2 292.69,62.29 PC6011.1
N32273439: length 9
  TOP w0.254: v1(290.52,55.79) 291.79,55.79 292.81,54.77 295.14,54.77 295.4,55.02 296.11,55.02 296.49,54.64 v2(296.81,54.64) PR6018.2
  BOTTOM w0.203: PU8201.9 290.37,55.94 v1(290.52,55.79)
N32273453: length 3
  BOTTOM w0.203: PR6056.2 291.09,55.58 291.09,55.91 v2(290.78,56.23) 290.67,56.34 PU8201.8
N32273563: length 4.5
  BOTTOM w0.203: PR6019.1 281.81,59.77 282.01,59.57 282.01,59.17 282.85,58.34 PU8201.37
  BOTTOM w0.254: PR6019.1 PC6006.1 279.69,59.77 PR6021.2
N32273609: length 6.7
  BOTTOM w0.203: PU8201.33 282.84,56.74 282.77,56.81 282.46,56.81 282.27,57 281.89,57 281.57,56.69 v2(281.57,56.25) 281.57,55.77 281.95,55.38 281.95,54.69 281.44,54.18 PC6005.1
  BOTTOM w0.254: PR6015.2 280.54,54.13 PR6012.1 PC6005.1
N32273633: length 6.2
  BOTTOM w0.203: PR6063.2 289.26,52.22 289.04,52.44 288.4,52.44 287.99,52.85 PU8201.16
  BOTTOM w0.254: PC6019.2 PR6060.1 PC6021.1 PR6065.1 PR6063.2
N32273643: length 20.4
  IN1 w0.254: v1(277,58.59) 277.02,58.57 277.02,57.68 277.73,56.98 278.33,56.98 279.02,57.66 282.18,57.66 283.17,56.68 283.17,54.19 284.22,53.14 284.22,49.98 v1(285.49,48.71)
  BOTTOM w0.107: v1(277,58.59) 277,58.58 v2(277.44,58.13)
  BOTTOM w0.254: PR6069.2 284.86,48.71 v1(285.49,48.71) 285.56,48.65 PR6070.1 ; PH6001.2 v1(277,58.59)
N32273684: length 2.6
  BOTTOM w0.203: PU8201.21 285.99,52.6 286.47,52.13 PR6078.2
  BOTTOM w0.254: PR6078.2 286.47,51.24 PC6028.1
N32273716: length 17
  TOP w0.254: v1(283.75,62.5) 283.43,62.5 281.92,64 v1(281.92,66.08) v2(281.92,66.71) 281.92,66.81 v1(282.39,67.28)
  BOTTOM w0.203: PC6014.2 284.47,61.69 285.19,60.97 285.19,59.82 PU8201.43
  BOTTOM w0.254: PC6015.2 284.41,63.53 PR6043.2 ; PC6015.2 283.9,62.64 v1(283.75,62.5) ; PC6015.2 PC6014.2 ; v1(281.92,66.08) 281.47,66.08 PR6048.1 ; PR6040.1 284.55,67.28 284.17,66.9 282.77,66.9 v1(282.39,67.28) PR6044.1 281.91,68.04 281.72,67.85 PR6046.1
N32273720: length 5.3
  TOP w0.107: PR6006.1 v2(300.45,59.09)
  TOP w0.508: PR6090.2 PR6089.2 PR6004.1 PR6005.1 PR6006.1
N32273790: length 4.9
  BOTTOM w0.107: v2(293.57,60.8) 291.99,60.8 291.72,60.52 PR6008.2
  BOTTOM w0.203: PR6008.2 291.35,60.29 291.16,60.1 290.71,60.1 289.75,59.14 PU8201.1
N32273792: length 10.6
  TOP w0.254: PR6075.1 297.63,57.18 v2(296.48,57.18) 295.37,57.18 293.81,55.62 293.16,55.62 292.11,56.67 v1(291.03,56.67)
  BOTTOM w0.203: PU8201.7 290.97,56.74 v1(291.03,56.67) 291.03,56.53 PR6080.2
N32273794: length 9.8
  TOP w0.254: v1(291.03,57.31) 294.55,57.31 295.57,58.33 v2(295.65,58.33) 297.63,58.33 PR6074.1
  BOTTOM w0.203: PU8201.6 290.86,57.14 v1(291.03,57.31) 291.14,57.31 PR6079.2
N32273848: length 4.3
  TOP w0.107: v2(282.61,52.77) 282.82,52.98 v1(283.58,52.98)
  TOP w0.254: PR6064.2 283.54,52.94 v1(283.58,52.98)
  BOTTOM w0.203: PC6022.2 283.02,52.37 283.58,52.93 ; PU8201.26 283.99,53.34 283.58,52.93 ; v1(283.58,52.98) 283.58,52.93
  BOTTOM w0.254: PC6023.2 283.03,52.34 PC6022.2
N32273852: length 4.5
  BOTTOM w0.203: PU8201.25 284.39,53.28 284.13,53.02 284.13,52.56 PC6022.1
  BOTTOM w0.254: PR6066.1 283.56,50.02 283.56,50.71 v2(284.01,51.15) 284.01,51.66 283.93,51.73 PC6022.1
N32274096: length 6.5
  TOP w0.107: v1(290.78,53.56) v2(290.78,52.34)
  TOP w0.254: v1(290.78,53.56) 290.55,53.56 290.03,54.08 288.24,54.08 PR6082.2
  BOTTOM w0.203: v1(290.78,53.56) 290.65,53.56 290.28,53.93 290.28,54.31 289.85,54.74 PU8201.12
N32274305: length 4.5
  TOP w0.107: v2(287.4,51.11) PR6071.2
  TOP w0.254: 287.61,53.47 287.61,53.11 287.61,53.11 287.61,52.5 287.4,52.28 PR6071.2 ; 287.61,53.47 287.79,53.47 288.35,52.92 v1(288.61,52.92) ; 287.61,53.47 PC6024.2
  BOTTOM w0.203: PU8201.15 288.39,53.13 v1(288.61,52.92)
N32274335: length 8.2
  IN4 w0.254: v1(291.66,51.02) 288.83,51.02 v1(287.12,52.74)
  BOTTOM w0.107: v1(291.66,51.02) v2(292.17,51.02)
  BOTTOM w0.203: PU8201.19 286.79,53.23 287.09,52.93 287.09,52.76 v1(287.12,52.74) 287.12,52.71 287.16,52.67 287.16,52.24 PC6020.2
  BOTTOM w0.254: PC6021.2 v1(291.66,51.02)
N32274341: length 3
  BOTTOM w0.203: PU8201.17 287.59,52.67 PR6063.1 PR6059.1
N32274405: length 6.5
  TOP w0.254: v1(290.81,49.5) 290.81,49.43 290.32,48.93 287.6,48.93 287.35,49.18 v2(287.35,49.56) v1(287.35,50.26)
  BOTTOM w0.254: PR6060.2 291.04,49.73 v1(290.81,49.5) ; PC6020.1 v1(287.35,50.26)
N32274409: length 2.4
  BOTTOM w0.107: v2(288.35,49.05) PC6019.1
  BOTTOM w0.254: PC6019.1 288.38,50.13 288.76,50.51 288.76,50.52 288.9,50.67 288.91,50.67 PR6059.2
N32274431: length 17.1
  TOP w0.254: PR6081.2 289.19,52.67 v1(289.51,52.99) ; PR6049.1 PC6016.2 285.2,60.43 v2(285.19,60.42) 284.8,60.81 v1(284.7,60.81)
  IN1 w0.254: v1(289.51,52.99) 289.51,60.04 288.97,60.57 284.94,60.57 v1(284.7,60.81)
  BOTTOM w0.203: v1(284.7,60.81) 284.79,60.72 PU8201.42
N32274465: length 3.6
  TOP w0.107: v2(284.49,52.29) 284.85,52.65 v1(284.93,52.65)
  TOP w0.254: PR6073.1 285.72,53.35 285.52,53.55 PC6027.2 284.91,52.74 284.93,52.71 v1(284.93,52.65)
  BOTTOM w0.203: v1(284.93,52.65) 284.98,52.7 284.98,52.93 285.19,53.14 PU8201.23
N32274547: length 6.8
  BOTTOM w0.203: PU8201.40 283.99,60.33 283.54,60.79
  BOTTOM w0.254: 283.54,60.79 283.18,61.15 v2(283.18,62.35) 283.18,62.83 283.49,63.14 PR6029.2 PR6086.1 PC6010.1 PR6027.1
N32274908: length 44.1
  IN4 w0.254: v1(247.33,62.64) 247.52,62.45 248.55,62.45 249,62 272.91,62 273.67,62.76 278.87,62.76 279.91,61.72 281.75,61.72 284.92,64.88 v1(286.2,64.88)
  BOTTOM w0.254: PH6000.2 246.58,62.64 v1(247.33,62.64) ; v1(286.2,64.88) 285.77,64.88 285.39,64.5 PR6042.2 PR6043.1
N32278456: length 1.3
  BOTTOM w0.107: v2(277.44,56.67) 276.68,57.44 PC6411.2
N32278462: length 7.9
  TOP w0.254: PC6400.2 264.11,59.21 v2(265.18,58.13) 266.9,56.42 v1(266.9,56.29)
  BOTTOM w0.203: 267.09,55.26 267.47,54.88 PU6400.6
  BOTTOM w0.254: PR6400.2 266.88,56.31 v1(266.9,56.29) 267.09,56.1 267.09,55.26
N32278468: length 0.5
  BOTTOM w0.107: 269.63,56.67 v2(269.63,57.18)
N32278470:
  vias: v2(271.66,57.31)
N32278548: length 1.1
  BOTTOM w0.107: PC6410.1 v2(269.35,47.76)
N32320046: length 1.3
  BOTTOM w0.107: PR6401.1 v2(266.77,50.3)
N32336439: length 0.9
  TOP w0.107: PC6128.2 v2(254.68,59.55)
N32336483:
  vias: v1(249.51,57.74)
N32336487:
  vias: v1(253.09,60.31) v2(253.63,58.45)
N32336585: length 5.3
  TOP w0.107: v2(246.33,57.5) 246.76,57.06 v1(246.76,56.48)
  TOP w0.254: v1(246.76,56.48) 247.08,56.48 247.42,56.81 PR6112.2 247.62,56.81 248.36,56.81 248.54,56.64 PC6117.2
  BOTTOM w0.203: v1(246.76,56.48) 246.83,56.48 247.4,55.9 PU6102.6
N32336677: length 1.1
  BOTTOM w0.107: PC6127.1 v2(249.75,48.93)
N32336681: length 1.2
  BOTTOM w0.107: PR6113.1 v2(247.28,51.46)
N32338871: length 1.3
  BOTTOM w0.107: PC6227.1 v2(232.61,48.8)
N32338879: length 1.3
  BOTTOM w0.107: PR6213.1 v2(230.07,51.47)
N32339676: length 1.1
  TOP w0.107: PC6228.2 v2(237.69,59.46)
N32339714:
  vias: v1(235.97,60.22) v2(236.9,58.07)
N32339788: length 5.6
  TOP w0.107: v2(229.5,57.94) 229.62,57.82 v1(229.62,56.48)
  TOP w0.254: v1(229.62,56.48) 229.94,56.48 230.28,56.82 PR6212.2 230.48,56.82 232.09,56.82 PC6217.2
  BOTTOM w0.203: PU6202.6 230.26,55.91 229.69,56.48 v1(229.62,56.48)
N32433695: length 3.9
  BOTTOM w0.089: UG13.J13 205.39,138.08 204.54,138.08 204.15,138.47
  BOTTOM w0.107: RG92.1 203.15,139.48 v2(203.59,139.03) 204.15,138.47
N32433703: length 2.6
  TOP w0.089: RG88.1 215.78,137.29 v1(215.07,138) 215.26,138 v2(215.72,138.46)
  BOTTOM w0.089: v1(215.07,138) 215.47,137.6 UG13.J1
N32433714: length 4.5
  TOP w0.089: v1(208.77,137.51) 208.99,137.51 209.24,137.26 209.73,137.26 210.48,136.51 RG90.1 210.89,137.1 v2(211.45,137.66)
  BOTTOM w0.089: UG13.J10 208.44,137.44 208.7,137.44 v1(208.77,137.51)
N32434049: length 7.8
  TOP w0.089: v2(229.43,140.75) 229.07,141.11 v1(229.07,141.2) 229.53,141.66 RG93.1
  BOTTOM w0.089: UG14.J13 229.02,137.26
  BOTTOM w0.1: 229.02,137.26 229.69,137.26 229.82,137.39 229.82,141 229.62,141.2 v1(229.07,141.2)
N32434050: length 5.2
  TOP w0.089: RG89.1 218.78,139.22 220.48,139.22 220.67,139.03 220.67,138.53 220.48,138.34 220.35,138.34 219.47,137.45 v1(219.47,137.2)
  BOTTOM w0.089: UG14.J1 v1(219.47,137.2)
N32434053: length 3.1
  TOP w0.089: RG91.1 224.45,137.86 224.49,137.82 v2(224.6,137.82) 224.89,137.82 v1(225.07,138)
  BOTTOM w0.089: UG14.J10 225.47,137.6 v1(225.07,138)
N32437553: length 7.4
  TOP w0.089: v2(233.82,140.75) 233.47,141.09 v1(233.47,141.2) 232.96,141.71 RG105.1
  BOTTOM w0.1: UG15.J13 233.53,137.26 232.87,137.26 232.74,137.39 232.74,141.02 232.92,141.2 v1(233.47,141.2)
N32437554: length 1.9
  TOP w0.089: v1(243.07,137.2) v2(243.07,137.76)
  TOP w0.1: v1(243.07,137.2) 243.11,137.2 243.49,136.82 RG102.1
  BOTTOM w0.089: v1(243.07,137.2) 243.47,137.6 UG15.J1
N32437557: length 3.8
  TOP w0.1: RG103.1 237.39,138.8 237.05,138.46 236.5,138.46 236.3,138.27 236.3,137.57 v1(236.67,137.2)
  BOTTOM w0.089: UG15.J10 v1(236.67,137.2)
N32437559: length 3.8
  BOTTOM w0.107: RG107.1 v2(258.96,139.18) 258.79,139.18 257.7,138.09 257.16,138.09 UG16.J13
N32437560: length 2.1
  TOP w0.089: v1(247.47,137.2) 247.1,137.57 v2(247.02,137.57)
  TOP w0.1: RG104.1 247.43,137.2 v1(247.47,137.2)
  BOTTOM w0.089: UG16.J1 v1(247.47,137.2)
N32437563: length 2
  TOP w0.089: RG106.1 253.56,137.2 v1(253.87,137.2) 253.94,137.2 v2(254.26,136.87)
  BOTTOM w0.089: UG16.J10 v1(253.87,137.2)
N32441039: length 6.1
  TOP w0.089: RG121.1 279.45,125.94 278.92,125.41 v1(278.92,125.38)
  BOTTOM w0.1: v1(278.92,125.38) 278.92,125.38 278.92,125.96 278.76,126.12 275.99,126.12 275.79,125.92 275.79,125.48 UG17.J13
N32441040: length 2.1
  TOP w0.089: v1(274.92,115.81) 275.45,115.81 275.74,115.53 RG117.1
  BOTTOM w0.089: UG17.J1 v1(274.92,115.81)
N32441043: length 9.9
  BOTTOM w0.089: 282.56,121.76 276.17,121.76 UG17.J10
  BOTTOM w0.107: 282.56,121.76 RG119.1 v2(283.84,122.83)
N32441045: length 8.2
  TOP w0.089: v2(278.49,102.24) 278.91,101.81 v1(278.92,101.81)
  TOP w0.1: 278.92,101.09 v1(278.92,101.81)
  TOP w0.107: RG120.1 278.92,101.09
  BOTTOM w0.1: v1(278.92,101.81) 278.92,101.26 278.72,101.06 275.23,101.06 275.01,101.28 275.01,101.9 UG18.J13
N32441046: length 2.1
  TOP w0.089: v2(275.6,111.16) 275.34,111.41 v1(274.92,111.41) 274.84,111.5 RG116.1
  BOTTOM w0.089: UG18.J1 v1(274.92,111.41)
N32441049: length 3.6
  TOP w0.089: RG118.1 276.53,105.61 276.17,105.25 276.17,104.87 275.92,104.62 275.32,104.62 v1(274.92,105.01)
  BOTTOM w0.089: UG18.J10 v1(274.92,105.01)
N32444525: length 8.1
  TOP w0.089: v1(278.92,97.41) 278.92,97.61 278.33,98.2 RG135.1 277.96,98.71
  TOP w0.107: 277.96,98.71 v2(277.96,99.13)
  BOTTOM w0.1: UG19.J13 274.98,97.36 274.98,98.02 275.12,98.16 278.72,98.16 278.92,97.96 v1(278.92,97.41)
N32444526: length 2.3
  TOP w0.089: v1(274.92,87.81) 274.8,87.69 RG131.1 274.8,86.43
  TOP w0.107: 274.8,86.43 v2(274.8,86.12)
  BOTTOM w0.089: UG19.J1 v1(274.92,87.81)
N32444529: length 2.7
  TOP w0.089: v2(275.19,93.41) v1(275.72,93.41) 275.76,93.38 RG133.1
  BOTTOM w0.089: v1(275.72,93.41) 275.32,93.81 UG19.J10
N32444531: length 7.2
  TOP w0.089: RG134.1 279.45,73.28 v1(278.92,73.81)
  BOTTOM w0.1: v1(278.92,73.81) 278.92,73.26 278.72,73.06 275.12,73.06 274.98,73.21 274.98,73.87 UG20.J13
N32444532: length 2.3
  TOP w0.089: RG130.1 274.84,83.5 v1(274.92,83.41) 275.48,83.41 v2(275.79,83.73)
  BOTTOM w0.089: UG20.J1 v1(274.92,83.41)
N32444535: length 10.6
  TOP w0.089: v2(276.49,78.39) 277.06,77.82 v1(277.06,77.79)
  TOP w0.107: v1(277.06,77.79) 280.83,77.79 RG132.1
  BOTTOM w0.089: v1(277.06,77.79) 276.68,78.18 275.51,78.18 275.32,77.99 UG20.J10
N32552238: length 1.5
  TOP w0.089: RG79.2 245.46,106.18 v1(245.04,105.76)
  BOTTOM w0.089: UG1.R14 244.62,105.33 v1(245.04,105.76)
N32559918: length 1.5
  TOP w0.381: RG78.2 239.59,89.18 v1(239.22,89.55)
  BOTTOM w0.3: UG1.AL20 239.07,89.55 v1(239.22,89.55)
N32621251: length 10.5
  BOTTOM w0.089: 229.56,78.66 229.56,82.61 229.18,82.99 228.65,82.99 228.42,83.22
  BOTTOM w0.107: 228.42,83.22 228.42,84.6 UG1.AU30 ; 229.56,78.66 v2(229.56,77.9) RG28.2 RG29.2
N32676252: length 2.7
  TOP w0.089: TV35.1 228.16,100.06 v1(228.42,99.8)
  BOTTOM w0.1: UG1.AA30 v1(228.42,99.8)
N32706715: length 3.2
  TOP w0.089: RG82.1 CG135.1 ; CG135.1 253.99,91.59 253.62,91.22 ; CG135.1 254.72,91.8 v2(255.02,92.11)
  TOP w0.107: 253.62,91.22 RG81.2
N32743557: length 1.5
  TOP w0.089: TV16.1 218.57,83.66 v1(218.57,83.15)
  BOTTOM w0.1: UG1.AW42 v1(218.57,83.15)
N32770979: length 3.9
  BOTTOM w0.107: PR813.2 192.57,75.42 191.93,76.05 v2(191.7,76.05)
  BOTTOM w0.254: PU800.13 194.59,75.55 194.46,75.42 PR812.1 PR813.2
N32822458: length 0.5
  TOP w0.107: v1(122.67,114.41) v2(123.21,114.41)
N32822470: length 13.9
  IN4 w0.254: v1(124.02,115.86) 123.32,116.56 123.32,120.18 121.13,122.37 v1(121.13,124.17)
  BOTTOM w0.107: v1(121.13,124.17) 121.13,124.4 v2(120.9,124.63)
  BOTTOM w0.254: PU509.14 123.73,116.34 124.02,116.05 v1(124.02,115.86) ; PR5015.1 121.11,122.47 PR5012.2 121.13,123.38 PC818.2 121.09,124.14 v1(121.13,124.17)
N32822602: length 4.5
  BOTTOM w0.107: v2(123,123.73) 122.78,123.51 122.78,122.1 PR5017.2
  BOTTOM w0.254: PR5017.2 123.19,121.58 PR5014.2 122.04,121.58 PR5012.1
N32822744: length 2.8
  BOTTOM w0.254: PU509.13 123.98,116.79 124.34,116.43 PR5034.2 PR5033.1
N32822911: length 4.2
  BOTTOM w0.254: PR5007.1 124.52,117.32 124.52,118.2 PC590.1 124.52,118.21 PR5008.1 124.03,119.1 123.71,118.77 123.71,117.97 123.43,117.69 PU509.11
N32822969: length 1.2
  BOTTOM w0.107: PC593.1 v2(119.39,112.05)
N32835753: length 22.1
  TOP w0.089: v1(227.77,101) 227.77,101.33 227.26,101.84 226.82,101.84 226.61,102.05 226.61,102.49 226.06,103.04 226.02,103.04 225.81,103.25 225.81,103.54 225.31,104.05 221.31,104.05 220.8,104.56 220.8,106.01 220.01,106.8 220.01,107.15 219.11,108.05 219.11,108.21 218.19,109.13 v2(218.19,113.57) 218.19,114.46 218.11,114.55
  TOP w0.107: RG60.2 218.11,114.55
  BOTTOM w0.3: UG1.Y31 227.77,100.85 v1(227.77,101)
N32835959: length 2.5
  TOP w0.089: v2(243.24,108.22) 243.24,107.46 RG61.2 243.38,107.3 v1(243.98,106.71)
  BOTTOM w0.089: v1(243.98,106.71) 243.67,106.4 UG1.P15
N32838652: length 3.7
  TOP w0.107: RG66.1 255.55,110.46 CG133.1 256.14,110.43 256.17,110.43 256.49,110.74 v2(256.49,111.22) 256.49,112.27 RG65.2
N33042292: length 3.4
  TOP w0.107: PR8213.2 v2(280.91,148.5)
  TOP w0.254: PQ8202.2 280.47,150.94 PC8222.1 PR8213.2
N33058126: length 2.2
  TOP w0.254: PR8214.1 282.1,154.96 v2(282.1,154.13) 281.63,153.66 PQ8202.1
N33364358: length 1.9
  BOTTOM w0.107: RV260.2 RV535.1 v2(211.78,103.22)
N33364367: length 2.9
  BOTTOM w0.107: UV23.4 210.39,110.73 210.02,111.11 RV533.2 v2(208.37,111.11)
N33364369: length 6.2
  BOTTOM w0.107: RV534.1 213.62,105.63 213.13,105.14 v2(212.8,105.14) RV535.2 211.07,105.85 RV537.1 CV22.1 211.07,107.03 UV23.3
N33587541: length 3.6
  TOP w0.254: PQ202.2 102.21,53.99 102.47,53.73 PR212.2 PC217.1
N33587555: length 4.4
  TOP w0.107: v2(101.38,55.85) PQ202.1
  TOP w0.254: PR213.2 100.78,53.03 100.78,54.36 101.07,54.64 PQ202.1
N33647933: length 4.1
  BOTTOM w0.203: 282.34,58.34 282.38,58.34 282.78,57.94 PU8201.36
  BOTTOM w0.254: PR6020.1 280.5,58.9 PR6083.2 281.43,58.93 PC6029.2 281.76,58.92 282.34,58.34
N33647937: length 4.9
  BOTTOM w0.107: v2(279.69,56.94) PR6022.2
  BOTTOM w0.203: 282.36,57.8 282.43,57.8 282.7,57.54 PU8201.35
  BOTTOM w0.254: PR6022.2 279.7,58.02 PR6083.1 281.43,58.02 PC6029.1 282.15,58.01 282.36,57.8
N33651095:
  vias: v1(244.53,60.22) v2(245.31,58.45)
N33651113: length 1.1
  BOTTOM w0.107: PC6215.1 v2(241.18,48.99)
N33651117: length 0.6
  TOP w0.107: v1(240.97,57.73) v2(240.97,58.31)
N33651207: length 5.4
  TOP w0.107: v1(238.2,56.48) 238.2,57.18 v2(237.75,57.63)
  TOP w0.254: PC6205.2 240.68,56.82 239.05,56.82 PR6209.2 238.85,56.82 238.51,56.48 v1(238.2,56.48)
  BOTTOM w0.203: PU6201.6 238.84,55.91 238.26,56.48 v1(238.2,56.48)
N33651327: length 1.2
  BOTTOM w0.107: PR6210.1 v2(238.71,51.47)
N33651387: length 1.1
  TOP w0.107: PC6216.2 v2(246.25,59.46)
N33654422:
  vias: v1(223.71,58.72)
N33654426: length 1.2
  BOTTOM w0.107: PC6315.1 v2(223.92,49.82)
N33654440:
  vias: v1(227.11,61.21) v2(228.04,59.34)
N33654550: length 5.3
  TOP w0.107: v1(220.93,57.48) 220.93,58 v2(220.42,58.52)
  TOP w0.254: PC6305.2 223.42,57.81 221.78,57.81 PR6309.2 221.58,57.81 221.25,57.48 v1(220.93,57.48)
  BOTTOM w0.203: v1(220.93,57.48) 221,57.48 221.57,56.9 PU6301.6
N33654622: length 1.3
  BOTTOM w0.107: PR6310.1 221.48,52.46 v2(221.37,52.36)
N33654648: length 1
  TOP w0.107: PC6316.2 v2(228.98,60.46)
N33668338: length 7.5
  BOTTOM w0.107: PU1301.7 208.19,75.13 207.58,74.52 v2(207.58,72.47)
  BOTTOM w0.254: PC1310.2 211.01,75.17 PR1309.1 ; PU1301.7 210.47,75.13 PR1309.1 ; PR1309.1 PR1307.2
N33730314: length 4.2
  TOP w0.107: v2(102.98,55.84) 102.98,55.19 102.75,54.96 102.75,54.49 103.25,53.99 PQ202.5
  TOP w0.254: PQ202.5 103.51,53.99 103.96,54.44 PC218.1 105.11,54.44 PR214.2
N33730328: length 2.5
  TOP w0.107: PR215.2 v2(105.24,52.27)
  TOP w0.254: PQ202.4 104.25,52.38 PR215.2
N33940720: length 9.2
  TOP w0.508: v1(65.03,40.86) v2(65.93,40.86) 67.09,40.86 PR726.1
  BOTTOM w0.508: PQ707.4 69.73,38.54 69.2,39.07 65.81,39.07 65.03,39.85 v1(65.03,40.86)
N33941468: length 4.9
  TOP w0.107: PR725.1 67.26,32.72 v2(67.7,32.28)
  TOP w0.508: PR725.1 67.26,33.65 67.64,34.03 69.33,34.03 69.74,34.45 PQ701.4
N34055083: length 3.6
  BOTTOM w0.107: YG1.1 211.2,81.79 RG158.1 RG159.1 210.15,82.48 209.77,82.86 209.77,84 v2(209.76,84.01)
N35037011: length 4.6
  BOTTOM w0.107: v2(209.35,85.91) RG49.2 208.92,87.04 208.91,87.05 208.31,87.05 CG130.1 208.29,86.27 207.3,85.28 QG2.2
N35037016: length 21.6
  BOTTOM w0.107: RG51.1 210.77,87.5 210.77,90.37 210.56,90.58 210.37,90.58 207.57,93.38 205.31,93.38 204.32,92.39 200.44,92.39 200.2,92.14 200.2,90.87 v2(200.3,90.77) 200.36,90.71 202.38,90.71 CG131.1 202.03,90.02 QG4.2
N37147447: length 3.6
  BOTTOM w0.107: RG171.2 v2(208.07,116.85)
  BOTTOM w0.254: UG2.5 209.59,116.38 208.97,115.77 RG170.2 RG171.2
N39112837: length 2.7
  BOTTOM w0.089: U1.47 215.05,158.38 214.63,158.8 214.63,159.12 v3(214.45,159.3) 214,159.75 213.76,159.75 CV1058.1
N39112883: length 2.7
  BOTTOM w0.089: U1.48 214.96,158.78 214.84,158.9 214.84,159.21 214.09,159.97 213.86,159.97 CV1057.1
N39112974: length 2
  BOTTOM w0.089: CV1059.1 213.83,157.23 214.58,157.23 214.63,157.28 214.83,157.28 214.92,157.18 U1.44
N39113020: length 2
  BOTTOM w0.089: U1.45 214.92,157.58 214.83,157.49 214.54,157.49 214.49,157.45 213.82,157.45 CV1060.1
N39113066: length 2.5
  BOTTOM w0.089: U1.41 215.07,155.98 214.98,156.08 214.8,156.08 214.26,155.54 214.26,155.37 214,155.11 213.88,155.11 CV1061.1
N39113112: length 2.5
  BOTTOM w0.089: CV1062.1 213.78,155.33 213.92,155.33 214.04,155.46 214.04,155.63 214.71,156.29 215.02,156.29 215.11,156.38 U1.42
N39113201: length 2.4
  BOTTOM w0.089: U1.38 215.09,154.78 215.01,154.7 215.01,154.63 v3(214.47,154.09) 214.17,153.79 213.95,153.79 CV1063.1
N39113246: length 2.4
  BOTTOM w0.089: CV1064.1 213.76,154.01 214.08,154.01 214.79,154.72 214.79,154.79 215,155 215,155.01 215.17,155.18 U1.39
N39116567: length 3
  BOTTOM w0.107: U1.36 216.36,152.99 215.9,152.52 v2(215.17,152.52) 214.96,152.31 RV193.2
N39344573: length 3.3
  BOTTOM w0.107: U1302.2 217.69,148.47 RV1307.2 RV1309.1 217.72,146.55 v2(217.6,146.42)
N40160711: length 3.5
  BOTTOM w0.107: v2(202.96,107.89) R183.2 204.47,109.39 UG3.4
N40259586: length 11.6
  TOP w0.107: v2(198.04,170.02) 198.04,169.02 198.48,168.57 RT108.1 RT109.2 198.48,167.51 198.93,167.06 198.93,164.96 199.24,164.64 199.91,164.64 200.29,164.27 200.29,163.82 201.23,162.88 201.23,162.34 200.39,161.5 v1(200.39,161.08)
  BOTTOM w0.089: UT4.D6 200.66,161.34 v1(200.39,161.08)
N40301337: length 2.7
  BOTTOM w0.107: QG505.5 QG505.6 259.14,51.24 RG513.2 258.95,51.43 v2(258.1,51.43)
N40301360: length 2.6
  BOTTOM w0.107: v2(258.06,46.06) 257.7,46.41 RG514.2 257.84,47.38 QG505.3
N40305020: length 3.3
  BOTTOM w0.107: v2(261.97,52.81) RG515.2 261.97,50.5 QG507.6 QG507.5
N40305043: length 4.3
  BOTTOM w0.107: QG507.3 260.46,47.99 260.71,47.73 262.84,47.73 263,47.9 v2(263,48.04) RG516.2
N41521526: length 9
  TOP w0.107: v2(309.1,4.73) QE2.2 309.1,6.46 309.56,6.92 309.98,6.92 310.46,7.4 310.46,8.35 310.02,8.8 CE51.1 310.91,9.05 311.2,9.34 311.2,10.2 310.4,11 RE85.1
N44255477: length 3.6
  TOP w0.089: 233.8,80.96 233.8,80.53 RG5.1
  TOP w0.1: v1(234.42,83.05) 233.8,82.43 v2(233.8,81.44) 233.8,80.96
  BOTTOM w0.135: v1(234.42,83.05) 234.57,83.05 UG1.AW24
N44255479: length 5.1
  TOP w0.1: v1(234.42,83.95) 234.42,83.57 233.69,82.84 233.69,82.78 v2(233.61,82.71) 233.61,81.87 233.36,81.62 233.07,81.62 232.85,81.4 232.85,80.57 RG6.1
  BOTTOM w0.135: UG1.AV24 234.57,83.95 v1(234.42,83.95)
N44258253: length 1.7
  TOP w0.089: v1(228.57,90.2) 228.44,90.2 228.13,89.89 RG3.1
  BOTTOM w0.2: UG1.AK30 229.02,90.65 v1(228.57,90.2)
N44270546: length 3.1
  BOTTOM w0.107: UG1.AV43 217.16,85.76 RG23.1
N44270552: length 8.3
  BOTTOM w0.089: 215.65,83.92 v2(216.1,83.92)
  BOTTOM w0.1: UG1.AV41 219.21,84.09 216.4,84.09 216.23,83.92 v2(216.1,83.92)
  BOTTOM w0.107: RG22.2 213.62,85.5 214.07,85.06 214.39,85.06 215.54,83.92 215.65,83.92
N44285633: length 2
  TOP w0.089: RG43.1 245.04,103.37 v1(245.07,103.4) v2(245.45,103.78)
  BOTTOM w0.4: UG1.V14 245.07,103.25 v1(245.07,103.4)
N44433082: length 9.1
  IN1 w0.1: v1(241.62,83.05) 242.26,82.41 242.26,79.85 242.26,79.27 240.94,77.95 v1(240.08,77.95)
  BOTTOM w0.089: RG150.1 240.25,77.95 v1(240.08,77.95)
  BOTTOM w0.135: UG1.AW18 241.47,83.05 v1(241.62,83.05)
N44433084: length 14.2
  IN1 w0.1: v1(238.71,75.41) 239.49,76.19 239.49,78.18 240.14,78.84 240.42,78.84 240.8,79.22 240.8,82.35 240.47,82.68 240.27,82.68 240.05,82.9 240.05,84.1 240.37,84.42 240.67,84.42 240.8,84.55 240.8,85.17 v1(240.41,85.56)
  BOTTOM w0.107: RG151.1 238.71,76.19 v1(238.71,75.41)
  BOTTOM w0.135: v1(240.41,85.56) 240.26,85.56 UG1.AT19
N44433090: length 14.7
  IN1 w0.1: v1(241.63,83.95) 241.62,83.95 241.19,83.52 241.19,82.76 241.37,82.58 241.75,82.58 242.01,82.33 242.01,80.11 241.82,79.92 241.44,79.92 241.25,79.73 241.25,79.35 240.55,78.65 240.23,78.65 239.71,78.13 239.71,75.59 238.83,74.71 v1(238.71,74.71)
  BOTTOM w0.107: RG149.1 238.3,75.97 238.3,75.12 v1(238.71,74.71)
  BOTTOM w0.135: UG1.AV18 241.47,83.95 v1(241.63,83.95)
N44451988: length 1.9
  TOP w0.089: v1(234.42,87.15) 234.72,86.85 234.94,86.85 234.99,86.9 RG18.1
  BOTTOM w0.1: UG1.AP24 234.57,87.15 v1(234.42,87.15)
N44451992: length 2.3
  TOP w0.089: v1(234.54,86.48) 234.83,86.2 234.83,86.2 234.97,86.06 234.97,85.57 235.21,85.33 235.21,85.2 RG19.1
  BOTTOM w0.1: UG1.AR24 234.7,86.48 v1(234.54,86.48)
N44452100: length 5.7
  TOP w0.1: v1(234.42,82.2) 234.77,82.2 234.93,82.04 v2(234.93,79.34) 234.93,79.12
  TOP w0.107: 234.93,79.12 234.24,78.43 RG46.1
  BOTTOM w0.3: v1(234.42,82.2) 234.62,82.2 UG1.AY24
N44473342: length 2.8
  TOP w0.089: v2(224.76,84.83) 224.38,85.21 RG44.2 224,85.78 v1(223.63,85.41)
  BOTTOM w0.3: v1(223.63,85.41) UG1.AT36
N44473345: length 9.9
  IN2 w0.089: v1(223.63,83.97) 223.63,83.3 224.35,82.58 225.24,82.58 225.43,82.39 225.43,81.58 225.74,81.27 226.17,81.27 226.4,81.05 226.4,78.9 226.16,78.66
  IN2 w0.091: v1(225.9,78.2) 225.9,78.4 226.16,78.66
  BOTTOM w0.107: UG1.AV36 224.06,84.4 v1(223.63,83.97) ; v1(225.9,78.2) 226.07,78.04 RG45.2
N46084233: length 8.6
  BOTTOM w0.107: RX2.1 230.8,166.23 230.8,164.67 230.5,164.36 228.63,164.36 228.46,164.53 228.46,166.46 QX2.2 v2(227.83,168.18)
N72585933:
  vias: v2(98.18,34.32)
N121507165: length 4.3
  BOTTOM w0.076: CPU1.BR25 132.89,111.06 132.54,110.71 131.77,110.71 v2(130.98,109.92) 130.43,109.37 130.43,109.18 129.87,108.62 RH57.2
N121507167: length 4.4
  BOTTOM w0.076: RH58.2 130.41,110.37 131.51,111.47 133.18,111.47 133.59,111.06 CPU1.BP25
N121507169: length 5.3
  BOTTOM w0.076: CPU1.BT29 131.97,113.82 131.43,113.82 131.23,114.03 v2(130.88,114.03) 130.57,114.03 130.18,114.41 129.47,114.41
  BOTTOM w0.107: RH166.2 127.64,114.85 128.08,114.41 129.47,114.41
N124752685: length 2.1
  TOP w0.107: CH101.2 RH211.1 v2(154.45,55.65)
N124753277: length 1.8
  TOP w0.107: v2(154.44,36.61) RH212.1 CH100.2
N125073340: length 2
  BOTTOM w0.076: CPU1.A33 173.48,117.25
  BOTTOM w0.089: 173.48,117.25 174.98,117.25 T1.1
N198830997: length 1.7
  BOTTOM w0.107: RV23.2 190.77,112.94 UV21.48
N212152397: length 11.5
  BOTTOM w0.508: PR2.2 284.31,36.37 284.31,37.37 285.23,38.3 288.39,38.3 288.41,38.28 v2(288.76,38.28) 292.18,38.28 292.69,37.77 JRTC1.1
N213961754: length 5.9
  TOP w0.254: PC14.2 81.01,7.31 80.75,7.06 v2(79.96,7.06) 78.12,7.06 PR28.2 77.26,7.81 76.89,7.45 PQ8.2
N401547420: length 3.1
  BOTTOM w0.076: T64.1 197.25,159.62 197.25,160.43 197.46,160.64 197.51,160.64 197.69,160.82 198.51,160.82 198.66,160.67 UT4.B2
N401547610: length 2.2
  BOTTOM w0.076: UT4.E10 202.66,162.1 202.87,162.32 203.66,162.32
  BOTTOM w0.107: T121.1 204.47,162.55 204.21,162.3 203.67,162.3 203.66,162.32
N427456051: length 2.3
  BOTTOM w0.107: v2(286.2,65.5) 287.16,64.55 PC6017.2
  BOTTOM w0.254: PR6050.1 287.17,64.46 PC6017.2
N427458001: length 0.9
  BOTTOM w0.254: PR6077.1 PC6028.2
N429247870: length 1.6
  TOP w0.089: v1(229.62,88.75) 229.15,88.75 TV13.1
  BOTTOM w0.1: v1(229.62,88.75) 229.77,88.75 UG1.AM29
N429252370: length 1.7
  TOP w0.089: TV14.1 229.15,87.48 v1(229.62,87.95)
  BOTTOM w0.1: UG1.AN29 229.77,87.95 v1(229.62,87.95)
N429294591: length 4.9
  BOTTOM w0.107: v2(200.38,87.67) 202.05,87.67 QG4.1 203,85.69 202.87,85.57 RG48.2
N429942030: length 1.3
  BOTTOM w0.203: U17.10 65.09,12.43 65.2,12.32 C2507.1
N429942496: length 1.2
  BOTTOM w0.203: C2506.1 64.29,11.86 U17.12
N4015486424: length 4
  BOTTOM w0.076: 196.22,159.94 197.6,161.32 198.52,161.32 198.66,161.18 UT4.C2
  BOTTOM w0.109: T65.1 195.82,159.54 196.22,159.94
N4015486425: length 2.4
  TOP w0.107: v1(203.91,161.64) 203.62,161.93 203.49,161.93 T114.1
  BOTTOM w0.076: 203.59,161.64 203.56,161.64 203.39,161.82 202.88,161.82 202.66,161.6 UT4.D10
  BOTTOM w0.107: 203.59,161.64 v1(203.91,161.64)
N4015486426: length 1.5
  TOP w0.107: v1(203.78,163.17) 203.64,163.17 T120.1
  BOTTOM w0.089: 203.78,163.16 203.68,163.07 UT4.G11
  BOTTOM w0.107: v1(203.78,163.17) 203.78,163.16 203.78,163.16
N4015486429: length 2.8
  BOTTOM w0.076: UT4.G10 202.66,163.12 202.85,163.32 203.34,163.32 203.61,163.59 203.78,163.59
  BOTTOM w0.107: T122.1 204.87,163.96 204.49,163.59 203.78,163.59
N4015486430: length 1.1
  TOP w0.107: v1(200.98,161.07) 200.98,161.12 201.24,161.39 T70.1
  BOTTOM w0.107: UT4.D7 201.16,161.25 v1(200.98,161.07)
N4015486431: length 1.2
  TOP w0.107: v1(200.76,164.08) 200.76,164.66 T71.1
  BOTTOM w0.089: v1(200.76,164.08) 200.66,163.98 UT4.H6
N4015486463: length 2.2
  TOP w0.107: T62.1 200.33,162.36 v1(199.14,162.36)
  BOTTOM w0.089: v1(199.14,162.36) 199.35,162.57 UT4.F4
N4015486464: length 1.3
  TOP w0.107: v1(199.14,162.94) 199.65,163.45 T63.1
  BOTTOM w0.089: v1(199.14,162.94) 199.14,162.97 199.24,163.07 UT4.G4
N4274545242: length 2.2
  BOTTOM w0.203: PU8201.46 286.39,60.73 287.16,61.49 PR6047.1
N4274545247: length 2.9
  TOP w0.107: PR6072.1 286.34,51.45 v2(285.94,51.05)
  TOP w0.254: PR6072.1 286.34,52.56 v1(286.52,52.74)
  BOTTOM w0.203: v1(286.52,52.74) 286.52,52.8 286.39,52.93 PU8201.20

## Copper pours and planes (outline as drawn)
1.2V_B+ on TOP (solid shape): 93.04,36.53 93.04,33.05 93.16,32.93 93.42,32.93 93.54,32.8 93.54,31.92 93.52,31.91 90.39,31.91 89.93,32.36 88.46,32.36 87.77,33.05 87.77,33.81 87.32,34.26 87.32,35.34 87.45,35.47 89.16,35.47 89.73,36.04 89.73,37.3 89.87,37.44 92.13,37.44
3/5V_B+ on TOP (solid shape): outline of 205 points within 43.89,29.69 56.97,42.26
3/5V_B+ on BOTTOM (solid shape): 54.81,41.31 54.93,41.2 55.08,41.14 55.1,41.14 55.19,41.05 55.19,36.54 54.87,36.23 51.82,36.23 51.25,36.8 51.25,41.14 51.42,41.31
3VS on BOTTOM (solid shape): 69.63,14.34 69.63,12.92 69.07,12.92 69.07,12.36 69.63,12.36 69.63,12.12 69.07,12.12 69.07,11.58 69.63,11.58 69.63,11 69.52,10.89 66.99,10.89 66.47,11.41 65.9,11.41 65.69,11.61 65.69,12.18 65.39,12.49 65.39,13.38 65.45,13.44 66.02,13.44 66.28,13.7 66.28,14.4 66.42,14.54 69.43,14.54
5VS on BOTTOM (solid shape): 60.31,14.53 62.31,14.53 63.4,13.44 63.93,13.44 63.99,13.38 63.99,12.49 63.79,12.29 63.79,11.68 63.66,11.55 61.82,11.55 60.5,12.87 59.99,12.87 59.99,13.43 59.44,13.43 59.44,12.87 59.19,12.87 59.19,13.42 58.64,13.42 58.64,12.87 56.72,12.87 56.46,13.13 56.46,14.68 56.55,14.76 60.08,14.76
+0.6VS on TOP (solid shape): 179.9,52.48 179.9,50.51 179.43,50.04 179.43,47.88 179.08,47.53 178.44,47.53 178.06,47.91 178.06,50.51 178.25,50.71 178.51,50.71 178.7,50.9 178.7,52.42 178.95,52.67 179.71,52.67
+0.6VS on TOP (solid shape): 178.81,41.82 178.89,41.78 178.91,41.71 178.98,41.48 179.16,41.35 179.22,41.3 179.24,41.23 179.78,40.88 179.69,41.52 179.64,41.56 179.62,41.63 179.63,41.67 179.62,41.71 179.65,41.78 179.73,41.82 179.75,41.81 179.91,41.77 180.07,41.81 180.09,41.82 181.05,41.82 181.62,41.24 181.62,34.26 181.3,33.94 179.78,33.94 179.65,34.07 179.65,39.4 179.46,39.59 179.46,40.1 179.13,40.43 178.24,40.43 177.95,40.72 177.95,41.58 178.19,41.82
+0.6VS on BOTTOM (solid shape): 178.9,41.55 178.9,40.74 178.77,40.61 178.76,40.61 178.06,39.91 178.06,38.77 177.81,38.77 177.81,41.18 178.34,41.7 178.75,41.7
+0.6VS on BOTTOM (solid shape): 178.06,51.78 178.06,50.83 178.25,50.64 178.76,50.64 179.07,50.34 179.07,49.71 178.67,49.31 178.06,49.31 177.81,49.56 177.81,51.78 177.87,51.85 178,51.85
+0.6VS on BOTTOM (solid shape): 91.92,52.48 92.1,52.45 92.28,52.42 92.93,52.38 93.59,52.44 93.8,52.23 93.8,51.02 93.67,50.9 91.77,50.9 91.45,51.21 91.45,52.29 91.64,52.48
+0.6VS on IN2 (solid shape): 93.93,52.99 93.93,52.48 93.1,51.66 93.1,51.34 92.59,50.83 91.51,50.83 91.19,51.15 91.19,52.93 92.08,53.82 93.1,53.82
+0.6VS on IN2 (solid shape): 179.15,51.86 179.15,49.7 178.68,49.22 177.88,49.22 177.6,49.51 177.6,50.33 177.61,50.42 177.6,50.5 177.6,51.87 177.73,52 179.01,52
+0.6VS on IN4 (solid shape): outline of 297 points within 175.78,40 178.95,51.09
+0.6VSP on BOTTOM (solid shape): 92.88,50.2 93.32,50.2 93.32,50.73 93.77,50.73 93.86,50.64 93.86,49.18 93.29,48.61 92.21,48.61 91.83,48.23 91.83,46.64 91.95,46.52 91.95,46.51 92.36,46.09 92.36,45.13 92.34,45.1 92.24,45.1 92.16,45.18 92.16,45.98 91.88,46.26 91.27,46.26 90.88,45.86 90.88,45.1 91.07,44.91 91.51,44.91 91.56,44.86 91.56,44.71 91.51,44.66 90.7,44.66 90.31,45.05 90.31,46.44 90.37,46.5 90.37,46.51 90.69,46.83 90.69,50.58 90.84,50.73 92.88,50.73
+0.9V_CIO on TOP (solid shape): 180.14,164.01 180.33,163.9 180.52,164.01 180.79,164.01 180.84,163.95 180.91,163.91 180.96,163.9 181.1,163.76 181.1,163.42 180.99,163.31 180.28,163.31 180.15,163.18 179.71,163.18 179.55,163.02 179.52,162.99 179.46,162.93 179.24,162.93 179.21,162.98 179.17,163.01 179.13,163.04 179.06,163.06 179.04,163.09 179.03,163.25 178.94,163.39 178.92,163.4 178.92,163.46 178.95,163.5 179.01,163.56 179.13,163.56 179.14,163.55 179.35,163.48 179.56,163.55 179.58,163.56 180.03,164.01
+0.9V_CIO on BOTTOM (solid shape): 180.91,163.9 180.91,163.71 180.97,163.65 181.44,163.65 181.47,163.62 181.47,163.22 181.44,163.19 180.89,163.19 180.79,163.29 179.9,163.29 179.71,163.1 179.59,163.1 179.4,162.91 179.26,162.91 179.13,163.04 179.13,163.26 179.26,163.39 179.46,163.39 179.83,163.76 179.83,163.96 179.89,164.03 180.78,164.03
+0.9V_DP on TOP (solid shape): 179.14,165.53 179.14,164.45 179.05,164.36 179.03,164.36 178.9,164.32 178.82,164.21 178.81,164.2 178.63,164.2 178.54,164.29 178.51,164.32 178.2,164.63 178.2,164.78 178.39,164.97 178.39,165.24 178.24,165.4 178.24,165.48 178.29,165.53 178.32,165.56 178.47,165.71 178.47,165.82 178.62,165.98 178.69,165.98
+0.9V_DP on TOP (solid shape): 181.42,162.74 181.42,162.73 181.47,162.67 181.53,162.63 181.53,162.62 181.57,162.58 181.57,162.42 181.74,162.25 181.74,162.11 181.71,162.08 181.68,162.04 181.58,162.04 181.52,162.1 181.44,162.18 181.3,162.19 181.19,162.18 181.16,162.15 181.05,162.07 180.96,162.16 180.66,162.29 180.36,162.18 180.33,162.16 180.3,162.18 180.27,162.2 180.25,162.24 180.26,162.27 180.35,162.55 180.18,162.79 180.15,162.8 180.15,162.93 180.28,163.05 181.1,163.05
+0.9V_DP on BOTTOM (solid shape): 176.28,154.7 176.28,152.84 176.22,152.78 175.33,152.78 175.21,152.91 175.21,153.7 175.08,153.83 175.08,154.83 175.21,154.96 176.03,154.96
+0.9V_DP on BOTTOM (solid shape): 180.92,162.97 181.59,162.97 181.75,162.82 181.81,162.82 181.94,162.8 182.06,162.82 182.09,162.82 182.15,162.76 182.15,162.3 182.07,162.22 180.54,162.22 180.37,162.39 180.36,162.39 180.03,162.86 179.69,162.39 179.64,162.39 179.59,162.34 179.21,162.34 179.14,162.4 179.14,162.72 179.21,162.78 179.45,162.78 179.5,162.83 179.5,162.83 179.59,162.89 179.66,162.97 179.77,162.97 179.96,163.16 180.73,163.16
+0.9V_DP on BOTTOM (solid shape): 179.71,165.56 179.71,165.55 179.97,165.4 180.26,165.5 180.37,165.5 180.48,165.4 180.62,165.4 180.69,165.4 180.81,165.4 180.91,165.5 181.05,165.5 181.23,165.41 181.42,165.42 181.51,165.41 181.56,165.32 181.56,165.01 181.5,164.96 180.98,164.96 180.9,164.88 180.64,164.88 180.57,164.8 180.51,164.78 179.07,164.78 179.04,164.75 179.04,164.38 178.89,164.22 178.62,164.22 178.45,164.4 178.45,165.03 178.41,165.07 178.41,165.17 178.38,165.26 178.37,165.27 178.37,165.83 178.41,165.87 179.4,165.87
+0.9V_DP on IN2 (solid shape): outline of 559 points within 175.02,154.52 182.44,162.97
+0.9V_DP on IN3 (solid shape): outline of 93 points within 180.06,162.22 181.69,165.4
+0.9V_LVR_OUT on BOTTOM (solid shape): 183.78,169.07 183.78,168.04 183.75,168.02 183.65,167.94 183.58,167.83 183.58,167.82 183.56,167.8 183.56,167.45 183.65,167.35 183.65,166.44 183.35,166.15 182.95,166.15 182.95,166.33 182.95,166.37 182.94,166.41 182.94,166.82 182.95,166.91 182.94,167 182.94,167.23 182.27,167.23 181.7,166.66 181.63,166.63 181.56,166.66 181.26,166.76 180.99,166.58 180.93,166.51 180.93,165.7 180.76,165.53 180.53,165.53 180.36,165.7 180.36,165.81 180.35,165.85 180.35,166.86 180.88,166.86 180.88,167.28 180.95,167.35 181.22,167.35 181.3,167.35 181.37,167.35 181.88,167.35 181.96,167.35 182.12,167.35 182.38,167.62 182.38,168.42 182.38,168.42 182.38,169.07 182.44,169.13 183.71,169.13
+0.9V_PCIE on TOP (solid shape): 187.84,159.21 187.94,159.14 188.04,159.08 188.04,158.18 188.1,158.13 188.12,158.13 188.12,156.63 188.01,156.52 187.69,156.52 187.59,156.62 187.59,159.08 187.6,159.09 187.6,159.16 187.66,159.23 187.83,159.23
+0.9V_PCIE on TOP (solid shape): 183.66,165.53 183.9,165.42 184.15,165.53 184.31,165.53 184.35,165.5 184.35,165.39 184.29,165.33 184.24,165.26 184.15,165.17 184.15,165.03 183.99,164.87 183.99,164.68 183.99,164.67 184.01,164.66 184.13,164.54 184.14,164.38 184.37,164.15 184.37,164.09 184.33,164.05 184.29,164.01 183.52,164.01 183.46,164.06 182.95,164.58 182.26,164.58 182.25,164.61 181.96,164.79 181.67,164.62 181.61,164.61 181.55,164.64 181.49,164.7 181.49,165.1 181.52,165.18 181.59,165.2 181.7,165.21 181.8,165.28 182.11,165.28 182.28,165.2 182.45,165.28 182.5,165.28 182.57,165.34 182.65,165.37 182.72,165.33 182.87,165.21 183.05,165.23 183.07,165.25 183.25,165.42 183.27,165.43 183.39,165.45 183.5,165.53
+0.9V_PCIE on BOTTOM (solid shape): 183.59,165.32 184.1,165.32 184.16,165.26 184.16,164.37 184.2,164.33 184.2,164.18 184.26,164.12 184.67,164.12 184.79,163.99 184.79,163.61 184.73,163.54 184.22,163.54 184.16,163.61 184.16,163.93 184.04,164.04 183.52,164.04 183.46,164.1 183.38,164.14 183.37,164.14 183.33,164.18 183.02,164.18 182.92,164.28 182.92,164.77 182.86,164.83 181.86,164.83 181.75,164.94 181.75,165.26 181.87,165.39 183.52,165.39
+0.9V_PCIE on IN2 (solid shape): outline of 284 points within 181.24,156.35 189.81,165.57
+0.9V_SVR on TOP (solid shape): 180.11,166.15 180.1,166.04 180.12,166 180.12,165.81 180.24,165.68 180.19,165.63 180.18,165.63 180.05,165.51 180.05,165.3 180.22,165.13 180.22,164.98 180.13,164.88 180.1,164.75 180.11,164.72 180.03,164.64 179.58,164.64 179.52,164.7 179.52,166.17 179.58,166.23 180.03,166.23
+0.9V_SVR on TOP (solid shape): 181.36,168.59 181.55,168.4 181.55,168.28 181.68,168.15 181.73,168.09 181.8,168.05 181.83,168.01 181.96,168.01 182.44,167.53 182.44,167.31 182.33,167.2 180.34,167.2 180.22,167.33 180.22,167.45 180.31,167.58 180.33,167.74 180.33,167.77 180.36,167.8 180.41,167.82 180.44,167.83 180.52,167.9 180.56,168.01 180.56,168.03 180.73,168.2 180.85,168.2 181.25,168.59
+0.9V_SVR on BOTTOM (solid shape): 173.49,172.88 173.49,170.29 173.17,169.97 169.67,169.97 169.49,170.15 169.49,172.75 169.87,173.13 173.24,173.13
+0.9V_SVR on BOTTOM (solid shape): 179.44,169.97 179.44,169.53 179.53,169.45 181.56,169.45 181.56,169.45 181.73,169.45 181.78,169.4 181.78,168.66 181.63,168.18 182.11,168.02 182.21,168.02 182.25,167.93 182.25,167.67 182.06,167.48 180.55,167.48 180.43,167.6 180.43,168.5 180.17,168.75 179.84,168.75 179.61,168.53 179.61,168.44 179.58,168.41 179.21,168.41 179.03,168.59 179.03,169.96 179.05,169.98 179.43,169.98
+0.9V_SVR on IN1 (solid shape): outline of 206 points within 179.3,165.51 182.32,168.89
+0.9V_SVR on IN2 (solid shape): outline of 796 points within 171.52,167.42 184.03,174.33
+0.9V_USB on IN2 (solid shape): outline of 354 points within 182.38,156.5 187.39,163.35
+1.2V_DDR on TOP (solid shape): outline of 30116 points within 97.58,23.02 174.07,102.36
+1.2V_DDR on BOTTOM (solid shape): 129.36,98.11 129.36,96.14 129.07,95.84 128.4,95.84 128.3,95.94 128.3,96.74 128.46,96.9 128.46,98.13 128.54,98.21 129.26,98.21
+1.2V_DDR on BOTTOM (solid shape): outline of 84 points within 138.4,59.07 154.97,64.07
+1.2V_DDR on BOTTOM (solid shape): outline of 333 points within 98.56,24.8 110.88,41.37
+1.2V_DDR on IN2 (solid shape): outline of 430 points within 98.56,31.02 110.88,41.37
+1.2V_HDMI on BOTTOM (solid shape): 220.46,149.87 220.56,149.75 220.7,149.68 220.73,149.67 220.73,148.9 219.87,148.04 218.42,148.04 218.25,148.22 218.25,148.74 218.08,148.9 216.91,148.9 216.85,148.84 216.09,148.84 216.02,148.9 216.02,149.14 216.53,149.65 217.64,149.65 217.66,149.66 218.09,149.66 218.1,149.68 218.82,149.68 219.01,149.87
+1.2V_HDMI on IN2: 215.45,158.25 222.47,158.25 223.05,157.68 223.05,155.47 222.72,155.14 218.97,155.14 217.85,156.25 214.18,156.25 213.42,157.02 213.42,157.03 213.24,157.21 213.24,159.09 213.52,159.37 214.33,159.37
+1.2V_HDMI on IN4: 222.93,156.79 222.93,151.84 220.3,149.21 218.97,149.21 218.63,149.55 218.63,152.99 220.33,154.69 220.33,156.55 220.84,157.05 222.67,157.05
+1.2V_VCCPLL_OC on BOTTOM (solid shape): 130.41,102.35 130.41,101.95 130.28,101.82 129.64,101.82 129.29,101.46 129.29,99.71 129.14,99.56 128.63,99.56 128.5,99.69 128.5,102.35 128.73,102.58 130.18,102.58
+1.2V_VCCPLL_OC on IN4 (solid shape): outline of 1298 points within 137.08,99.48 169.75,103.54
+1.2VP on TOP (solid shape): 97.45,31.08 97.97,31.08 97.97,30.63 97.45,30.63 97.45,29.88 97.97,29.88 97.97,29.43 97.45,29.43 97.45,25.75 97.97,25.75 97.97,25.3 97.45,25.3 97.45,24.55 97.97,24.55 97.97,24.1 97.45,24.1 97.45,23.31 97.16,23.02 94.31,23.02 93.73,23.59 93.73,28.73 94.12,29.12 94.43,29.12 97.08,31.76 97.45,31.76
+1.2VP on BOTTOM (solid shape): outline of 328 points within 89.54,25.11 98.12,37.24
+1.5V_MEM_GFX on BOTTOM (solid shape): 256.82,148.64 257.57,148.64 257.57,149.18 260.93,149.18 260.93,148.62 261.68,148.62 261.68,149.17 262.14,149.17 262.14,148.62 262.88,148.62 262.88,149.17 263.6,149.17 263.85,148.91 263.85,148.36 264.73,147.48 264.73,145.51 264.33,145.12 256.08,145.12 254.83,146.36 254.83,148.93 255.09,149.18 255.63,149.18 255.63,148.63 256.37,148.63 256.37,149.19 256.82,149.19
+1.5V_MEM_GFX on IN1 (solid shape): outline of 17459 points within 221.02,82.3 252.77,114.85
+1.5V_MEM_GFX on IN2 (solid shape): outline of 5086 points within 203.15,120.17 215.48,145.86
+1.5V_MEM_GFX on IN2 (solid shape): outline of 64574 points within 216.66,69.06 285.89,147.42
+1.5V_MEM_GFX on IN4 (solid shape): outline of 4622 points within 238.66,85.97 273.57,105.44
+1.5V_MEM_GFX on VCC: 203.95,128.37 203.08,129.23 203.08,145.66 204.52,147.1 216.96,147.1 217.72,147.86 224.71,147.86 225.03,148.18 225.73,148.18 226.81,147.1 245.61,147.1 248.17,149.66 248.87,148.97 253.28,148.97 254.42,150.11 254.42,152.81 271.56,152.81 284.23,140.13 284.23,128.37
+1.5V_VGAP on BOTTOM (solid shape): outline of 167 points within 255.08,148.76 266.26,168.75
