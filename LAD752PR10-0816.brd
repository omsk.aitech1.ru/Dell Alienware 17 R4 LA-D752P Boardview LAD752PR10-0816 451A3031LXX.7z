# Allegro board LAD752PR10-0816.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
XDP_TDO: length 205.6
  TOP w0.089: v1(211.78,41.67) 211.77,41.67 v4(211.27,41.18)
  TOP w0.107: v1(121.85,159.99) 121.85,159.52 JPCMC.35
  IN2 w0.091: v1(203.27,57.12) 201.03,57.12 198.83,59.32 192.16,59.32 181.48,70 138.75,70 128.48,80.26 128.48,94.56 127.52,95.53 127.52,99.29 130.89,102.66 130.89,103.68 132.47,105.26 132.47,109.63 131.33,110.78 131.33,112.49 131.6,112.76 v1(131.6,113.42)
  IN3 w0.089: v1(211.78,41.67) 211.37,42.08
  IN3 w0.091: v1(203.27,57.12) 203.27,55.68 204.09,54.86 204.09,54.03 208.3,49.83 208.3,45.16 211.37,42.08
  IN4 w0.097: v1(131.6,113.42) 129.36,115.67 129.36,116.3 127.17,118.49 127.17,122.56 118.63,131.1 118.63,147.36 119.16,147.9 119.16,148.21 120.03,149.07 120.03,152.26 119.27,153.02 119.27,153.56 117.54,155.29 116.66,155.29 115.9,156.05 115.9,156.81 118.5,159.42 121.28,159.42 v1(121.85,159.99)
  BOTTOM w0.076: RH496.2 130.06,113.74 131.29,113.74 v1(131.6,113.42) CPU1.BT28
  BOTTOM w0.089: UH1.AP1 211.16,40.29 211.58,40.71 211.58,40.98
  BOTTOM w0.127: 211.58,40.98 211.78,41.18 211.78,41.67 v1(211.78,41.67)
XDP_TMS: length 295
  TOP w0.089: v4(130.82,114.01) 131.06,113.78 v1(131.06,113.38)
  TOP w0.107: JPCMC.30 v1(119.35,160.27)
  IN1 w0.097: v1(131.06,113.38) 131.06,114.76 131.58,115.29 131.58,115.98 130.44,117.13 130.44,121.57 129.8,122.21 129.8,124.02 129.35,124.46 129.35,125.8 126.07,129.08 120.75,129.08 118.1,131.74 118.1,146.95 120.91,149.76 121.29,149.76 121.75,150.22 122.25,150.22 122.89,150.86 122.89,151.93 124.71,153.75 124.71,158.42 123.84,159.28 120.33,159.28 v1(119.35,160.27) ; v1(213.96,42.38) 213.96,42.38 214.18,42.6 214.18,44.94 211.23,47.89 211.23,50.43 209.1,52.56 v1(209.1,53.74)
  IN3 w0.091: v1(113.77,36.61) 113.77,37.35 110.7,40.42 109.45,40.42 109.04,40.83 108.3,41.57 108.3,57.25 108.53,57.48 108.53,61.16 108.3,61.4 108.3,64.9 109.04,65.65 120.96,77.57 120.96,81.46 126.11,86.61 126.11,97.95 129.09,100.93 129.09,102.32 132.18,105.41 132.18,112.26 v1(131.06,113.38)
  IN4 w0.097: v1(113.77,36.61) 114.17,36.2 130.12,36.2 135.68,30.64 161.68,30.64 166.44,35.41 179.59,35.41 186.63,42.44 186.63,52.76 188.72,54.85 192.97,54.85 196.55,58.44 199.28,58.44 201.87,55.85 205.79,55.85 207.9,53.74 v1(209.1,53.74)
  BOTTOM w0.076: CPU1.BP28 133.32,113.76 132.79,113.76 132.67,113.63 132.67,113.32 132.43,113.08 132.09,113.08 131.9,112.89 131.55,112.89 v1(131.06,113.38)
  BOTTOM w0.089: v1(131.06,113.38) 130.59,112.91 RH494.2 ; UH1.AR2 211.79,39 211.79,40.16 212.4,40.77 212.4,40.92 213.19,41.71
  BOTTOM w0.127: 213.19,41.71 213.86,42.38 v1(213.96,42.38)
XMP1: length 169.4
  TOP w0.107: v1(97.51,45.27) 96.92,45.85 v2(96.92,46.2) 96.92,48.06 97.37,48.51 100.85,48.51 102.47,50.13 PR212.1
  IN2 w0.089: v1(216.95,29.08) 216.92,29.08 216.8,28.95 216.15,28.95 215.77,29.33 215.77,29.68 215.28,30.17 213.83,30.17 211.99,28.33 211.39,28.33 210.82,27.77 210.82,27.33 210.54,27.05 209.18,27.05 208.4,26.27 206.93,26.27 206.01,25.36 202.61,25.36 201.06,26.91 194.28,26.91 192.43,28.76 191.87,28.76
  IN2 w0.091: 191.87,28.76 189.62,28.76 188.21,30.17 177.53,30.17 168.73,21.37 137.26,21.37 137,21.11 134.2,21.11 133.94,21.37 120.3,21.37 118.56,19.63 103.14,19.63 102.68,19.17 100.3,19.17 v1(99.91,18.78)
  IN4 w0.097: v1(99.91,18.78) 100.35,19.22 101.15,19.22 101.98,20.05 101.98,23.01 103.14,24.17 103.14,29.65 102.03,30.76 102.03,34.07 99.92,36.17 99.92,42.75 97.51,45.17 v1(97.51,45.27)
  BOTTOM w0.089: v1(216.95,29.08) 216.85,28.98 216.2,28.98 UH1.BD22
XMP2: length 150
  TOP w0.107: PR214.1 105.13,55.57 v1(105.55,55.99) 105.18,56.36 v2(105,56.36)
  IN2 w0.089: 191.87,29.06 192.38,29.06 193.59,27.85 199.4,27.85 200.16,27.08 201.13,27.08 201.92,26.3 206.36,26.3 207.11,27.04 208.62,27.04 209.37,27.79 210.6,27.79 211.64,28.84 211.64,29.86 212.13,30.35 215.35,30.35 216.36,29.34 v1(216.42,29.34)
  IN2 w0.091: v1(135.77,21.58) 135.95,21.77 168.77,21.77 177.39,30.39 188.3,30.39 189.62,29.06 191.87,29.06
  IN3 w0.091: v1(135.77,21.58) 132.56,24.8 113.66,24.8 108.45,30 107.3,30 105.96,31.34 105.96,33.54 106.72,34.29 106.72,51.6 105.9,52.42 105.9,54.64 105.55,54.99 v1(105.55,55.99)
  BOTTOM w0.089: UH1.BE21 216.38,29.38 v1(216.42,29.34)
XTAL24_IN: length 10.6
  BOTTOM w0.089: UH1.A6 194.23,37.58 194.23,37.88 194.07,38.04 194.07,38.49 193.83,38.73 193.83,41.83 193.61,42.06 193.46,42.06 193.44,42.08
  BOTTOM w0.127: YH2.1 193.87,45.55 193.87,44.04 193.47,43.63 CH47.1 193.47,43.15 193.37,43.05 RH72.1 193.37,42.15 193.44,42.08
XTAL24_OUT: length 8.2
  BOTTOM w0.089: UH1.A5 194.53,37.56 194.42,37.66 194.42,38.01 194.26,38.17 194.26,38.55 194.01,38.81 194.01,41.83 194.23,42.06 194.23,42.08
  BOTTOM w0.127: 194.23,42.08 194.28,42.13 RH72.2 194.35,42.67 CH48.1 194.35,43.8 194.38,43.83 194.38,44.05 195.08,44.75 YH2.3
XTALIN: length 6
  BOTTOM w0.127: UG1.BA43 216.34,81.9 v2(215.91,82.33) 214.09,84.15 YG1.3
XTLI: length 3.9
  BOTTOM w0.127: UL1.8 237.09,156.51 237.26,156.68 237.26,157.34 237.73,157.8 CL8.2 237.73,158.68 YL1.1
XTLO: length 5.6
  BOTTOM w0.127: YL1.3 237.17,159.85 237.17,158.31 236.83,157.97 CL9.2 236.8,156.54 236.69,156.43 UL1.7
N4123408: length 1.2
  BOTTOM w0.107: PC105.2 v2(58.44,46.96)
N4123550: length 1.8
  TOP w0.107: PR110.2 v2(42.71,29.59)
N4123582: length 1.4
  TOP w0.107: v2(42.43,31.02) 42.62,31.22 PR111.2
N4124695: length 3.3
  BOTTOM w0.107: v2(47.72,46.66) 47.72,45.31 48.49,44.53 PR109.2
N16767833: length 7.3
  TOP w0.107: v2(63.89,44.93) 63.25,44.93 62.92,45.27 PR115.2
  TOP w0.254: PR115.2 PR113.2 62.15,45.51 PR116.1 61.65,46.64 PC112.1 61.64,47.27 PR112.2 PR100.2 59.65,47.27 PR114.2
N16767857: length 74.3
  TOP w0.508: v1(64.33,44.35) PR115.1
  IN3 w0.508: v1(54.49,16.73) 54.61,16.62 54.61,14.59 55.18,14.01 63.13,14.01 63.72,13.42 78.14,13.42 82.48,17.75 82.48,18.93 82.85,19.3 82.85,22 79.95,24.9 74.57,24.9 65.6,33.87 65.6,39.43 64.33,40.7 v1(64.33,44.35)
  BOTTOM w0.508: PD101.1 53.38,16.26 53.56,16.08 54.28,16.08 54.49,16.29 v1(54.49,16.73)
N16768121: length 3.1
  TOP w0.107: PR113.1 v2(61.91,43.28)
  TOP w0.254: PR113.1 61.4,44.35 61.16,44.59 61.16,44.99 60.91,45.24 PD100.1
N16788038: length 31.3
  TOP w0.508: PQ700.1 66.85,32.23 67.33,31.74 67.92,31.74 68.39,32.21 v1(68.4,32.21) 68.4,33.14 PR725.2 PC723.2 ; v1(60.46,32.42) 60.46,31.66 60.27,31.46 60.27,30.96 v2(59.6,30.29) 58.81,29.5 57.64,29.5 57.13,28.99 PC701.2 57.13,27.66 PR705.1
  IN3 w0.508: v1(68.4,32.21) 68.16,32.21 66.24,34.13 66.24,39.08 66.84,39.68 v1(67.92,39.68)
  BOTTOM w0.508: v1(60.46,32.42) 65.17,32.42 66.93,34.17 PQ702.4 67.62,34.17 68.4,33.4 v1(68.4,32.21)
N16788064: length 3.3
  TOP w0.254: PR700.2 63.35,31.67 PR701.1 v2(63.36,32.8) 63.43,32.88 PQ700.2
N16857461: length 2.8
  TOP w0.107: v2(187.71,70.83) 187.2,71.35 QS3.1 186.7,69.76 DS1.1
N17244731: length 258.8
  TOP w0.254: PD1.2 v1(268.93,35.34) 269.33,35.34 PR6.2 270.39,35.74 270.74,36.09 PQ7.1
  IN2 w0.091: v1(28.27,41.24) 30.77,41.24 36.05,46.52 52.81,46.52 53.61,47.32 55.81,47.32 55.82,47.34 57.29,47.34 58.09,46.54 91.7,46.54 92.42,45.82 93.29,45.82 93.34,45.78 95.8,45.78 95.97,45.95 97.79,45.95 98.86,44.88 105.87,44.88 109.48,41.28 110.87,41.28 113.02,39.13 173.11,39.13 174.12,38.11 180.26,38.11 184,41.85 197.67,41.85 198.7,42.87 201.01,42.87 201.69,43.55 207.13,43.55 207.22,43.64 212.35,43.64 213.02,42.96 213.36,42.96 213.61,43.21 214.31,43.21 214.5,43.03 222.28,43.03 222.99,42.32 226.95,42.32 227.31,41.96 232.68,41.96 234.21,40.44 256.63,40.44 257.42,41.22 262.12,41.22 268,35.34 v1(268.93,35.34)
  BOTTOM w0.254: PL2.1 28.83,40.49 28.27,41.05 v1(28.27,41.24)
N17431129: length 2.5
  TOP w0.107: RE89.1 302.13,27.69 CE36.1 303.2,27.76 v2(303.6,28.16)
N17434554: length 2.3
  TOP w0.107: UE5.107 308.19,13.81 RE74.2
N17761544: length 18.8
  TOP w0.254: v1(94.68,46.4) 94.82,46.4 v2(95.58,47.16) 97.24,48.81 100.11,48.81 100.91,49.61 v1(100.91,50.39) 100.91,50.67 PR213.1 ; v1(105.05,51.53) 104.87,51.35 PR215.1
  IN2 w0.254: v1(105.05,51.53) 103.09,51.53 101.95,50.39 v1(100.91,50.39)
  BOTTOM w0.203: PU201.6 94.48,44.8 94.68,45 v1(94.68,46.4) 95.02,46.73 PR207.1
  BOTTOM w0.254: PR207.1 PR205.1
N17847188: length 1.2
  TOP w0.254: PC800.2 199.41,74.53 v1(199.46,74.58)
  vias: v2(199.46,73.63)
N17847698: length 4.7
  TOP w0.107: v1(194.57,77.76) v2(193.94,77.76)
  TOP w0.254: PC803.1 v1(194.57,77.76)
  BOTTOM w0.254: v1(194.57,77.76) 195.72,77.76 195.97,77.5 PU800.16 195.97,76.65 196.07,76.55 196.29,76.55 196.42,76.68 PU800.17
N17848703: length 1.6
  BOTTOM w0.107: PR806.2 200.1,79.85 v2(200.86,80.61)
N17848716: length 2.9
  BOTTOM w0.254: PU800.1 199.1,76.45 v2(199.53,76.87) 199.59,76.93 PR806.1
N18168284: length 4.8
  BOTTOM w0.107: PR204.2 92.02,40.8 v2(91.07,39.85)
  BOTTOM w0.203: PR204.2 PC207.2 93.61,41.46 93.07,42 PU201.12
N18249914: length 4
  TOP w0.089: v1(203.63,25.89) 204,26.26 v2(204.03,26.26)
  TOP w0.508: CH3.1 204.16,23.58 RH6.2 204.16,25.11 203.63,25.64 v1(203.63,25.89)
  BOTTOM w0.127: UH1.V28 v1(203.63,25.89)
N18250394: length 4.3
  TOP w0.381: RH7.2 212.67,33.69 213.41,33.69 213.41,33.69 213.42,33.69 v1(213.95,33.15) 213.95,33.28 214.37,33.7 214.96,33.7 CH4.1
  BOTTOM w0.203: v1(213.95,33.15) 214.41,32.7 UH1.BA15
N18456729: length 1.6
  TOP w0.203: PR722.1 58.37,19.17 58.24,19.3 PU700.20
N18456733: length 1.8
  TOP w0.203: PU700.19 57.84,19.53 57.9,19.47 57.9,19.01 PR723.1
N18456739: length 4.1
  TOP w0.203: PR709.1 59.25,19.12 58.64,19.73 PU700.21
  TOP w0.254: PR709.1 PR711.1 60.62,18.11 PQ705.3
N18456772: length 4.4
  TOP w0.107: v1(60.46,24.23) v2(60.97,24.73)
  BOTTOM w0.508: v1(60.46,24.23) 60.33,24.1 60.33,23.15 PC711.2 60.84,22.26 61.73,21.37 PR707.2
N18456789: length 3.5
  BOTTOM w0.107: v2(63.51,18.96) 63.25,18.7 PR707.1
  BOTTOM w0.508: PR707.1 60.59,18.7 PD700.1
N18456799: length 1.7
  TOP w0.203: PR724.2 54.15,22.57 54.68,22.57 54.74,22.63 PU700.10
N18456859: length 1.2
  TOP w0.107: PR708.1 v2(62.81,20.48)
N18456884: length 6
  TOP w0.107: v2(51.95,25.31) 52.11,25.15 53.47,25.15 53.88,25.56
  TOP w0.203: PR717.2 53.88,24.7 PC718.2 54.76,24.69 54.94,24.86 55.97,24.86 56.24,24.59 PU700.7
N18456888: length 1.7
  TOP w0.203: PC720.2 54.61,23.8 54.98,23.43 PU700.8
N18456944: length 2.2
  TOP w0.107: PR710.2 v2(64.58,17.82)
  TOP w0.254: PQ705.1 63.38,18.76 63.64,18.51 PR710.2
N18456952: length 1.7
  TOP w0.114: PR720.2 54.3,22.01 54.53,22.23 PU700.11
N18456954: length 2.9
  TOP w0.107: v2(53.67,20.1) 53.84,20.27 PR721.2 54.55,21.83
  TOP w0.114: PU700.12 54.55,21.83
N18468008: length 8
  TOP w0.107: v1(220.34,39.32) 219.93,39.32 RH656.2 RH657.2
  BOTTOM w0.089: 218.89,39.08 219.18,39.37
  BOTTOM w0.107: UH1.BD7 216.12,36.79 216.53,36.79 217.05,37.31 217.81,37.31 217.94,37.43 217.94,38.13 218.89,39.08 ; 219.18,39.37 219.58,39.77 RH9.1 219.79,39.77 220.23,39.34 220.32,39.34 v1(220.34,39.32)
N18650921: length 7.4
  BOTTOM w0.107: UV21.59 186.19,110.91 185.69,110.41 v2(184.07,110.41) 183.65,109.99 183.65,108.41 183.19,107.95 183.19,106.86 183.27,106.78 RV634.2
N18651247: length 3.6
  BOTTOM w0.107: UV21.58 186.59,110.77 185.97,110.16 184.81,110.16 RV635.2
N18786622: length 1.3
  TOP w0.089: v1(131.84,93.76) 132.22,94.14 T44.1
  BOTTOM w0.076: CPU1.BT2 132.24,94.16 v1(131.84,93.76)
N18786625: length 4.3
  TOP w0.089: T43.1 133.17,94.27 131.92,93.02 v1(131.52,93.02)
  BOTTOM w0.076: v1(131.52,93.02) 131.67,93.17 132.2,93.17 132.61,93.59 CPU1.BR1
N18786626: length 1.8
  TOP w0.089: T41.1 170.49,94.78 v1(171.06,94.21)
  BOTTOM w0.076: v1(171.06,94.21) 171.06,94.27 170.51,94.82 CPU1.E3
N18786627: length 2.8
  TOP w0.089: v1(136.92,117.28) 137.3,116.9 137.3,115.22 T82.1
  BOTTOM w0.076: CPU1.BJ33 136.59,116.96 v1(136.92,117.28)
N18786629: length 5.3
  BOTTOM w0.127: CPU1.B2 172.32,92.83 174.94,90.21 T85.1
N18786630: length 8.2
  TOP w0.089: T88.1 134.76,93.95 133.49,93.95 132.03,92.49 131.22,92.49 v1(131.15,92.56)
  BOTTOM w0.076: v1(131.15,92.56) 132.21,92.56 132.75,93.1 133,93.1 133.29,93.39 133.29,94.06 CPU1.BR2
N18786631: length 4.4
  TOP w0.089: T81.1 136.03,114.68 136.53,115.19 136.53,117.55 v1(136.92,117.93)
  BOTTOM w0.076: v1(136.92,117.93) 136.59,117.61 CPU1.BJ34
N18786633: length 4.3
  BOTTOM w0.127: CPU1.C1 172.04,93.27 172.04,92.73 173.76,91.01 T89.1
N18786635: length 1.8
  TOP w0.089: T73.1 137.36,103.92 v1(137.36,103.48)
  BOTTOM w0.076: CPU1.BJ16 137.36,103.53 v1(137.36,103.48)
N18786636: length 1.2
  TOP w0.089: v1(135.91,104.37) 135.72,104.56 T74.1
  BOTTOM w0.076: CPU1.BK16 136.26,104.02 v1(135.91,104.37)
N18786637: length 1.2
  TOP w0.089: v1(135.88,109.87) 135.87,109.88 T75.1
  BOTTOM w0.076: CPU1.BK24 136.26,110.24 v1(135.88,109.87)
N18786638: length 1.4
  TOP w0.089: T76.1 137.04,109.61 v1(137.44,110.01)
  BOTTOM w0.076: CPU1.BJ24 137.18,110.27 v1(137.44,110.01)
N18786639: length 2.5
  TOP w0.089: T66.1 134.63,116.3 v1(134.63,116.97)
  BOTTOM w0.076: v1(134.63,116.97) 134.96,116.64 CPU1.BM33
N18786640: length 1.5
  TOP w0.089: T68.1 137.08,103.11 v1(137.42,102.77)
  BOTTOM w0.076: CPU1.BJ14 137.05,102.44 137.38,102.77 v1(137.42,102.77)
N18786641: length 2.6
  TOP w0.089: T69.1 137.51,102.34 v1(137.99,102.82)
  BOTTOM w0.076: CPU1.BJ13 136.86,101.92 137.36,102.41 137.58,102.41 v1(137.99,102.82)
N18786642: length 2.7
  TOP w0.089: T67.1 135.45,115.79 135.45,116.61 v1(136.13,117.28)
  BOTTOM w0.076: CPU1.BL33 135.81,116.96 v1(136.13,117.28)
N18786644: length 7.5
  TOP w0.089: RH192.2 173.72,110.11 v2(173.62,110.01) 173.31,109.7 169.13,109.7 v1(168.74,110.09)
  BOTTOM w0.076: v1(168.74,110.09) 168.11,110.09 CPU1.J23
N18786646: length 6.9
  TOP w0.089: RH167.2 174.35,109.16 174.2,109.32 173.62,109.32 173.23,108.93 v2(172.79,108.93) 169.14,108.93 v1(168.76,109.32)
  BOTTOM w0.076: CPU1.H23 168.38,109.69 v1(168.76,109.32)
N19064079: length 4.2
  BOTTOM w0.107: PR1300.2 96.7,49.61 v2(96.27,49.61)
  BOTTOM w0.254: PR1300.2 98.33,47.98 98.69,47.98 98.98,48.26 PU1300.1
N19066382: length 3.8
  BOTTOM w0.254: PU1300.7 100.25,42.17 PR1304.2 99.35,42.17 PR1305.1 99.35,41.73 99.51,41.56 PC1305.2
N19499560: length 0.9
  TOP w0.203: UA2.B3 22.05,27.2 22.04,27.2 CA51.2
N19499567: length 2.4
  TOP w0.107: RA46.2 23.85,29.6 v2(23.63,29.81)
  TOP w0.203: RA46.2 23.02,28.86 22.88,28.73 UA2.A1
N19499569: length 1.9
  TOP w0.107: RA47.2 v2(23.57,26.8)
  TOP w0.203: UA2.A3 22.55,27.34 22.68,27.21 RA47.2
N19500898: length 0.8
  TOP w0.203: UA3.A3 19.92,22.03 RA39.2
N19500900: length 4.9
  TOP w0.203: UA3.A1 20.02,23.2 20.75,22.47 20.75,21.71 21.17,21.29 v2(21.17,20.97) 21.41,20.73 RA38.2
N19500925: length 2.4
  TOP w0.107: CA44.2 17.9,22.67 17.9,22.34 v2(17.62,22.07)
  TOP w0.203: UA3.B3 18.87,22.2 18.21,22.87 CA44.2
N19501351: length 1.2
  BOTTOM w0.107: CA18.1 36.11,24.48 RA10.2
N19501355: length 2.4
  TOP w0.107: CA11.1 38.5,27.37 v1(38.15,27.02) 37.6,27.02 v2(37.51,26.92)
  BOTTOM w0.107: RA2.2 38.39,27.26 v1(38.15,27.02)
N19501476: length 3.8
  BOTTOM w0.203: 29.44,25.93 29.44,25.98 30.02,26.55 UA1.27
  BOTTOM w0.254: 29.44,25.93 29.33,25.82 29.33,24.47 30.06,23.74 CA21.1
N19501478: length 3.8
  BOTTOM w0.203: 28.65,25.65 29.62,26.61 UA1.28
  BOTTOM w0.254: 28.65,25.65 v2(28.65,24.68) 28.65,24.21 CA21.2
N19501482: length 2.4
  BOTTOM w0.203: CA20.1 30.36,25.25 30.36,25.88 30.82,26.33 UA1.25
N19501484: length 2.3
  BOTTOM w0.203: 30.06,26.09 30.42,26.44 UA1.26
  BOTTOM w0.254: 30.06,26.09 29.84,25.87 v2(29.84,25.81) CA20.2
N19501519: length 3.9
  TOP w0.107: v1(34.07,25.96) 34.07,26.52 v2(33.96,26.64)
  TOP w0.254: CA85.1 33.99,24.99 CA23.1 33.98,25.59 34.07,25.68 v1(34.07,25.96)
  BOTTOM w0.107: UA1.18 33.62,26.61 34.07,26.15 v1(34.07,25.96)
N19501610: length 3.7
  BOTTOM w0.107: RA18.2 36.88,25.36 35.89,26.35 35.29,26.35 35.23,26.29 34.74,26.29 34.42,26.61 UA1.16
N19501675: length 5.1
  BOTTOM w0.107: UA1.46 30.82,35.71 CA4.1 30.81,36.06 30.56,36.3 CA3.1 30.56,37.17 RA68.1
N19501723: length 5.3
  TOP w0.107: RA69.1 CA7.1 33.12,36.55 CA8.1 33.12,35.63 v1(32.41,34.92) 31.99,34.5 v2(31.67,34.5)
  BOTTOM w0.107: v1(32.41,34.92) 32.43,34.92 32.82,34.53 UA1.51
N19501777: length 5.4
  BOTTOM w0.107: v2(26.41,35.61) 26.41,35.24 26.67,34.98 26.74,34.98 27.22,34.51 CA26.1
  BOTTOM w0.203: UA1.43 29.62,34.38 29.49,34.51 28.85,34.51
  BOTTOM w0.254: CA27.1 CA26.1 27.83,34.51 28.09,34.25 28.6,34.25 28.85,34.51
N19501783: length 1.9
  BOTTOM w0.203: 28.17,32.71 UA1.41
  BOTTOM w0.254: 28.17,32.71 28,32.89 27.33,32.89 CA33.1
N19501785: length 4.4
  TOP w0.107: v1(32.6,25.55) 32.14,26.01 v2(32.14,26.32)
  TOP w0.254: CA30.1 31.69,24.93 31.77,24.86 CA31.1 32.28,25.24 v1(32.6,25.55)
  BOTTOM w0.203: v1(32.6,25.55) 32.35,25.81 32.35,26.32 32.42,26.39 UA1.21
N19501806: length 4.3
  TOP w0.107: v2(27.54,34.16) 28.14,34.76 v1(28.34,34.76)
  TOP w0.254: v1(28.34,34.76) CA32.1
  BOTTOM w0.203: UA1.44 30.02,34.49 29.55,34.95 28.53,34.95 v1(28.34,34.76)
N19501856: length 3.6
  TOP w0.107: v2(29.56,26.65) CA25.1
  TOP w0.254: v1(27.76,26.88) 27.8,26.88 28.03,26.65 CA25.1
  BOTTOM w0.203: v1(27.76,26.88) 28.02,26.88 28.29,27.15 28.29,27.78 28.41,27.91 UA1.29
N19501872: length 4.3
  TOP w0.107: v1(27.44,28.16) 26.93,28.16 v2(26.55,28.54)
  TOP w0.254: v1(27.44,28.16) 27.63,28.16 28.01,28.54 28.01,28.86 28.47,29.32 CA24.1
  BOTTOM w0.203: UA1.31 28.17,28.71 27.62,28.16 v1(27.44,28.16)
N19501885: length 9.3
  TOP w0.508: CA19.2 31.84,21.3 v2(30.87,22.27) 30.87,23.28 30.27,23.87 30.27,26 30.63,26.36 31.27,26.36 31.56,26.06 v1(31.56,25.62)
  BOTTOM w0.203: v1(31.56,25.62) 31.62,25.68 UA1.23
N19501890: length 3.2
  TOP w0.107: v2(33.03,22.32) 33.36,21.99 CA19.1
  TOP w0.254: RA15.2 RA16.1 33.94,21.88 CA19.1
N19529476: length 2.8
  TOP w0.203: UA4.23 33.45,14.12 v1(33.32,14.25)
  BOTTOM w0.107: v2(32.71,14.51) 32.71,14.38 32.84,14.25 v1(33.32,14.25)
  BOTTOM w0.457: v1(33.32,14.25) 33.32,14.56 33.78,15.01 CA74.1
N19529515: length 1.8
  TOP w0.107: CA66.2 29.19,8.1 29.28,8.01 UA4.40
N19529521: length 4.2
  TOP w0.107: v2(38.77,8.34) 38.45,8.01 UA4.3 37.11,8.01 36.72,8.41 v1(36.72,8.54)
  BOTTOM w0.107: RA51.2 37.53,8.82 CA71.2 36.91,8.74 36.71,8.54 36.71,8.54 v1(36.72,8.54)
N19529522: length 4.4
  TOP w0.107: v1(36.71,9.94) 36.78,9.87 36.78,9.7 37.26,9.21 UA4.6
  BOTTOM w0.107: v1(36.71,9.94) 36.71,10.31 36.94,10.53 RA51.1 37.6,10.6 RA52.1 v2(36.57,11.3)
N19529526:
  vias: v1(39.7,8.8) v1(40.29,8.8) v2(40.23,8.24)
N19529531: length 3.5
  TOP w0.107: UA4.5 37.14,8.81 36.77,9.18 v1(36.72,9.18)
  BOTTOM w0.107: RA62.2 36.71,7.84 v2(36.27,8.29) 36.27,8.67 36.72,9.12 v1(36.72,9.18)
N19942790: length 7.6
  TOP w0.107: v2(27.15,44.46) UU5.2
  TOP w0.381: UU5.2 31.43,44.46 CU27.1
  TOP w0.508: DU8.2 33.76,43.49 RU5.2 32.39,43.49 CU27.1
N19950372: length 3.1
  TOP w0.107: UU1.16 19.73,43.83 RU3.2 19.3,43.52 18.42,42.64 v2(18.42,42.45)
N19950378: length 3
  TOP w0.107: v2(18.3,43.72) 18.3,43.91 18.77,44.38 RU2.2 19.46,44.33 UU1.15
N19950402: length 2.5
  TOP w0.107: v2(25.35,44.73) 25.35,45.56 RU7.2 24.77,45.66 24.44,45.33 UU1.8
N19950406: length 3.7
  TOP w0.107: v2(25.31,42.2) 24,42.2 23.47,41.66 RU1.2 23.08,41.98 UU1.4
N20474318: length 2.1
  TOP w0.107: RA76.1 30.56,1.04 29.4,1.04 v2(29.23,1.2)
N20474320: length 1.9
  BOTTOM w0.107: RA75.1 v2(33.73,3.51)
  BOTTOM w0.254: RA75.1 34.03,2.52 v1(34.46,2.1)
N20474322: length 1.2
  TOP w0.107: v2(34.86,1.11) 34.93,1.18 35.12,1.18 35.57,1.62 RA74.1
N20474324: length 1.6
  BOTTOM w0.107: v2(40.17,3.8) 40.52,4.15 40.52,4.78 RA73.1
N20758419: length 1.5
  TOP w0.089: RH580.1 206.64,35.76 v1(206.84,35.57)
  BOTTOM w0.089: v1(206.84,35.57) 206.84,35.41 206.68,35.25 UH1.AD10
N20758429: length 3.6
  BOTTOM w0.089: 207.16,41.82 207.16,41.49 207.32,41.33 207.32,41.1 207.47,40.95 207.47,40.5 207.6,40.37 207.6,39.31 207.75,39.16 UH1.AG2
  BOTTOM w0.127: 207.16,41.82 RH581.1
N20762834: length 5.9
  BOTTOM w0.089: UH1.BC17 215.59,31.48 215.87,31.76 216.05,31.76 216.19,31.62 217.47,31.62 217.86,31.22 217.86,30.78 v2(218.7,29.94) 218.71,29.93 218.71,29.5
  BOTTOM w0.127: RH89.2 219.17,29.04 218.71,29.5
N20904379: length 2.9
  BOTTOM w0.107: UT4.A7 UT4.A6 ; UT4.A7 UT4.B7 ; UT4.A7 UT4.A8 201.66,159.42 201.56,159.32 RT22.1
N20905578: length 4.2
  TOP w0.107: v1(201.41,164.09) 202.32,165 202.32,166.15 202.64,166.47 v1(202.64,166.62)
  BOTTOM w0.076: v1(201.41,164.09) 201.16,163.83 UT4.H7
  BOTTOM w0.127: v1(202.64,166.62) 202.63,166.63 CT104.1
N20905857: length 2.7
  TOP w0.107: RT83.2 197.43,163.09 v1(197,162.65)
  BOTTOM w0.076: UT4.F1 197.9,162.82 197.56,162.82 197.56,162.82 197.16,162.82
  BOTTOM w0.089: v1(197,162.65) v2(196.48,162.65)
  BOTTOM w0.127: 197.16,162.82 v1(197,162.65)
N20960158: length 1.7
  TOP w0.107: QE53.5 230.2,31.27 230.54,30.93 RE527.1 RE528.2
N20960615: length 3.2
  TOP w0.107: QE54.2 225.29,25.38 225.54,25.14 RE449.2 RE511.1
N20960628: length 1.7
  BOTTOM w0.107: RE455.2 RE456.1 230.54,21.9 230.2,21.56 QE39.5
N20960654: length 2.7
  BOTTOM w0.107: QE29.5 236.1,31.27 236.44,31.62 RE397.1 RE396.2 236.89,30.93 237.12,30.7 v2(237.63,30.7)
N20960689: length 3.4
  BOTTOM w0.107: v2(232.34,29.66) 232.65,29.97 232.65,30.72 232.86,30.93 RE401.1 RE399.2 233.36,31.62 233.7,31.27 QE29.2
N20960760: length 1.7
  BOTTOM w0.107: QE39.2 227.72,21.56 227.38,21.22 227.15,21.22 RE453.1 RE454.2
N20960779: length 2.7
  TOP w0.107: v2(231.81,25.14) RE513.2 RE512.1 230.54,24.45 230.2,24.8 QE49.5
N20960882: length 2.8
  TOP w0.107: RE511.2 227.36,23.65 227.85,23.65 228.02,23.82 QE49.3 227.66,24.15 227.53,24.27 227.53,24.67 227.66,24.8 QE49.2
N20960884: length 1.7
  BOTTOM w0.107: RE460.2 RE458.1 227.15,24.45 227.38,24.45 227.72,24.8 QE40.2
N20960892: length 1.7
  BOTTOM w0.107: RE461.2 RE462.1 230.54,25.14 230.2,24.8 QE40.5
N20960976: length 2.8
  BOTTOM w0.107: RE467.2 RE465.1 ; RE465.1 226.42,27.76 v2(226.2,27.53) ; RE465.1 227.15,27.69 227.38,27.69 227.72,28.04 QE41.2
N20960982: length 1.7
  BOTTOM w0.107: QE41.5 230.2,28.04 230.54,28.38 RE468.1 RE466.2
N20960988: length 3.8
  TOP w0.107: QE54.5 225.29,23.49 225.07,23.27 224.29,23.27 224.1,23.46 224.1,23.91 223.68,24.33 RE514.1 RE517.2
N20961029: length 3.1
  TOP w0.107: QE50.5 225.29,21.07 225.01,21.34 RE515.1 RE516.2
N20961045: length 3.4
  TOP w0.107: QE50.2 225.29,22.24 225.12,22.07 224.74,22.07 224.64,22.16 QE50.3 224.64,22.85 224.54,22.96 224.19,22.96 RE514.2
N20961145: length 4
  BOTTOM w0.107: v2(227.34,33.56) 227.55,33.34 227.55,31.79 227.38,31.62 RE474.2 RE472.1 227.15,30.93 227.38,30.93 227.72,31.27 QE42.2
N20961166: length 2.7
  BOTTOM w0.107: QE42.5 230.2,31.27 230.54,31.62 RE473.1 RE471.2 v2(231.78,30.93)
N20961197: length 1.7
  BOTTOM w0.107: QE43.2 233.6,28.38 RE480.2 RE479.1
N20961228: length 2.6
  BOTTOM w0.107: QE43.5 236.1,28.04 236.44,28.38 RE478.1 RE476.2 v2(237.65,27.69)
N20961244: length 3
  TOP w0.107: QE55.2 225.29,28.65 225.4,28.54 225.67,28.54 225.83,28.38 RE521.2 RE518.1
N20961277: length 1.7
  TOP w0.107: QE51.5 230.2,28.04 230.54,27.69 RE519.1 RE520.2
N20961293: length 2.2
  TOP w0.107: RE518.2 227.43,27.11 227.7,27.39 QE51.3 228.27,27.39 228.37,27.49 228.37,27.93 228.27,28.04 QE51.2
N20961336: length 10.6
  TOP w0.107: RE525.2 RE522.1 v1(226.58,21.22) ; v1(225.52,28.04) 225.29,27.81 QE55.5
  IN1 w0.097: v1(226.58,21.22) 226.58,25.75 225.52,26.81 v1(225.52,28.04)
  BOTTOM w0.107: v1(225.52,28.04) 225.52,28.78 v2(225.75,29.01)
N20961369: length 2.7
  TOP w0.107: QE52.5 230.32,21.56 230.67,21.22 RE523.1 RE524.2 v2(231.81,21.9)
N20961391: length 2.6
  TOP w0.107: QE52.2 QE52.3 227.74,20.63 RE522.2 227.15,19.72 v2(227.08,19.65)
N20961418: length 1.7
  BOTTOM w0.107: RE486.2 RE485.1 233.6,24.45 QE44.2
N20961454: length 2.6
  BOTTOM w0.107: v2(237.63,24.45) RE482.2 RE484.1 236.44,25.14 236.1,24.8 QE44.5
N20961510: length 1.7
  BOTTOM w0.107: RE492.2 RE491.1 233.6,21.22 QE45.2
N20961531: length 2.6
  BOTTOM w0.107: v2(237.63,21.22) RE488.2 RE490.1 236.56,21.9 236.22,21.56 QE45.5
N20961580: length 2.6
  TOP w0.107: v2(237.56,31.72) 236.84,31.72 RE498.2 RE496.1 236.42,30.93 236.08,31.27 QE46.2
N20961592: length 1.7
  TOP w0.107: QE46.5 233.66,31.27 233.32,31.62 RE497.1 RE495.2
N20961638: length 5.9
  TOP w0.107: QE56.2 223.89,31.61 223.91,31.59 223.91,31.53 224.29,31.15 224.54,31.15 225.18,30.51 225.68,30.51 225.95,30.78 225.95,31.28 v2(226.13,31.46) 226.61,31.46 RE526.1 RE529.2
N20961685: length 3.8
  TOP w0.107: QE53.2 228.35,31.27 228.56,31.07 228.56,30.71 228.47,30.62 QE53.3 227.77,30.62 227.49,30.35 RE526.2 226.23,30.35 v2(226,30.12)
N20961740: length 1.7
  TOP w0.107: QE47.2 236.14,28.04 236.48,27.69 RE501.1 RE503.2
N20961750: length 1.7
  TOP w0.107: QE47.5 233.66,28.04 233.32,28.38 RE504.1 RE502.2
N20961813: length 1.7
  TOP w0.107: QE48.2 236.2,24.8 236.55,24.45 236.67,24.45 RE508.1 RE510.2
N20961825: length 1.7
  TOP w0.107: QE48.5 233.6,24.8 233.26,25.14 RE509.1 RE507.2
N20971521: length 7.1
  TOP w0.107: JLAN.9 245,170.67 244.46,170.13 v2(244.46,168.62) 244.46,168.1 242.77,166.4 RL8.1
N20971565: length 2.9
  BOTTOM w0.107: UL2.3 227.57,148.34 227.28,148.05 227.28,147.16 RL5.1 228.18,147.15 v2(228.35,146.97)
N20971567: length 9.9
  TOP w0.107: JLAN.12 260.86,170.67 261.37,170.15 261.37,167.93 v2(261.25,167.8) 261.12,167.67 261.12,167.05 CL31.1 261.5,165.91 261.5,164.58 260.74,163.82 LL1.2
N20972379: length 3
  BOTTOM w0.107: RL2.2 235.16,157.79 235.44,157.51 235.89,157.51 UL1.5
N20972746: length 4.3
  TOP w0.107: QL3.1 260.04,161.07 259.28,161.83 258.71,161.83 v2(258.5,162.03) RL14.2 258.52,163.11 RL13.2
N20986399: length 7.9
  TOP w0.107: UE12.3 147.38,165.49 v1(147.31,165.42) ; RE161.1 152.47,164.88 v1(152.41,164.94)
  IN3 w0.091: v1(152.41,164.94) 152.31,165.04 149.74,165.04 149.59,164.89 147.89,164.89 147.36,165.42 v1(147.31,165.42)
  BOTTOM w0.107: v2(148.07,165.7) 147.79,165.42 v1(147.31,165.42)
N20995131: length 2.8
  TOP w0.107: v2(221.9,152.69) RE25.2 220.31,152.93 UE3.24
N20995135: length 3.4
  TOP w0.107: RE31.1 223.16,156.76 222.46,156.06 v2(222.23,156.06) 222,156.06 221.76,156.31 221.76,157.11 221.54,157.33 UE3.30
N20999302: length 2.5
  BOTTOM w0.107: RM72.1 125.77,159.07 v2(125.77,159.07) 125.77,158.72 126.31,158.18 UM8.27
N20999314: length 1.8
  BOTTOM w0.107: RM61.2 137.85,155.18 UM8.52
N20999316: length 2.4
  BOTTOM w0.107: UM8.48 138.17,157.18 RM64.1 RM66.1
N21000707: length 4.7
  BOTTOM w0.107: v2(170.79,150.45) 170.79,151.84 170.3,152.32 RM96.2 RM21.2 171.26,152.79 171.19,152.86 UM4.1
N21000709: length 3.8
  BOTTOM w0.107: RM28.1 166.4,162.5 165.65,162.5 165.48,162.34 164.78,162.34 RM29.1 CM99.1
N21000711: length 4.7
  BOTTOM w0.107: RM27.1 167.06,162.74 165.55,162.74 165.39,162.58 164.58,162.58 164.14,163.01 RM38.1 CM98.1
N21000719: length 5.6
  BOTTOM w0.107: UM4.20 171.19,160.54 171.49,160.85 172.03,160.85 v2(172.53,161.35) 172.63,161.35 172.74,161.24 172.74,160.65 CM17.1 CM16.1 RM18.2
N21000750: length 1.7
  BOTTOM w0.107: RM25.2 169.89,161.45 UM4.18
N21000786: length 1.6
  BOTTOM w0.107: RM28.2 166.63,160.95 166.64,160.95 UM4.13
N21000788: length 1.7
  BOTTOM w0.107: UM4.14 167.29,160.77 167.45,160.93 167.45,161.28 RM27.2
N21000830: length 7.5
  BOTTOM w0.107: QM2.6 149.35,166.42 148.52,167.24 v2(148.47,167.24) 147.34,167.24 146.06,165.96 QM1.2 145.77,165.37 146.07,165.07 147.1,165.07 147.46,164.71 RM92.2
N21000850: length 7.5
  BOTTOM w0.107: QM3.2 153.22,164.87 152.54,164.18 151.41,164.18 150.91,163.68 RM94.2 ; QM3.2 153.01,165.79 152.57,165.36 152.13,165.36 151.89,165.12 QM2.3 ; QM3.2 v2(153.22,167.57)
N21000877: length 3.8
  BOTTOM w0.107: v2(168.86,150.46) 168.86,151.73 169.35,152.23 RM20.2 169.35,152.95 169.24,153.07 UM4.4
N21002214: length 2.6
  BOTTOM w0.107: RE14.2 104.59,15.77 v2(104.36,15.54) 104.15,15.54 103.67,16.02 UE2.3
N21002223: length 7.3
  BOTTOM w0.107: RE11.1 95.35,10.85 95.35,12.5 CE20.1 94.13,13.72 94.13,15.32 v2(94.31,15.5) 94.83,16.02 UE2.6
N21002224: length 3.9
  BOTTOM w0.107: UE2.5 94.82,14.75 94.47,14.41 v2(94.47,14.09) 94.47,13.86 94.85,13.48 95.47,13.48 RE9.1
N21002246: length 5.5
  BOTTOM w0.107: RE13.2 95.83,19.16 94.83,19.16 94.31,18.64 v2(94.31,18.07) 94.31,17.81 94.83,17.29 UE2.7
N21002311: length 3
  TOP w0.107: v2(315.98,20.16) 316.51,19.64 RE651.1 317,19.57 UE1.20
N21002312: length 3
  TOP w0.107: UE1.19 317.8,19.37 CE9.1 318.77,19.64 v2(319.06,19.94)
N21002317: length 2
  TOP w0.107: UE1.11 322,12.33 322.3,12.03 CE18.1
N21002319: length 1.9
  TOP w0.107: CE17.1 322.2,12.92 321.99,13.13 UE1.12
N21002321: length 1.9
  TOP w0.107: UE1.13 322.21,13.93 322.33,13.81 CE16.1
N21002324: length 1.8
  TOP w0.107: CE15.1 322.68,14.73 UE1.14
N21002326: length 1.8
  TOP w0.107: UE1.15 322.71,15.53 CE14.1
N21002328: length 3.1
  TOP w0.107: UE1.16 322.61,16.33 CE13.1 322.75,17.39 v2(322.53,17.62)
N21002352: length 7.8
  BOTTOM w0.107: UE2.2 101.19,17.29 99.51,15.61 v2(99.51,13.05) 99.4,12.94 RE10.1
N21002366: length 6.1
  TOP w0.107: v2(317.06,22.07) DE1.2 315.6,20.21 RE8.2 315.1,19.27 314.6,18.77 UE1.23
N21002397: length 6.7
  BOTTOM w0.107: v2(94.35,19.44) 95.62,19.44 95.91,19.73 RE20.1 96.4,20.61 96.59,20.8 99.32,20.8 99.48,20.95 UE9.3
N21003330: length 2.6
  BOTTOM w0.107: U2407.7 186.7,47.36 R181.2 v2(187.75,45.78)
N21003701: length 5.8
  TOP w0.254: RF3.1 105.03,58.37 103.7,59.69 DF1.1 103.7,61.29 v2(103.9,61.48) 104.37,61.95 JFAN1.3
N21003743: length 12.1
  TOP w0.107: DF2.1 292.45,73.53 RF6.1 292.42,74 v2(292.42,75.77) 292.42,78.1 291.72,78.81 289.11,78.81 288.37,78.07 JFAN2.3
N21014812: length 2.7
  BOTTOM w0.107: v2(128.04,102.71) C3.1
  BOTTOM w0.127: C3.1 128.1,101.42 UZ21.6
N21181966: length 9.9
  TOP w0.089: 172.12,101.84 169.14,101.84 v1(168.78,101.47)
  TOP w0.102: 172.12,101.84 172.29,102 172.29,102.79 172.39,102.89 172.6,102.89 172.7,102.79 172.7,102 172.8,101.9 173,101.9 173.1,102 v4(173.1,102.39) 173.1,102.79 173.21,102.89 173.41,102.89 173.51,102.79 173.51,101.8 173.66,101.64 RH154.2
  BOTTOM w0.076: v1(168.78,101.47) 168.41,101.84 CPU1.H13
N21181987: length 17.1
  IN4 w0.097: v1(128.34,119.48) 131.7,119.48 133.04,118.14 133.04,115.75 134.23,114.56 136.46,114.56 136.92,115.02 v1(136.92,115.92)
  BOTTOM w0.076: v1(136.92,115.92) 137.17,115.66 CPU1.BH31
  BOTTOM w0.107: RH153.2 126.73,119.46 126.84,119.35 128.22,119.35 v1(128.34,119.48) 128.85,119.98 v2(128.85,120.49)
N21182006: length 5.9
  BOTTOM w0.107: RH519.2 130.27,117.8 v2(130.95,117.13) 131.19,116.88 132.69,116.88 CPU1.BR33
N21182008: length 3.5
  BOTTOM w0.076: RH158.2 129.87,115.8 130.33,115.34 v2(130.74,115.34) 130.81,115.28 132.73,115.28 CPU1.BR30
N21182026: length 6.9
  BOTTOM w0.107: CPU1.BP31 133.31,116.13 131.43,116.13 130.24,117.32 128.18,117.32 RH155.2
N21185219: length 1.3
  BOTTOM w0.107: RV45.1 166.5,166.59 UV17.3
N21185406: length 1.4
  TOP w0.107: CV374.1 165.8,163.06 RV13.2
N21238299: length 3.8
  BOTTOM w0.107: RE166.2 v2(287.75,40.52) 287.94,40.52 288.36,40.1 289.62,40.1 289.71,40.19 UE8.24
N21238303: length 2.6
  BOTTOM w0.107: UE8.30 288.48,44.05 287.91,43.48 v2(287.75,43.48) 287.38,43.48 RE167.1
N22278193: length 1.4
  TOP w0.089: TV38.1 225.05,94.68 v1(225.37,95)
  BOTTOM w0.1: v1(225.37,95) 225.37,95.15 UG1.AE34
N22278233: length 1.4
  TOP w0.089: v1(226.13,92.62) 226.07,92.68 TV40.1
  BOTTOM w0.089: UG1.AJ33 226.62,92.13 v1(226.13,92.62)
N22278253: length 1.8
  TOP w0.089: TV41.1 226.17,95.88 v1(226.17,95)
  BOTTOM w0.1: UG1.AE33 226.17,95.15 v1(226.17,95)
N22278293: length 1.4
  TOP w0.089: TV43.1 225.94,90.52 v1(226.26,90.2)
  BOTTOM w0.089: UG1.AK34 225.82,90.64 v1(226.26,90.2)
N22278373: length 2.9
  TOP w0.089: v1(234.58,85.63) 234.83,85.38 234.83,84.55 234.64,84.36 234.2,84.36 TV47.1
  BOTTOM w0.1: v1(234.58,85.63) 234.95,86 UG1.AT24
N22278393: length 1.6
  TOP w0.089: TV48.1 228.48,85.38 v1(228.48,85.57)
  BOTTOM w0.107: UG1.AT30 228.92,86 v1(228.48,85.57)
N22278413: length 1.3
  TOP w0.089: TV49.1 228.81,86.02 v1(228.48,86.35)
  BOTTOM w0.107: v1(228.48,86.35) 228.48,86.39 228.89,86.8 UG1.AR30
N22278433: length 2.1
  TOP w0.089: TV50.1 226.6,84.13 v1(227.22,84.75)
  BOTTOM w0.107: v1(227.22,84.75) 227.37,84.75 UG1.AU32
N22278453: length 1.6
  TOP w0.107: v1(227.22,85.55) 226.92,85.25 226.91,85.25 226.85,85.19 TV51.1
  BOTTOM w0.107: v1(227.22,85.55) 227.37,85.55 227.59,85.77 UG1.AT32
N24365027: length 3.9
  TOP w0.107: v2(305.7,47.09) 306.08,47.09 306.28,47.29 RE530.2 CE63.2 308.05,47.55 UE10.3
N24371838: length 12.2
  TOP w0.107: v1(219.57,166.4) 219.45,166.52 219.45,170.75 v2(219.79,171.09) 220.29,171.09 221.21,172 221.21,172.99 220.69,173.51 218.91,173.51 JHDMI.13
  BOTTOM w0.107: RV655.2 220.15,166.99 v1(219.57,166.4)
N24377100: length 4.7
  BOTTOM w0.107: RX6.1 211.68,161.96 211.51,161.79 QX3.2 210.19,161.18 209.55,161.83 v2(208.97,161.83)
N24405043: length 3.7
  BOTTOM w0.107: v2(193.46,113.67) 192.07,113.67 191.56,113.16 CV438.1 191.32,113.34 UV21.47
N24405047: length 12.5
  TOP w0.107: RV24.1 191.91,116.11 191.49,116.53 190.87,116.53 190.63,116.77 190.63,118.39 190.95,118.71 191.59,118.71 191.76,118.54 v1(191.76,118.14)
  BOTTOM w0.107: UV21.34 190.78,118.54 190.83,118.59 191.31,118.59 v1(191.76,118.14)
N24405061: length 7.6
  BOTTOM w0.107: QV95.1 191.32,108.89 191.5,109.06 RV26.2 191.51,109.56 RV25.1 ; UV21.50 190.44,112.14 190.57,112.01 190.57,111.48 190.34,111.25 190.34,110.67 190.6,110.42 191.51,110.42 RV25.1 ; v2(193.48,110.85) 191.95,110.85 RV25.1
N24405079: length 1.9
  BOTTOM w0.107: v2(193.39,109.54) RV26.1 192.4,109.56 CV439.1
N24654698: length 4.8
  TOP w0.107: U18.3 200.41,64.04 199.78,63.41 199.78,60.83 R367.1
N25131299: length 2.1
  BOTTOM w0.107: QV2.1 159.23,165.74 159.52,165.45 159.52,164.84 RV12.2
N25769611: length 3.7
  BOTTOM w0.107: v2(254.48,18.07) 254.48,16.64 254.16,16.33 QE57.5 253.13,16.33 RE637.2 RE638.1
N25769633: length 2
  BOTTOM w0.107: v2(256.79,14.37) RE636.2 256.21,15.34 QE57.3
N25769981: length 2.3
  BOTTOM w0.107: QE57.6 253.38,16.98 253.25,17.11 RE639.2 v2(252.82,18.18)
N25769983: length 2.5
  BOTTOM w0.107: v2(256.76,17.94) RE641.1 RE640.2 255.96,16.42 QE57.2
N25814049: length 2.8
  BOTTOM w0.107: QG3.2 206.4,89.15 206.39,89.14 206.39,88.36 CG306.1 206.38,87.05 RG50.1
N25867602: length 4.2
  TOP w0.107: QE13.6 203.24,172.11 203.78,172.66 203.78,174.76 RE160.2
N25867965: length 5.7
  TOP w0.107: RE155.2 201.45,174.29 201.45,172.39 200.76,171.7 QE21.6 200.76,170.82 v2(201.18,170.4)
N25868866: length 5
  TOP w0.107: RE157.2 206.19,175.22 206.89,174.51 v2(206.89,172.88) 206.89,172.63 QE22.6
N26196167: length 5.2
  TOP w0.107: UE5.2 305.14,24.94 305.32,25.11 v2(305.32,25.5) 305.32,26.26 305.82,26.77 306.9,26.77 307.29,26.38 RE646.2
N26590619: length 2.7
  TOP w0.107: v2(20.11,54.71) 20.27,54.55 v1(20.27,54.07) 20.27,53.38 RU15.1
  BOTTOM w0.107: v1(20.27,54.07) 19.82,53.63 UU7.1
N26590621: length 2.5
  TOP w0.107: RU16.1 19.19,55.15 v1(19,55.34)
  BOTTOM w0.107: UU7.20 18.62,54.77 19,55.15 v1(19,55.34) 19.38,55.34 v2(19.57,55.53)
N26590623: length 3.8
  TOP w0.107: RU17.1 14.64,54.15 15.09,54.59 15.09,54.61 v1(15.38,54.9) 14.87,55.4 v2(14.74,55.4)
  BOTTOM w0.107: v1(15.38,54.9) 15.64,54.63 15.64,53.88 15.89,53.63 UU7.16
N26590625: length 3.2
  TOP w0.107: RU20.1 17.51,54.52 18.27,55.28 v1(18.36,55.28) 18.36,55.28 18.99,55.91 v2(19.06,55.91)
  BOTTOM w0.107: UU7.19 18.12,55.03 v1(18.36,55.28)
N26590627: length 3.1
  TOP w0.107: RU19.1 17.08,55.28 v1(17.66,55.28)
  BOTTOM w0.107: UU7.18 17.62,55.23 v1(17.66,55.28) v2(18.17,55.79)
N26590629: length 4.8
  TOP w0.107: RU18.1 15.82,54.46 15.82,54.83 16.9,55.91 v1(17.66,55.91)
  BOTTOM w0.107: UU7.17 17.12,55.37 v1(17.66,55.91)
N26590633: length 1.7
  TOP w0.508: v1(21.54,52.29) 21.54,52.74 CU44.1
  BOTTOM w0.508: RU23.1 RU21.1
  vias: v1(19.86,49.03) v1(19.86,48.39) v1(20.49,49.03) v1(20.49,48.39) v1(21.13,49.03) v1(21.13,48.39) v1(21.54,51.66) v1(22.18,52.29) v1(22.18,51.66) v1(22.82,52.29) v1(22.82,51.66) v2(20.71,52.55)
N26590645: length 3.6
  BOTTOM w0.107: UU7.9 17.62,49.9 17.15,49.44 17.15,48.67 RU14.1 v2(16.6,47.13)
N26590649: length 1.5
  BOTTOM w0.107: UU7.8 18.12,49.38 17.77,49.02 RU23.2
N26590685: length 2.5
  BOTTOM w0.107: UU7.10 17.12,49.91 16.6,49.39 RU14.2 v2(15.66,49.02)
N26590716: length 1.3
  BOTTOM w0.107: UU7.7 18.62,49.73 18.63,49.72 RU21.2
N28750395: length 1.3
  TOP w0.089: TV39.1 229.73,86.24 v1(229.62,86.35)
  BOTTOM w0.135: UG1.AR29 229.77,86.35 v1(229.62,86.35)
N29389682: length 3.7
  TOP w0.107: UE4.24 190.92,21.69 191.03,21.8 RE32.2 v2(190,23.81)
N29389707: length 1.7
  TOP w0.107: RE37.1 187.1,23.63 UE4.30
N29418337: length 3.3
  BOTTOM w0.107: PC508.2 120.42,137.02 119.96,136.56 v2(118.63,136.56)
  BOTTOM w0.254: PR525.1 120.44,137.03 PC508.2
N29418339: length 5.9
  BOTTOM w0.107: v2(119.26,140.37) 119.55,140.08 PR522.1
  BOTTOM w0.203: PR531.1 121.87,139.73 121.87,140.01 122.34,140.48 PU500.5
  BOTTOM w0.254: PR522.1 PR525.2 PR531.1
N29418355: length 2
  BOTTOM w0.107: v2(125.04,148.81) 125.25,148.6 PC533.2
  BOTTOM w0.254: PC533.2 125.25,146.95 PR546.2
N29418359: length 4.3
  BOTTOM w0.203: PR546.1 125.27,145.86 125.61,145.51 125.61,145.2 125.87,144.93 PU500.17
  BOTTOM w0.254: PR549.1 PR546.1 PR550.2
N29418369: length 2
  BOTTOM w0.107: v2(134.37,144.81) 134.03,144.47 PC514.1
  BOTTOM w0.254: PR532.2 133.99,143.85 PC514.1
N29418371: length 53.6
  IN1 w0.254: v1(123.12,145.26) 123.12,145.55 124.03,146.46 128.31,146.46 129.68,147.83 129.68,148.72 131.48,150.53 133.55,150.53 133.87,150.21 133.87,148.78 134.51,148.14 135.37,148.14 135.79,148.56 137.74,148.56 138.31,149.13 138.31,149.51 139.74,150.94 141.5,150.94 141.73,150.72 143.71,150.72 144.32,151.33 149.39,151.33 150.12,150.59 156.54,150.59 157.3,149.83 161.62,149.83 v1(163.71,147.74)
  BOTTOM w0.107: v1(163.71,147.74) v2(163.71,148.39)
  BOTTOM w0.254: PC5011.2 121.24,146.45 121.66,146.03 122.53,146.03 PR547.2 123.4,146.02 PR545.1 123.41,145.55 v1(123.12,145.26) ; v1(163.71,147.74) 163.71,147.69 163.97,147.42 PH504.2
N29418373: length 5.5
  BOTTOM w0.203: PU500.30 v2(130.78,141.28) 131.02,141.28 131.64,141.9 131.64,142.39 PR533.1
  BOTTOM w0.254: PR536.1 132.17,144.76 PR532.1 132.17,142.93 PR533.1
N29418377: length 2.2
  BOTTOM w0.203: PU500.15 125.07,144.7 124.53,145.25 124.53,145.83 PR545.2
N29418393: length 36.6
  IN3 w0.254: v1(140.28,149.51) 140.28,149.19 139.14,148.05 139.14,147.38 137.85,146.1 121.56,146.1 119.26,143.8 119.26,137.14 v1(121.17,135.24)
  BOTTOM w0.254: PH500.2 140.14,149.51 v1(140.28,149.51) ; PR513.2 120.43,135.26 PR514.1 ; PR513.2 120.45,134.36 PC5010.2 ; PR513.2 v1(121.17,135.24)
N29418395: length 4.9
  BOTTOM w0.203: PU500.3 122.95,139.68 122.05,138.79 122.05,138.15 122.31,137.89 v2(122.31,137.57) 122.31,137.1 PR514.2
N29418397: length 4
  TOP w0.107: v1(122.37,139.8) 121.61,139.03 v2(121.48,139.03)
  TOP w0.254: v1(122.37,139.8) 122.45,139.72 PR521.2 123.07,139.72 123.09,139.75 123.82,139.75 PC505.2
  BOTTOM w0.203: v1(122.37,139.8) 122.37,139.8 122.66,140.08 PU500.4
N29418405: length 4
  TOP w0.254: PR527.1 129.99,137.56 v1(130.31,137.88)
  BOTTOM w0.107: v1(130.31,137.88) 130.31,137.64 v2(130.63,137.32)
  BOTTOM w0.203: v1(130.31,137.88) 130.31,137.88 130.31,138.47 129.89,138.88 PU500.36
N29418417: length 3.9
  BOTTOM w0.203: PU500.33 130.4,140.08 130.63,139.86 v2(130.88,139.86) 130.89,139.85 131.32,139.85 131.81,139.37 PR524.1
  BOTTOM w0.254: PR524.1 132.17,138.5 PC509.2
N29418423: length 3.2
  TOP w0.254: v1(130.56,141.74) 130.54,141.77 129.56,141.77 PR537.1 129.41,141.89 PC520.2
  BOTTOM w0.203: PU500.29 130.48,141.68 130.54,141.74 v1(130.56,141.74)
N29418425: length 5.2
  TOP w0.254: PC519.1 PR539.1 129.37,143.34 v2(129.87,142.84) 130.48,142.23 v1(131.13,142.23)
  BOTTOM w0.203: v1(131.13,142.23) 130.26,142.23 130.12,142.08 PU500.28
N29418433: length 4
  TOP w0.107: v2(122.17,136.2) PR515.2
  TOP w0.254: v1(124.08,136.94) 124.06,136.92 PR520.2 PR515.2
  BOTTOM w0.203: v1(124.08,136.94) 124.08,137 124.67,137.59 PU500.47
N29418441: length 2.1
  BOTTOM w0.203: PU500.40 127.47,137.42 127.83,137.07 127.83,136.42 PR518.1
N29418445: length 2.1
  BOTTOM w0.203: PU500.39 127.87,137.49 128.16,137.2 128.16,136.55 PR517.1
N29418451: length 2.3
  BOTTOM w0.203: PR516.1 128.53,137.07 128.53,137.32 128.27,137.58 PU500.38
N29418455: length 3.8
  BOTTOM w0.107: PR519.1 130.35,136.2 130.76,135.8 v2(131.33,135.8)
  BOTTOM w0.203: PR519.1 129.23,137.26 129.1,137.26 128.67,137.68 PU500.37
N29418473: length 3.5
  TOP w0.254: PC536.1 124.91,143.67 PR551.1 124.91,145.26 v1(125.04,145.39)
  BOTTOM w0.203: v1(125.04,145.39) 125.04,145.26 125.47,144.82 PU500.16
N29418487: length 4.1
  TOP w0.107: PR506.1 v2(128.67,136.19)
  TOP w0.254: PR506.1 127.64,136.51 v1(127.32,136.83) 127.64,137.14 PC504.1
  BOTTOM w0.203: v1(127.32,136.83) 127.32,137.07 127.07,137.32 PU500.41
N29418491: length 2.4
  BOTTOM w0.203: PR523.1 123.45,136.48 123.45,137.07 123.83,137.45 124.02,137.45 124.27,137.7 PU500.48
N29419473: length 4.1
  TOP w0.107: v2(122.18,137.7) 122.51,138.03 v1(122.51,138.53)
  TOP w0.254: v1(122.51,138.53) 123.3,138.53 PC500.2 PR500.2
  BOTTOM w0.203: PU500.2 123.01,139.28 122.5,138.77 122.5,138.53 v1(122.51,138.53)
N29419486: length 3.6
  BOTTOM w0.203: PC518.2 121.35,142.7 121.67,142.38 121.67,142.37 121.82,142.22 121.82,142.13 122.1,141.85 122.27,141.85 122.44,141.68 PU500.8
  BOTTOM w0.254: PR540.2 120.48,142.97 120.75,142.7 PC518.2
N29419576: length 2
  TOP w0.107: v2(122.75,141.64) 123.01,141.38 PR521.1
  TOP w0.254: PC506.2 123.9,140.66 123.88,140.64 PR521.1
N29419623: length 2.3
  TOP w0.107: v2(123.14,148.94) 123.14,148.3 123.63,147.81 PH502.1
  TOP w0.254: PH502.1 PR534.2
N29419647: length 2.7
  TOP w0.107: v2(130.68,140.34) 130.03,140.99 PR537.2
  TOP w0.254: PR537.2 128.67,140.24 PC521.1
N29419655: length 1.9
  BOTTOM w0.107: v2(132.92,146.58) 132.92,146.57 133.09,146.4 PC522.1
  BOTTOM w0.254: PR536.2 PC522.1
N29419663: length 2
  BOTTOM w0.107: PR530.1 186.21,134.99 v2(186.38,135.16)
  BOTTOM w0.254: PR530.1 PH501.2
N29419667: length 60.7
  TOP w0.254: PR544.1 122.21,146.94 v1(121.87,146.59)
  IN4 w0.254: v1(121.87,146.59) 122.21,146.94 122.84,146.94 124.5,145.27 124.5,145.22 125.1,144.62 128.53,144.62 129.61,145.7 130.69,145.7 135.64,140.75 135.64,131.95 139.74,127.86 142.06,127.86 142.38,127.54 146.75,127.54 147.13,127.92 156.5,127.92 159.04,130.46 163.79,130.46 v1(164.29,129.96)
  BOTTOM w0.254: PH503.2 v1(164.29,129.96)
N29419693: length 1
  BOTTOM w0.254: PC518.1 120.72,143.62 120.48,143.86 PR538.2
N29419713: length 5.2
  BOTTOM w0.107: v2(121.38,134.78) 121.74,135.14 121.74,135.7 122.24,136.2 PR526.1
  BOTTOM w0.203: PU500.1 123.11,138.88 123,138.78 123,137.32 122.28,136.6 PR526.1
N29419730: length 2.1
  BOTTOM w0.107: v2(132.72,136.62) 133.1,137 PR528.2
  BOTTOM w0.254: PR528.2 PC509.1
N29419832: length 3.6
  TOP w0.107: PC503.1 v2(125.59,137.58)
  TOP w0.254: PC503.1 126.54,137.16 v1(126.75,136.94) 126.73,136.92 PR505.2
  BOTTOM w0.203: v1(126.75,136.94) 126.67,137.02 PU500.42
N29419860: length 5.3
  TOP w0.107: PR548.1 v2(122.03,143.51)
  TOP w0.254: v1(123.66,145.04) 124.02,144.67 124.02,143.62 PC535.2 PR548.1
  BOTTOM w0.203: PU500.14 124.67,144.63 124.27,145.04 v1(123.66,145.04)
N29419910: length 1.1
  TOP w0.254: PR551.2 125.83,144.42 126.51,143.73 PC538.2
N29419918: length 2.2
  BOTTOM w0.107: PC537.1 123.07,148.24 v2(123.07,148.94)
  BOTTOM w0.254: PC537.1 123.51,147.82 PR549.2
N29419943: length 3.9
  BOTTOM w0.107: PC532.1 127.29,147.88 v2(127.33,147.92)
  BOTTOM w0.203: PU500.20 127.07,144.95 127.2,145.07 127.2,145.94 PR541.1
  BOTTOM w0.254: PR541.1 PC532.1
N29419947: length 3
  BOTTOM w0.107: v2(128.5,148.59) 127.77,147.86 127.77,147.35 PC532.2
  BOTTOM w0.254: PC532.2 129.06,146.92 PR543.1
N29425467: length 6.1
  TOP w0.107: v1(176.79,134.97) 177.11,134.97 v2(177.3,134.78)
  TOP w0.254: v1(176.79,134.97) 176.66,135.1 PR578.1 176.1,135.67 PR577.2
  TOP w0.508: PR575.1 v1(175.46,139.1)
  BOTTOM w0.254: v1(176.79,134.97) 177.05,135.23 PL503.2
N29425497: length 6.9
  TOP w0.107: v1(168.66,135.1) 168.98,135.1 v2(169.17,134.91)
  TOP w0.254: v1(168.66,135.1) 168.58,135.18 PR568.1 168,135.77 PR567.2
  TOP w0.508: PR565.1 v1(167.2,139.04)
  BOTTOM w0.254: PL502.2 168.98,135.41 v1(168.66,135.1)
N29425633: length 8
  TOP w0.107: v2(160.73,134.84) 160.47,135.1 v1(160.28,135.1)
  TOP w0.254: v1(160.28,135.1) 160.23,135.05 PR558.1 159.58,135.71 PR557.2
  TOP w0.508: PR555.1 v1(158.84,137.9)
  BOTTOM w0.254: v1(160.28,135.1) 159.96,135.41 PL501.2
N29426641: length 2.7
  BOTTOM w0.107: v2(173.2,146.37) PR573.1
  BOTTOM w0.254: PU504.1 174.75,145.15 174.52,145.38 174.52,145.63 174.27,145.89 PR573.1
N29426805: length 3.7
  TOP w0.107: PC548.1 162.12,135.35 v2(162.12,134.97)
  TOP w0.508: PR555.2 161.23,137.01 PC548.1
N29426831: length 3.2
  TOP w0.107: PC556.1 169.87,135.61 v2(170.57,134.91)
  TOP w0.508: PR565.2 PC556.1
N29426855: length 3.2
  TOP w0.107: v2(178.73,134.94) 178.12,135.54 PC564.1
  TOP w0.508: PR575.2 PC564.1
N29435109: length 8.7
  TOP w0.508: v1(181.68,134.21) 181.94,134.21 v2(183.14,133) 183.9,133 184.23,133.33 PR5002.1 185.33,132.57 PR5003.1
  BOTTOM w0.254: v1(181.68,134.21) 182.06,134.21 183.24,135.38 PL508.1
N29435333: length 7.2
  TOP w0.107: v1(152.15,137.96) v2(152.72,137.96)
  TOP w0.254: v1(152.15,137.96) 151.77,138.34 PR596.1 151.4,138.82 PR595.2
  TOP w0.508: PR593.1 v1(151.2,142.34)
  BOTTOM w0.254: v1(152.15,137.96) 152.15,139.1 PL506.2
N29435335: length 1.6
  TOP w0.107: PC587.1 182.38,134.46 182,134.84 v2(181.75,134.84)
N29436554: length 6
  TOP w0.107: v2(144.47,138.14) 144.28,138.34 v1(143.96,138.34)
  TOP w0.254: v1(143.96,138.34) 143.92,138.38 PR587.1 143.31,138.88 PR586.2
  TOP w0.508: PR584.1 v1(142.56,142.28)
  BOTTOM w0.254: PL505.2 143.71,138.59 v1(143.96,138.34)
N29436709: length 3
  TOP w0.107: v2(154.06,138.14) 153.87,138.34 PC580.1
  TOP w0.508: PR593.2 PC580.1
N29436789: length 3.2
  TOP w0.107: v2(146,138.14) 145.29,138.85 PC570.1
  TOP w0.508: PR584.2 145.23,139.48 PC570.1
N29438561: length 2
  BOTTOM w0.203: PR512.2 126.27,136.66 PU500.43
N29438565: length 1.9
  BOTTOM w0.203: PR510.2 125.94,136.31 125.94,137.24 125.87,137.31 PU500.44
N29438567: length 2.8
  TOP w0.107: PR502.2 125.83,134.5 v1(125.84,134.5) 125.84,134.82 v2(125.68,134.98)
  BOTTOM w0.107: PR509.1 v1(125.84,134.5) PR510.1
N29438569: length 4.5
  TOP w0.107: v2(125.12,136.23) 124.63,135.74 v1(124.63,134.55) 124.62,134.54 124.62,134.1 PR501.2
  BOTTOM w0.107: PR508.1 124.63,134.97 v1(124.63,134.55) 124.63,134.11 PR507.1
N29438571: length 2.1
  BOTTOM w0.203: PU500.45 125.47,137.45 124.95,136.93 PR508.2
N29438583: length 3.5
  TOP w0.107: PR503.2 126.72,134.18 v1(127.04,134.5) 127.35,134.5 v2(127.77,134.08)
  BOTTOM w0.107: PR511.1 126.73,134.19 v1(127.04,134.5) 127.04,134.97 PR512.1
N29438934: length 2.3
  BOTTOM w0.203: PU500.46 125.07,137.52 124.6,137.04 124.6,136.74 PR504.1
N29599145: length 2.2
  BOTTOM w0.107: v2(118.56,138.27) PR522.2
  BOTTOM w0.254: PR522.2 PC507.1
N29647096: length 3.4
  TOP w0.107: v2(308.54,59.14) RU24.2 RU25.1 307.55,57.12 QU1.2
N30005754: length 2.8
  TOP w0.089: CH70.1 v2(213.18,26.7) 213.69,26.7 v1(214.07,26.32)
  BOTTOM w0.203: UH1.BA26 214.45,26.71 v1(214.07,26.32)
N30712936: length 3.1
  TOP w0.107: v2(54.19,18.65) PR727.2
  TOP w0.203: PU700.15 56.24,19.98 56.04,19.78 55.92,19.78 55.25,19.11 PR727.2
N30746783: length 2.3
  BOTTOM w0.203: PU201.10 94.56,43.2 95.2,42.56 95.2,42.39 PR210.2
N30816588: length 1.4
  TOP w0.254: RA85.1 RA84.1 21.38,28.23 UA2.B2
N31077401: length 2.5
  TOP w0.107: PQ710.3 120.15,76.83 v2(120.15,76.23)
  TOP w0.254: PR732.2 118.88,77.83 119.45,77.25 PQ710.3
N31077403: length 4.1
  TOP w0.107: v2(122.75,79.98) 122.49,79.71 PR730.2
  TOP w0.254: PQ710.6 122.42,78.55 PR729.1 ; PQ710.6 121.63,79.63 PR730.2 ; PQ710.6 PQ710.5
N31077444: length 3.8
  TOP w0.107: PR731.2 v2(116.73,77.83)
  TOP w0.254: PQ710.2 119.51,77.9 PC724.1 117.75,77.87 PR731.2
N31306212: length 2
  BOTTOM w0.254: PU511.1 182.43,143.67 182.3,143.8 182.06,143.8 181.81,144.05 PR5006.1
N31425874: length 1.2
  BOTTOM w0.107: PC541.1 v2(160.42,148.88)
N31426231: length 3
  BOTTOM w0.107: PR552.1 157.01,146.45 156.65,146.08 v2(156.37,146.08)
  BOTTOM w0.254: PU502.1 158.08,145.23 157.4,145.9 PR552.1
N31426252: length 1.7
  BOTTOM w0.254: PU502.2 158.58,145.31 158.25,145.64 158.25,146.4 PR556.1
N31426527: length 2.8
  TOP w0.254: v1(156.54,143.06) 157.24,142.36 PR5028.2 157.3,141.53 PC5005.1
  BOTTOM w0.254: v1(156.54,143.06) 156.67,143.2 PU502.24
N31427446: length 3.4
  TOP w0.107: v2(159.06,146.63) 158.78,146.34 158.78,145.86 v1(158.75,145.84)
  TOP w0.254: PC540.2 158.18,145.84 v1(158.75,145.84)
  BOTTOM w0.254: PU502.3 159.08,145.39 158.75,145.72 v1(158.75,145.84) 158.75,145.99 159.18,146.42 PR553.1
N31432086: length 1.3
  BOTTOM w0.107: PC550.1 v2(168.75,148.91)
N31432114: length 1.5
  BOTTOM w0.107: PR564.2 170.41,146.24 170.76,146.59 v2(171.33,146.59)
N31434994: length 1.6
  BOTTOM w0.254: PU503.2 166.91,145.32 166.69,145.54 166.69,146.23 PR566.1
N31435092: length 2.7
  BOTTOM w0.107: v2(164.92,146.36) PR563.1
  BOTTOM w0.254: PR563.1 165.93,145.86 166.18,145.61 166.18,145.35 166.41,145.12 PU503.1
N31436196: length 1.3
  BOTTOM w0.107: PC558.1 v2(177.1,149)
N31436218: length 1.3
  BOTTOM w0.107: PR574.2 178.85,146.3 179.08,146.53 v2(179.59,146.53)
N31436380: length 1.6
  BOTTOM w0.254: PU504.2 175.25,145.35 175.03,145.57 175.03,146.26 PR576.1
N31438582: length 3.4
  TOP w0.107: v2(172.67,142.53) 172.86,142.72 v1(173.17,142.72)
  TOP w0.254: v1(173.17,142.72) 173.47,142.42 PR5030.2 173.95,141.62 PC5007.1
  BOTTOM w0.254: v1(173.17,142.72) 173.62,143.17 PU504.24
N31438896: length 3.4
  TOP w0.107: v1(175.58,145.7) 175.58,146.01 175.9,146.34 v2(175.9,146.53)
  TOP w0.254: v1(175.58,145.7) 175.53,145.65 PC557.2
  BOTTOM w0.254: PU504.3 175.75,145.53 v1(175.58,145.7) 175.58,145.83 176.05,146.3 PR5020.1
N31439632: length 1.8
  BOTTOM w0.107: v2(142.95,151.61) 143.01,151.67 143.52,151.67 144.24,150.95 PC567.1
N31439736: length 1.6
  BOTTOM w0.254: PR585.1 142.34,149.52 142.34,148.83 142.56,148.61 PU507.2
N31439790: length 2.8
  BOTTOM w0.107: v2(140.67,149.19) 141.13,149.65 PR590.1
  BOTTOM w0.254: PR590.1 141.58,149.02 142.06,148.54 PU507.1
N31442956: length 3.4
  TOP w0.107: v1(142.93,148.98) 142.93,149.62 v2(143.2,149.89)
  TOP w0.254: PC566.2 142.84,148.89 v1(142.93,148.98)
  BOTTOM w0.254: PU507.3 143.06,148.85 v1(142.93,148.98) 142.93,149.16 143.36,149.58 PR5022.1
