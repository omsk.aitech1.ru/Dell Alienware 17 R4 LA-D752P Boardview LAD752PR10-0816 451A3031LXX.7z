# Allegro board LAD752PR10-0816.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PCIE_PTX_DRX_N12: length 3.3
  TOP w0.099: v1(251.4,10.86) 251.21,10.68 251.21,10.23 CH209.2
  BOTTOM w0.099: v1(251.4,10.86) 251.3,10.96 251.3,11.94 251.53,12.17 JSSD3.11
PCIE_PTX_DRX_N12_C: length 74.2
  TOP w0.099: CH209.1 251.39,9.32 251.39,8.71 251.03,8.34 v1(249.5,8.34)
  IN4 w0.097: v1(249.5,8.34) 249.34,8.5 249.21,8.5 248.6,7.89 241.71,7.89 239.56,10.04 238.29,10.04 237.57,10.76 227.54,10.76 226.69,11.61 206.94,11.61 206.2,10.87 204.93,10.87 204.3,10.24 202.38,10.24 201.92,10.7 198.39,10.7 196.5,12.6 196.5,13.99 196.29,14.2 196.29,15.03 195.96,15.35 194.88,15.35 194.21,16.03 194.21,17.38 194.56,17.73 194.56,18.47 194.16,18.87 194.16,19.99 194.72,20.55 194.72,21.36 194.33,21.75 193.42,21.75 v1(193.32,21.65)
  BOTTOM w0.089: 195.26,22.69 194.95,22.38 194.51,22.38 194.46,22.33 194.21,22.33 193.7,21.81 193.48,21.81 v1(193.32,21.65)
  BOTTOM w0.099: UH1.B35 195.26,22.69
PCIE_PTX_DRX_N13: length 6.1
  TOP w0.099: v1(329.27,37.6) 329.5,37.36 329.96,37.36 CH206.2
  BOTTOM w0.099: v1(329.27,37.6) 329.09,37.41 328.83,37.41 328.59,37.66 328.59,38.68 327.8,39.47 326.91,39.47 326.77,39.61 JSSD1.35
PCIE_PTX_DRX_N13_C: length 165.4
  TOP w0.099: CH206.1 330.98,37.35 331.18,37.35 v1(331.38,37.55)
  IN1 w0.097: v1(192.69,20.71) 192.82,20.85 193.16,20.85 193.26,20.75 193.26,18.87 193.6,18.53 194.87,18.53 195.89,17.51 196.39,17.51 196.97,16.92 196.97,16.82 197.34,16.45 197.72,16.45 200.38,13.79 205.81,13.79 206.74,12.86 212.73,12.86 212.83,12.95 229.81,12.95 231.63,14.76 236.8,14.76 237.67,15.63 237.67,16.35 238.24,16.93 256.74,16.93 263.38,23.56 268.46,23.56 270.92,26.02 275.47,26.02 275.68,25.82 275.68,24.72 276.41,23.98 280.43,23.98 282.57,26.13 289.75,26.13 290.89,27.27 291.98,27.27 292.21,27.5 293.98,27.5 295.28,26.2 301.95,26.2 306.28,30.53 325.27,30.53 326.35,31.62 329.53,31.62 332.54,34.62 332.54,36.88 332.02,37.4 331.53,37.4 v1(331.38,37.55)
  BOTTOM w0.089: UH1.C36 195.31,21.93 195,21.93 194.91,22.02 194.66,22.02 194.61,21.97 194.41,21.97 194.06,21.62 194.06,21.62 193.96,21.52 193.86,21.43 193.86,21.4 193.65,21.19 193.43,20.97 193.37,20.97 193.36,20.96 193.35,20.96
  BOTTOM w0.099: v1(192.69,20.71) 192.93,20.96 193.35,20.96
PCIE_PTX_DRX_N14: length 4.8
  TOP w0.099: v1(329.26,36.3) 329.5,36.06 329.98,36.06 CH204.2
  BOTTOM w0.099: v1(329.26,36.3) 329.06,36.1 327.32,36.1 327.01,36.42 326.77,36.42 326.58,36.61 JSSD1.47
PCIE_PTX_DRX_N14_C: length 154.9
  TOP w0.099: v1(331.4,36.19) 331.22,36.01 330.95,36.01 CH204.1
  IN1 w0.097: v1(195.78,20.8) 195.63,20.94 195.63,21.08 195.74,21.19 195.73,21.32 195.63,21.39 195.48,21.39 195.08,20.96 195.08,20.36 196.38,19.06 196.38,18.64 196.69,18.34 197.8,18.34 201.34,14.8 207.12,14.8 208.1,13.81 210.08,13.81 210.37,14.1 211.38,14.1 211.71,13.77 229.47,13.77 231.86,16.16 233.64,16.16 233.9,16.42 236.57,16.42 237.9,17.75 256.31,17.75 265.07,26.52 270.25,26.52 270.67,26.94 275.72,26.94 276.35,26.31 278.71,26.31 279.06,25.97 280.84,25.97 281.88,27.01 289.37,27.01 290.46,28.1 291.64,28.1 292.13,28.58 299.42,28.58 300.06,27.95 302.53,27.95 305.94,31.36 324.92,31.36 326.01,32.44 329.1,32.44 330.67,34.01 330.67,35.58 330.87,35.78 330.99,35.78 331.06,35.85 331.06,36.09 331.16,36.19 v1(331.4,36.19)
  BOTTOM w0.099: v1(195.78,20.8) 195.56,20.8 195.17,21.18 UH1.B38
PCIE_PTX_DRX_N17: length 2.7
  BOTTOM w0.099: JSSD2.47 271,12.76 270.85,12.6 270.54,12.6 269.98,12.05 269.82,12.05 CH214.1
PCIE_PTX_DRX_N17_C: length 82.2
  IN3 w0.099: v1(197.61,15.48) 197.86,15.73 197.98,15.73 198.2,15.51 198.2,12.15 199.55,10.8 214.44,10.8 214.86,11.21 219.39,11.21 219.99,10.61 225.84,10.61 226.96,9.48 253.02,9.48 253.46,9.93 257.02,9.93 258.45,11.35 265.48,11.35 266.6,12.48 267.79,12.48 267.98,12.29 267.98,12.18 v1(267.59,11.78)
  BOTTOM w0.099: UH1.E45 196.67,17.73 196.67,15.76 196.95,15.48 v1(197.61,15.48) ; v1(267.59,11.78) 267.59,11.8 268.21,12.43 268.58,12.43 268.7,12.3 CH214.2
PCIE_PTX_DRX_N18: length 2.3
  BOTTOM w0.099: JSSD2.35 271.07,15.76 270.9,15.59 270.52,15.59 270.42,15.49 270,15.49 CH216.1
PCIE_PTX_DRX_N18_C: length 81.6
  IN3 w0.099: v1(268.02,14.6) 268.12,14.5 268.26,14.5 268.4,14.64 268.4,14.89 268.29,15 267.79,15 267.52,14.74 266.98,14.74 264.93,12.68 257.9,12.68 256.5,11.28 246.36,11.28 246.13,11.51 242.89,11.51 242.64,11.26 242.31,11.26 241.87,10.81 227.51,10.81 226.39,11.94 220.63,11.94 220.03,12.54 214.3,12.54 213.89,12.13 206.79,12.13 205.55,13.37 201.35,13.37 199.47,15.25 199.47,16.91 198.81,17.56 197.87,17.56 197.78,17.47 197.78,17.35 197.86,17.26 198.02,17.26 198.12,17.16 v1(198.12,17)
  BOTTOM w0.099: v1(268.02,14.6) 268.21,14.79 268.21,15.39 268.53,15.72 CH216.2 ; v1(198.12,17) 198.1,17 197.79,17.3 197.79,17.44 198.01,17.66 198.01,17.79 197.91,17.89 197.78,17.89 UH1.G45
PCIE_PTX_DRX_N19: length 3.3
  BOTTOM w0.099: JSSD2.23 270.83,18.76 270.67,18.6 270.43,18.6 269.83,18 269.21,18 CH221.2
PCIE_PTX_DRX_N19_C: length 80.7
  IN3 w0.099: v1(267.51,16.49) 267.67,16.33 267.84,16.33 267.94,16.43 267.94,16.66 268.12,16.84 268.12,16.96 267.94,17.14 267.18,17.14 265.76,15.72 265.76,15.4 264.37,14.02 257.35,14.02 255.95,12.62 246.96,12.62 246.67,12.91 242.37,12.91 242.11,12.65 241.09,12.65 240.58,12.14 232.87,12.14 232.41,12.61 231.63,12.61 231.16,12.14 228.06,12.14 226.94,13.27 221.26,13.27 220.64,13.89 210.98,13.89 210.55,13.46 208.43,13.46 207.18,14.71 203.23,14.71 201.95,15.99 201.66,15.99 201.56,15.89 201.56,15.75 v1(201.66,15.65)
  BOTTOM w0.099: v1(267.51,16.49) 267.61,16.59 267.61,17.61 268.02,18.02 268.18,18.02 CH221.1 ; UH1.H43 198.55,18.33 198.55,18.04 198.44,17.94 198.44,17.7 199.6,16.54 201.41,16.54 201.66,16.29 v1(201.66,15.65)
PCIE_PTX_DRX_N20: length 2.4
  BOTTOM w0.099: JSSD2.11 270.92,21.76 270.68,21.51 269.82,21.51 CH219.2
PCIE_PTX_DRX_N20_C: length 78.6
  IN3 w0.099: v1(201.62,17.69) 201.86,17.45 202.29,17.45 203.02,16.71 206.97,16.71 207.32,16.36 207.93,16.36 208.85,15.44 211.15,15.44 211.25,15.34 216.43,15.34 216.5,15.41 221.27,15.41 221.87,14.8 227.55,14.8 228.7,13.66 230.49,13.66 231.53,14.7 232.48,14.7 233.52,13.66 239.95,13.66 240.46,14.16 241.48,14.16 241.74,14.42 247.3,14.42 247.59,14.14 255.32,14.14 256.72,15.53 260.94,15.53 264.14,18.74 267.22,18.74 267.9,19.42 267.9,20.09 v1(267.51,20.49)
  BOTTOM w0.099: UH1.K44 198.85,18.17 198.92,18.1 199.1,18.1 199.94,17.26 200.75,17.26 200.92,17.43 201.37,17.43 v1(201.62,17.69) ; v1(267.51,20.49) 267.62,20.61 267.62,21.08 268.21,21.67 CH219.1
PCIE_PTX_DRX_P5: length 175.3
  IN3 w0.099: v1(196.3,28.6) 196.55,28.85 196.55,29.16 196.23,29.48 196.23,30.52 197.37,31.66 197.37,32.36 197.88,32.87 197.88,34.44 197.43,34.89 195.26,34.89 194.21,35.94 194.21,37.35 192.86,38.7 192.86,39.61 190.45,42.02 190.45,48.2 189.33,49.32 189.33,64.16 189.76,64.58 189.76,83.74 192.43,86.42 198.76,86.42 200.83,88.48 201.61,88.48 205.24,92.12 205.24,99.84 202.1,102.98 202.1,107.56 197.49,112.18 197.49,143.6 203.14,149.25 218.02,149.25 219.5,150.74 222.98,150.74 223.93,151.68 229.45,151.68 230.46,152.69 230.46,153.53 230.34,153.64 230.13,153.64 229.74,153.25 v1(229.74,153.19)
  BOTTOM w0.089: UH1.C22 195.75,29.08 196.05,28.79 196.17,28.79 196.3,28.66 v1(196.3,28.6)
  BOTTOM w0.099: CL3.2 230.28,153.32 229.98,153.32 229.98,153.32 229.87,153.32 v1(229.74,153.19)
PCIE_PTX_DRX_P5_C: length 2.2
  BOTTOM w0.099: CL3.1 231.98,153.3 232.83,153.3 232.91,153.22 UL1.35
PCIE_PTX_DRX_P6: length 141.2
  TOP w0.099: CN23.2 307.52,39.37 307.52,39.76 v1(307.34,39.94)
  IN4 w0.097: v1(307.34,39.94) 307.56,39.72 307.56,38.72 306.82,37.99 290.45,37.99 289.42,36.96 288.28,36.96 286.28,34.96 284.04,34.96 283.65,34.56 281.7,34.56 281.35,34.21 265.59,34.21 263.5,36.3 241.12,36.3 240.27,37.16 236.33,37.16 229.89,43.59 229.4,43.59 227.99,45 216.8,45 216.04,45.77 206.89,45.77 206.41,45.28 198.46,45.28 196.53,43.35 194.79,43.35 191.59,40.14 191.59,33.25 193.29,31.55 194.18,31.55 194.53,31.2 194.53,30.71 194.27,30.46 194.27,30.28 v1(194.06,30.07)
  BOTTOM w0.099: UH1.A23 194.76,28.71 194.3,29.17 194.3,29.83 v1(194.06,30.07)
PCIE_PTX_DRX_P6_C: length 5.9
  TOP w0.099: CN23.1 307.46,37.74 307.46,37.26 v1(307.27,37.07)
  BOTTOM w0.099: v1(307.27,37.07) 307.46,36.88 307.46,36.13 307.86,35.74 308.6,35.74 309,35.34 309,34.68 308.82,34.5 JWLAN.27
PCIE_PTX_DRX_P9: length 7.5
  TOP w0.099: CH211.1 239.49,9.87 239.57,9.87 239.77,9.67 239.77,9.35 v1(239.41,8.98)
  BOTTOM w0.099: JSSD3.49 242.02,12.12 242.31,11.83 242.31,11.22 241.49,10.4 240.45,10.4 239.53,9.47 239.53,9.1 v1(239.41,8.98)
PCIE_PTX_DRX_P9_C: length 71.5
  TOP w0.099: CH211.2 238.41,9.74 238.12,9.74 237.93,9.54 237.93,8.91 237.62,8.6 237.39,8.6 v1(237.19,8.4)
  IN4 w0.097: v1(193.69,24.38) 193.69,25.3 193.44,25.55 192.68,25.55 192.25,25.12 192.25,24.82 191.84,24.41 191.53,24.41 190.95,23.83 190.95,20.49 192.08,19.37 192.08,10.79 194.86,8.01 205.33,8.01 207.52,10.19 213.49,10.19 213.61,10.31 226.04,10.31 226.9,9.45 235.37,9.45 236.37,8.45 237.15,8.45 v1(237.19,8.4)
  BOTTOM w0.089: UH1.B31 195.2,24.5 195.2,24.58 195.12,24.67 194.97,24.67 194.88,24.59 194.88,24.37 194.81,24.3 194.67,24.3 194.44,24.53 194.41,24.53 194.32,24.62 194.32,24.74 194.22,24.84 194.09,24.84 194.03,24.77 193.9,24.77 193.84,24.84 193.68,24.84 193.54,24.7 193.54,24.64 193.58,24.6 193.58,24.49 v1(193.69,24.38)
PCIE_PTX_DRX_P10: length 7.5
  TOP w0.099: CH213.1 243.66,9.58 244.05,9.58 244.6,9.04 244.6,8.89 v1(244.26,8.56)
  BOTTOM w0.099: v1(244.26,8.56) 244.46,8.75 244.46,11.18 244.87,11.59 245.16,11.59 245.26,11.69 245.26,11.96 245.02,12.19 JSSD3.37
PCIE_PTX_DRX_P10_C: length 70.7
  TOP w0.099: v1(240.02,7.95) 239.78,8.2 239.78,8.27 239.88,8.37 v3(241.42,8.37) 241.71,8.37 241.99,8.66 241.99,9.48 242.09,9.58 242.19,9.58 CH213.2
  IN4 w0.097: v1(240.02,7.95) 239.78,8.19 239.78,8.3 239.52,8.56 238.65,8.56 236.93,10.28 227.27,10.28 226.41,11.13 211.63,11.13 211.51,11.02 207.07,11.02 206.44,10.39 205.13,10.39 203.57,8.83 196.65,8.83 192.9,12.58 192.9,19.28 192.9,19.31 192.9,19.8 192.22,20.48 192.22,21.33 192.29,21.4 192.29,21.81 192.95,22.48 192.95,22.83 193.04,22.91 193.04,22.92 193.58,23.47 193.58,23.6 v1(193.81,23.82)
  BOTTOM w0.089: v1(193.81,23.82) 193.87,23.89 194.03,23.89 194.09,23.83 194.12,23.83 194.16,23.79 194.16,23.72 194.2,23.68 194.3,23.68 194.42,23.8 194.53,23.8 194.65,23.68 194.79,23.68 195.02,23.9 195.02,24.14 195.08,24.21 195.27,24.21 195.38,24.32 195.53,24.32 195.62,24.23 195.62,24.08 195.5,23.96 UH1.B32
PCIE_PTX_DRX_P11: length 3.4
  TOP w0.099: v1(247.7,10.86) 247.91,10.65 247.91,10.23 CH202.2
  BOTTOM w0.099: JSSD3.25 248.02,12.18 248.17,12.03 248.17,11.86 248.07,11.76 247.85,11.54 247.85,11.01 v1(247.7,10.86)
PCIE_PTX_DRX_P11_C: length 68.9
  TOP w0.099: CH202.1 247.87,9.18 247.87,8.96 v1(247.68,8.77)
  IN4 w0.097: v1(193.43,22.8) 193.68,22.8 194.24,22.23 194.8,22.23 195.24,21.79 195.24,20.26 194.7,19.72 194.7,19.14 195.61,18.24 195.61,16.72 196.94,15.39 196.94,14.57 198.08,13.42 198.08,12.28 199.01,11.35 202.18,11.35 202.65,10.89 204.03,10.89 204.66,11.52 205.9,11.52 206.64,12.26 226.96,12.26 227.81,11.41 237.84,11.41 238.56,10.69 239.83,10.69 241.56,8.96 246.89,8.96 247.24,9.32 247.59,9.32 247.68,9.22 v1(247.68,8.77)
  BOTTOM w0.099: v1(193.43,22.8) 193.91,23.28 194.08,23.28 194.11,23.31 194.94,23.31 195.03,23.4 195.13,23.4 UH1.B33
PCIE_PTX_DRX_P12: length 3.3
  TOP w0.099: v1(250.82,10.86) 251.01,10.67 251.01,10.15 CH208.2
  BOTTOM w0.099: v1(250.82,10.86) 251.11,11.16 251.11,12.02 251.02,12.11 JSSD3.13
PCIE_PTX_DRX_P12_C: length 74.2
  TOP w0.099: v1(249.5,8.93) 249.89,8.54 250.95,8.54 251.2,8.79 251.2,9.03 CH208.1
  IN4 w0.097: v1(249.5,8.93) 249.25,8.67 249.13,8.67 248.53,8.07 241.78,8.07 239.63,10.21 238.37,10.21 237.64,10.94 227.61,10.94 226.76,11.78 206.87,11.78 206.12,11.04 204.86,11.04 204.23,10.41 202.45,10.41 201.99,10.88 198.46,10.88 196.67,12.67 196.67,14.07 196.46,14.27 196.46,15.1 196.03,15.53 194.95,15.53 194.38,16.1 194.38,17.3 194.73,17.65 194.73,18.54 194.33,18.94 194.33,19.92 194.89,20.48 194.89,21.43 194.4,21.92 193.6,21.92 v1(193.32,22.2)
  BOTTOM w0.089: v1(193.32,22.2) 193.52,22 193.62,22 194.13,22.51 194.38,22.51 194.44,22.57 194.88,22.57 194.98,22.67 194.98,22.81 194.91,22.88 194.81,22.88 UH1.A35
PCIE_PTX_DRX_P13: length 6.1
  TOP w0.099: CH207.2 329.94,37.17 329.43,37.17 v1(329.27,37.01)
  BOTTOM w0.099: v1(329.27,37.01) 329.06,37.22 328.75,37.22 328.39,37.58 328.39,38.6 327.72,39.27 326.97,39.27 326.8,39.11 JSSD1.37
PCIE_PTX_DRX_P13_C: length 165.3
  TOP w0.099: v1(331.38,36.96) 331.18,37.16 330.98,37.16 CH207.1
  IN1 w0.097: v1(192.71,21.56) 192.64,21.49 192.64,21.22 192.74,21.11 192.86,21.11 192.95,21.02 193.23,21.02 193.43,20.82 193.43,18.95 193.67,18.7 194.94,18.7 195.97,17.68 196.46,17.68 197.15,16.99 197.15,16.89 197.41,16.63 197.79,16.63 200.45,13.96 205.88,13.96 206.81,13.03 212.66,13.03 212.75,13.12 229.74,13.12 231.56,14.94 236.73,14.94 237.49,15.7 237.49,16.43 238.17,17.1 256.67,17.1 263.3,23.73 268.38,23.73 270.85,26.2 275.55,26.2 275.85,25.89 275.85,24.79 276.48,24.16 280.36,24.16 282.5,26.3 289.68,26.3 290.82,27.45 291.91,27.45 292.13,27.67 294.05,27.67 295.35,26.37 301.87,26.37 306.2,30.71 325.19,30.71 326.28,31.79 329.46,31.79 332.37,34.69 332.37,36.81 331.95,37.22 331.62,37.22 331.38,36.98 v1(331.38,36.96)
  BOTTOM w0.089: UH1.B36 195.1,22.21 194.59,22.21 194.53,22.15 194.33,22.15 193.98,21.8 193.98,21.8 193.68,21.5 193.68,21.48 193.35,21.15 193.35,21.15
  BOTTOM w0.099: v1(192.71,21.56) 192.58,21.56 192.48,21.46 192.48,21.24 192.56,21.15 193.35,21.15
PCIE_PTX_DRX_P14: length 4.7
  TOP w0.099: v1(329.25,35.71) 329.41,35.87 329.87,35.87 CH205.2
  BOTTOM w0.099: JSSD1.49 326.65,36.11 326.77,36.22 326.93,36.22 327.24,35.91 329.05,35.91 v1(329.25,35.71)
PCIE_PTX_DRX_P14_C: length 155
  TOP w0.099: v1(331.4,35.6) 331.19,35.81 330.95,35.81 CH205.1
  IN1 w0.097: v1(331.4,35.6) 330.94,35.6 330.84,35.51 330.84,33.94 329.17,32.27 326.08,32.27 325,31.18 306.01,31.18 302.6,27.78 299.99,27.78 299.35,28.41 292.2,28.41 291.71,27.93 290.53,27.93 289.44,26.83 281.95,26.83 280.91,25.79 278.98,25.79 278.64,26.14 276.28,26.14 275.65,26.77 270.74,26.77 270.32,26.34 265.14,26.34 256.38,17.58 237.97,17.58 236.64,16.25 233.97,16.25 233.71,15.99 231.93,15.99 229.55,13.6 211.64,13.6 211.31,13.93 210.44,13.93 210.15,13.64 208.03,13.64 207.05,14.62 201.27,14.62 197.73,18.16 196.62,18.16 196.21,18.57 196.21,18.99 194.91,20.29 194.91,21.03 195.4,21.55 195.68,21.57 v1(196.13,21.24)
  BOTTOM w0.099: v1(196.13,21.24) 196.13,21.32 196.03,21.42 195.78,21.42 195.68,21.32 UH1.C38
PCIE_PTX_DRX_P17: length 2.7
  BOTTOM w0.099: CH215.1 269.77,11.86 270.11,11.86 270.67,12.41 270.91,12.41 271.06,12.25 JSSD2.49
PCIE_PTX_DRX_P17_C: length 82.3
  IN3 w0.099: v1(268.17,11.77) 268.17,12.36 267.87,12.66 266.52,12.66 265.4,11.54 258.37,11.54 256.95,10.11 253.38,10.11 252.94,9.67 227.04,9.67 225.91,10.79 220.07,10.79 219.46,11.39 214.78,11.39 214.37,10.98 199.62,10.98 198.38,12.22 198.38,15.59 198.05,15.92 197.72,15.92 v1(197.61,16.03)
  BOTTOM w0.099: CH215.2 268.69,11.65 268.61,11.73 268.61,12.12 268.5,12.23 268.29,12.23 268.04,11.99 268.04,11.9 v1(268.17,11.77) ; UH1.F45 196.86,17.54 196.86,15.84 197.03,15.67 197.26,15.67 v1(197.61,16.03)
PCIE_PTX_DRX_P18: length 2.3
  BOTTOM w0.099: CH217.1 269.99,15.3 270.5,15.3 270.6,15.4 270.92,15.4 271.06,15.25 JSSD2.37
PCIE_PTX_DRX_P18_C: length 81.6
  IN3 w0.099: v1(268.8,14.6) 268.59,14.82 268.59,14.97 268.36,15.19 267.71,15.19 267.45,14.92 266.9,14.92 264.85,12.87 257.82,12.87 256.42,11.47 246.43,11.47 246.2,11.7 242.82,11.7 242.56,11.44 242.24,11.44 241.79,11 227.59,11 226.46,12.12 220.71,12.12 220.11,12.73 214.23,12.73 213.82,12.31 206.87,12.31 205.62,13.55 201.42,13.55 199.65,15.33 199.65,16.99 198.89,17.75 197.79,17.75 197.58,17.54 v1(197.58,17)
  BOTTOM w0.099: CH217.2 268.74,15.52 268.61,15.52 268.4,15.31 268.4,15 v1(268.8,14.6) ; v1(197.58,17) 197.55,17.02 197.55,17.5 197.44,17.62 197.44,17.95 197.63,18.13 UH1.G44
PCIE_PTX_DRX_P19: length 3.3
  BOTTOM w0.099: CH220.2 269.2,17.81 269.96,17.81 270.56,18.41 270.77,18.41 270.92,18.25 JSSD2.25
PCIE_PTX_DRX_P19_C: length 80.8
  IN3 w0.099: v1(201.06,15.65) 201.58,16.17 202.02,16.17 203.31,14.89 207.26,14.89 208.51,13.65 210.47,13.65 210.91,14.08 220.72,14.08 221.34,13.45 227.02,13.45 228.14,12.33 231.09,12.33 231.55,12.8 232.48,12.8 232.95,12.33 240.5,12.33 241.01,12.83 242.03,12.83 242.29,13.09 246.75,13.09 247.03,12.81 255.87,12.81 257.27,14.2 264.3,14.2 265.57,15.48 265.57,15.79 267.11,17.33 268.02,17.33 268.31,17.04 268.31,16.53 v1(268.35,16.49)
  BOTTOM w0.099: v1(268.35,16.49) 268.08,16.49 267.8,16.77 267.8,17.53 268.1,17.82 268.17,17.82 CH220.1 ; v1(201.06,15.65) 201.47,16.06 201.47,16.21 201.33,16.35 199.52,16.35 198.25,17.62 198.25,17.82 197.99,18.07 197.99,18.21 198.08,18.3 198.18,18.3 UH1.H44
PCIE_PTX_DRX_P20: length 2.3
  BOTTOM w0.099: JSSD2.13 270.92,21.25 270.85,21.32 269.94,21.32 CH218.2
PCIE_PTX_DRX_P20_C: length 78.5
  IN3 w0.099: v1(268.09,20.49) 268.09,19.35 267.3,18.55 264.22,18.55 261.01,15.35 256.79,15.35 255.4,13.95 247.51,13.95 247.22,14.24 241.81,14.24 241.55,13.98 240.53,13.98 240.03,13.47 233.45,13.47 232.41,14.52 231.61,14.52 230.57,13.47 228.62,13.47 227.48,14.62 221.8,14.62 221.19,15.22 216.58,15.22 216.51,15.16 211.17,15.16 211.07,15.26 208.77,15.26 207.85,16.18 207.25,16.18 206.9,16.53 202.95,16.53 202.21,17.27 201.75,17.27 v1(201.62,17.14)
  BOTTOM w0.099: v1(201.62,17.14) 201.52,17.24 201,17.24 200.83,17.07 199.86,17.07 199.02,17.91 198.84,17.91 UH1.J45 ; CH218.1 268.63,21.48 268.29,21.48 267.81,21 267.81,20.77 v1(268.09,20.49)
PCIE_RBIAS: length 1.1
  TOP w0.089: UT1.N16 v1(183.25,163.81)
  BOTTOM w0.107: v1(183.25,163.81) 183.38,163.68 183.75,163.68 RT3.1
PCIE_WAKE#: length 302.6
  TOP w0.089: v1(217.56,32.87) 217.56,33.43 RH4.1
  TOP w0.107: v1(293.38,10.89) 292.3,9.81 UE5.64
  IN1 w0.097: v1(225.11,32.73) 225.14,32.76 225.15,32.76 226.15,33.76 226.15,37.84 222.46,41.53 222.46,45.95 222.66,46.16 222.66,48.14 222.07,48.74 216.72,48.74 216.08,49.37 216.08,52.53 213.85,54.76 213.85,56.3 209.63,60.51 207.9,60.51 207.65,60.76 206.17,60.76 205.98,60.95 205.98,63.6 206.54,64.16 206.54,67.88 207.72,69.06 207.72,77.76 209.47,79.51 209.47,87.57 211.68,89.78 211.68,92.66 210.77,93.57 210.77,97.93 207.05,101.65 207.05,103.14 202.55,107.64 202.55,109.51 198.1,113.95 198.1,123.84 197.64,124.31 197.64,144.13 202.21,148.7 208.36,148.7 208.65,148.99 215.18,148.99 216.23,150.04 216.23,151.14 216.3,151.21 216.3,152.78 217.27,153.75 223.61,153.75 224.53,154.68 224.53,155.82 225.05,156.34 230.56,156.34 230.63,156.27 234.1,156.27 v1(234.9,157.07)
  IN3 w0.091: v1(293.38,10.89) 298.97,16.48 298.97,17.82 302.21,21.06 302.21,21.87 300.72,23.36 293.3,23.36 290.11,26.55 282.95,26.55 281.67,27.82 266.09,27.82 262.93,24.66 259.26,24.66 257.74,23.14 253.43,23.14 251.63,21.34 251.63,21.04 249.64,19.05 246.02,19.05 245.77,18.8 242.18,18.8 241.38,19.6 233.21,19.6 231.72,21.09 230.17,21.09 229.85,20.76 228.85,20.76 227.71,21.9 226.75,21.9 225.1,23.55 225.1,27.22 224.64,27.67 224.64,32.25 225.04,32.64 225.04,32.66 v1(225.11,32.73)
  IN4 w0.097: v1(217.56,32.87) 217.56,32.8 217.94,32.42 219.54,32.42 220.28,31.69 224.08,31.69 225.04,32.64 225.04,32.66 v1(225.11,32.73)
  BOTTOM w0.107: RL1.2 233.78,157.79 234.21,157.36 234.61,157.36 v1(234.9,157.07) 235.09,156.87 UL1.3
PCIECOMP: length 4.5
  BOTTOM w0.127: RH193.1 191.98,31.9 v2(191.52,32.35)
  BOTTOM w0.254: 194.3,31.81 194.52,31.58 195.39,31.58 195.62,31.36 UH1.C17
  BOTTOM w0.381: RH193.1 192.64,31.81 194.3,31.81
PCIECOMP#: length 3.9
  BOTTOM w0.127: RH193.2 191.74,30.98 v2(191.52,30.77)
  BOTTOM w0.203: 194.11,31.34 194.19,31.26 UH1.B18
  BOTTOM w0.381: 194.11,31.34 193.82,31.34 193.47,30.98 RH193.2
PCIRST#: length 549
  TOP w0.107: v1(209.27,117.19) 209.17,117.29 v1(201.12,117.29) ; RC355.2 127.93,159.21 130.17,159.21 130.5,159.54 v1(130.5,159.78) ; v1(300.61,21.3) 300.61,22 300.74,22.14 UE5.13 300.74,25.4 CE34.1 ; UH3.4 214.12,21.11 214.44,20.8 RH199.1 215.58,20.23 217.18,20.23 217.5,19.91 v1(217.94,19.91)
  IN1 w0.097: v1(233.56,157) 233.31,156.75 230.83,156.75 230.76,156.82 224.85,156.82 224.05,156.02 224.05,154.88 223.56,154.39 217.14,154.39 215.82,153.07 215.82,151.38 215.75,151.31 215.75,150.24 214.98,149.47 208.45,149.47 208.16,149.18 201.92,149.18 199.34,146.59 198.7,146.59 v1(198.12,146.01) 198.12,148.35 196.45,150.02 196.45,153.59 199.23,156.37 201.94,156.37 203.59,158.02 204.59,158.02 207.36,160.79 207.36,163.39 205.03,165.73 203.23,165.73 202.46,164.96 195.29,164.96 194.86,164.53 192.96,164.53 192.24,165.25 191.34,165.25 190.81,165.78 190.81,166.13 190.8,166.15 190.8,167.45 189.21,169.03 188.26,169.03 187.5,169.79 176.57,169.79 173.75,166.98 169.88,166.98 v1(169.63,166.73) ; v1(202.32,93.12) 202.23,93.03 202.23,89.07 199.94,86.78 199.94,76.05 199.06,75.17 199.06,71.6 196.46,69 196.46,67.74 195.66,66.94 195.66,63.03 194.02,61.39 194.02,60.98 192.21,59.16 192.21,52.98 192.1,52.87 192.1,48.8 191.55,48.25 191.55,44.56 192.32,43.78 193.3,43.78 195.91,41.18 196.49,41.18 198.71,38.96 202.57,38.96 203.63,37.9 203.63,31.9 204.76,30.76 207.21,30.76 207.84,30.12 207.84,25.75 208.13,25.46 209.53,25.46 210.64,24.35 210.64,23.84 211.07,23.41 213.54,23.41 217.05,19.91 v1(217.94,19.91) ; v1(300.61,21.3) 301.18,20.73 309.63,20.73 314.08,25.18 315.12,25.18 318.93,28.99 328.18,28.99 334.54,35.35 v1(335.17,35.35)
  IN3 w0.091: v1(300.61,21.3) 300.2,21.71 298.23,21.71 297.82,21.3 292.38,21.3 291.98,21.71 288.47,21.71 286.02,24.16 276.05,24.16 275.28,24.92 v1(275.28,24.92) 275.28,25.05 274.57,25.76 269.07,25.76 266.2,22.89 266.2,22.33 265.5,21.63 259.17,21.63 256.01,18.47 252,18.47 250.46,16.92 246.84,16.92 246.63,16.72 240.09,16.72 239.54,16.16 v1(239.34,16.16) 238.17,17.34 223.85,17.34 222.85,18.34 221.17,18.34 219.98,19.53 218.32,19.53 v1(217.94,19.91)
  IN4 w0.097: v1(169.63,166.73) 169.29,166.73 169.13,166.58 163.51,166.58 162.63,165.7 162.63,159.8 162.01,159.18 152.04,159.18 150.56,157.69 149.64,157.69 149.27,157.32 141.74,157.32 141.02,156.6 134.71,156.6 134.28,157.03 134.28,157.96 133.2,159.04 131.25,159.04 v1(130.5,159.78)
  BOTTOM w0.107: v1(233.56,157) 234.01,157 234.41,156.6 234.41,156.6 234.69,156.31 UL1.2 ; JWLAN.44 313.07,39.86 311.67,38.45 307.6,38.45 306.85,37.7 306.85,29.44 304.32,26.91 304.32,25.02 v1(300.61,21.3) ; v1(239.34,16.16) 239.34,16.14 238.49,15.29 238.49,10.83 238.08,10.43 238.08,7.7 238.69,7.09 240.96,7.09 241.77,6.28 JSSD3.50 ; v1(275.28,24.92) 275.79,24.41 275.79,14.07 277.85,12.01 JSSD2.50 ; v1(202.32,93.12) 202.29,93.16 198.21,93.16 197.59,93.78 195.74,93.78 192.57,96.95 192.57,103.89 194.98,106.3 199.74,106.3 203.43,109.99 203.43,115.92 202.06,117.29 v1(201.12,117.29) 198.36,120.06 198.36,145.15 198.12,145.4 v1(198.12,146.01) ; v1(335.17,35.35) 334.67,35.86 JSSD1.50 ; RT1.1 176.03,165.39 174.48,166.93 169.96,166.93 169.77,166.74 169.64,166.74 v1(169.63,166.73) ; v1(209.27,117.19) 209.37,117.19 210.24,118.06 UG2.2
PD_EE_CLK: length 5.1
  BOTTOM w0.107: RT101.2 196.27,157 196.67,157.4 198.14,157.4 199.18,158.43 v2(199.18,158.78) 199.18,160.04 UT4.A3
PD_EE_CS_N: length 22.2
  TOP w0.107: v1(198.38,158.4) v2(197.3,158.4) 196.1,158.4 195.18,157.48 193,157.48 192.19,158.3 190.85,158.3 190.61,158.06 190.61,155.63 v1(191.14,155.1)
  BOTTOM w0.076: 198.91,159.65 198.91,160.32 UT4.B3
  BOTTOM w0.107: 198.91,159.65 198.91,159.31 198.38,158.78 v1(198.38,158.4) ; RT100.2 187.52,159.54 187.78,159.29 189.05,159.29 190.13,158.21 190.13,155.42 190.45,155.1 v1(191.14,155.1)
PD_EE_DI: length 5
  BOTTOM w0.076: UT4.B4 199.65,160.57 199.41,160.32 199.41,159.15 199.59,158.97
  BOTTOM w0.107: 199.59,158.97 199.59,158.27 v2(198.7,157.39) 198.32,157 RT98.2
PD_EE_DO: length 8.9
  TOP w0.107: v1(199.72,157.77) 199.27,157.32 196.08,157.32 v2(195.8,157.04) 194.94,156.18 194.64,156.18 v1(194.64,156.18)
  BOTTOM w0.107: v1(194.64,156.18) 194.64,156.18 194.76,156.05 RT99.2 ; 199.84,158.26 199.84,159.16 199.66,159.35 UT4.A4
  BOTTOM w0.127: v1(199.72,157.77) 199.84,157.89 199.84,158.26
PD_IRQ#: length 260.9
  TOP w0.107: v1(299.47,14.15) 299.47,12.62 302.62,9.47 302.62,9.2 302.74,9.09 UE5.89
  IN2 w0.091: v1(201.05,157.64) 200.73,157.64 200.01,156.92 198.22,156.92 195.31,154.01 195.31,149.49 199.05,145.74 199.05,111.54 201.25,109.35 201.25,96.49 201.69,96.04 201.69,77.77 202.02,77.44 202.02,75.54 201.92,75.44 201.92,71.83 200.98,70.89 200.98,68.49 201.57,67.91 202.82,67.91 202.82,67.91 205.91,67.91 207.99,65.83 212.24,65.83 213.31,66.9 223.2,66.9 223.66,67.37 223.67,67.37 223.71,67.42 223.85,67.42 224,67.57 249.85,67.57 250.03,67.38 266.49,67.38 266.65,67.53 274.28,67.53 280.57,61.25 280.57,48.2 282.47,46.29 294.07,46.29 295,47.23 v1(295.54,47.23)
  BOTTOM w0.076: UT4.B6 200.41,160.32 200.41,159.77 200.55,159.62
  BOTTOM w0.089: 200.55,159.62 201.09,159.08 201.09,158.85
  BOTTOM w0.107: 201.09,158.85 201.09,158 201.05,157.96 v1(201.05,157.64) 202.92,157.64 RT107.2 ; v1(295.54,47.23) 295.93,46.84 295.93,45.48 297.84,43.57 297.84,41.3 297.74,41.21 297.74,31.69 299.35,30.09 299.35,27.12 298.09,25.87 298.09,24.75 297.6,24.25 297.6,19.97 298.4,19.17 298.4,15.19 299.45,14.15 v1(299.47,14.15)
PD_RESET: length 216.3
  TOP w0.107: RT109.1 201.04,167.58 201.32,167.3 v2(201.51,167.3) 206.57,167.3 206.84,167.57 208.91,167.57 v1(209.05,167.43) ; UE10.8 311.25,50.08 v1(311.33,50)
  IN3 w0.091: v1(209.05,167.43) 209.18,167.43 211.52,169.78 218.24,169.78 218.4,169.62 224,169.62 224.28,169.9 225.38,169.9 226.19,169.09 230.14,169.09 232.58,171.53 237.82,171.53 242.5,166.85 242.5,164.55 242.88,164.17 242.88,158.03 242.5,157.65 242.5,150.69 244.08,149.11 254.46,149.11 255.48,150.13 264.43,150.13 275.5,139.06 282.91,139.06 285.79,136.18 285.79,96.5 289.23,93.05 289.23,87.9 291.14,86 291.14,80.09 293.46,77.78 293.46,76.01 298.22,71.24 298.22,63.86 303.28,58.8 303.28,52.36 306.43,49.21 309.56,49.21 310.36,50 v1(311.33,50)
PD_UART: length 3.2
  TOP w0.107: RT62.1 198.14,161.91 v1(197.62,162.43) 197.39,162.43 v2(197.11,162.15)
  BOTTOM w0.076: UT4.E2 198.53,162.07 198.28,162.32 197.73,162.32 v1(197.62,162.43)
  BOTTOM w0.127: UT4.E2 UT4.F2
PECI_KB9012: length 2.1
  TOP w0.107: UE5.118 308.7,18.21 RE76.1
PEG_CRX_C_GTX_N8: length 2.5
  BOTTOM w0.099: CM69.2 135.01,151.46 135.01,152.05 134.76,152.31 134.76,152.94 134.61,153.08 UM8.4
PEG_CRX_C_GTX_N9: length 2.5
  BOTTOM w0.099: CM66.2 132.41,151.47 v3(132.41,152.04) 132.41,152.38 132.7,152.67 132.7,152.89 132.61,152.98 UM8.8
PEG_CRX_C_GTX_N10: length 4.5
  BOTTOM w0.099: UM8.6 133.61,152.79 133.75,152.65 v3(133.75,152.05) 133.75,151.31 133.61,151.18 133.61,150.84 133.58,150.81 133.58,150.12 133.61,150.08 133.61,149.62 CM62.2
PEG_CRX_C_GTX_N11: length 4.6
  BOTTOM w0.099: CM65.2 136.34,149.56 136.34,150.46 136.31,150.49 136.31,151.07 136.34,151.1 136.34,151.87 v3(136.09,152.12) 135.78,152.43 135.78,152.74 135.61,152.91 UM8.2
PEG_CRX_C_GTX_P8: length 2.6
  BOTTOM w0.099: CM67.2 135.2,151.5 135.2,152.13 134.95,152.39 134.95,152.89 135.11,153.05 UM8.3
PEG_CRX_C_GTX_P9: length 2.6
  BOTTOM w0.099: CM63.2 132.63,151.47 132.63,152.33 132.89,152.59 132.89,152.75 133.11,152.97 UM8.7
PEG_CRX_C_GTX_P10: length 4.4
  BOTTOM w0.099: UM8.5 134.11,152.79 133.98,152.65 133.98,151.27 133.8,151.1 v3(133.8,150.46) 133.8,149.54 CM68.2
PEG_CRX_C_GTX_P11: length 4.6
  BOTTOM w0.099: UM8.1 136.11,152.9 135.97,152.76 135.97,152.56 136.53,152 v3(136.53,150.78) 136.53,149.6 CM64.2
PEG_CRX_GTX_N0: length 37.7
  TOP w0.099: v1(195.66,95.4) 195.76,95.5 195.76,96.08 196.04,96.36 198.46,96.36 198.59,96.24 199.78,96.24 199.88,96.33 200.54,96.33 CG2.2
  IN3 w0.099: v1(170.05,99.89) 170.05,99.7 170.21,99.54 170.51,99.54 171.14,98.9 172.35,98.9 172.86,98.39 172.86,96.43 173.45,95.83 185.7,95.83 187.87,93.67 190.3,93.67 191.64,95.02 194.63,95.02 195.11,94.54 195.64,94.54 195.74,94.64 195.74,95.32 v1(195.66,95.4)
  BOTTOM w0.076: v1(170.05,99.89) 170.05,99.81 CPU1.E10
PEG_CRX_GTX_N0_C: length 26.3
  TOP w0.099: CG2.1 201.62,96.55 201.68,96.49 201.68,96.21 201.78,96.11 203.16,96.11 204.85,94.42 205.24,94.42 205.27,94.45 205.85,94.45 205.88,94.42 210.96,94.42 219.42,85.96 221.47,85.96 221.57,86.06 221.57,86.26 v1(221.27,86.56)
  BOTTOM w0.099: v1(221.27,86.56) 221.72,87.01 UG1.AR39
PEG_CRX_GTX_N1: length 37.4
  TOP w0.099: v1(198.76,97.97) 198.66,98.07 198.48,98.07 198.38,97.97 198.38,97.36 198.55,97.19 v3(199.27,97.19) 199.91,97.19 200.07,97.35 202.19,97.35 CG4.2
  IN3 w0.099: v1(198.76,97.97) 198.48,97.69 198.48,96.58 198.13,96.24 189.51,96.24 188.87,95.6 187,95.6 184.57,98.04 174.18,98.04 172.99,99.22 171.16,99.22 170.95,99.43 170.95,99.63 v1(170.71,99.87)
  BOTTOM w0.076: CPU1.E11 170.38,100.2 v1(170.71,99.87)
PEG_CRX_GTX_N1_C: length 25.4
  TOP w0.099: CG4.1 203.18,97.38 203.78,97.38 v3(204.29,96.87) 205.55,95.6 210.91,95.6 219.31,87.21 222.56,87.21 222.97,87.61 v1(222.97,87.8)
  BOTTOM w0.099: v1(222.97,87.8) 223.42,88.25 UG1.AN37
PEG_CRX_GTX_N2: length 36.5
  TOP w0.099: CG6.2 200.69,98.46 199.67,98.46 198.65,99.48 197.63,99.48 197.3,99.15 197.3,99.01 197.09,98.8 v1(197.08,98.8)
  IN3 w0.099: v1(197.08,98.8) 197.27,98.8 197.43,98.96 197.43,99.15 197.29,99.29 195.14,99.29 194.33,98.48 190.62,98.48 188.82,100.28 179.38,100.28 179.28,100.18 179.28,99.62 179.07,99.41 178.62,99.41 178.41,99.62 178.41,100.18 178.31,100.28 171.09,100.28 170.31,101.06 170.12,101.06 169.93,100.87 169.93,100.73 170.04,100.62 v1(170.06,100.62)
  BOTTOM w0.089: v1(170.06,100.62) 170.06,100.85 170.26,101.05 CPU1.E12
PEG_CRX_GTX_N2_C: length 27
  TOP w0.099: CG6.1 201.5,98.48 204.19,98.48 205.36,97.31 205.56,97.31 205.59,97.34 206.17,97.34 206.19,97.31 206.75,97.31 206.96,97.1 206.96,96.72 207.06,96.62 207.36,96.62 207.46,96.72 207.46,97.04 207.86,97.44 210.2,97.44 219.09,88.55 221,88.55 221.09,88.47 221.45,88.47 v1(222.07,87.85)
  BOTTOM w0.099: v1(222.07,87.85) 222.07,87.85 UG1.AN38
PEG_CRX_GTX_N3: length 37.8
  TOP w0.099: CG8.2 202.28,99.6 201.21,99.6 201.11,99.7 201.11,100.24 200.9,100.45 200.42,100.45 200.16,100.19 200.16,99.51 200.06,99.41 199.85,99.41 198.58,100.68 194.78,100.68 194.51,100.41 194.51,100.2 v1(194.32,100.01)
  IN3 w0.099: v1(170.71,101.45) 170.86,101.45 171.04,101.26 171.04,101.01 171.25,100.81 172.46,100.81 173.15,101.49 177.86,101.49 178.41,100.94 189.1,100.94 190.82,99.22 192.79,99.22 194.08,100.51 194.54,100.51 194.66,100.39 194.66,100.23 194.44,100.01 v1(194.32,100.01)
  BOTTOM w0.076: v1(170.71,101.45) 170.38,101.77 CPU1.E13
PEG_CRX_GTX_N3_C: length 25.1
  TOP w0.099: v1(222.2,89.04) 221.98,89.26 221.98,89.46 221.61,89.83 219.07,89.83 212.94,95.96 212.94,97.07 211.71,98.31 205.54,98.31 v3(204.74,99.1) 204.24,99.6 203.12,99.6 CG8.1
  BOTTOM w0.099: UG1.AM38 v1(222.2,89.04)
PEG_CRX_GTX_N4: length 34.9
  TOP w0.099: CG10.2 200.48,101.7 200.35,101.82 200.35,102.01 200.22,102.14 199.1,102.14 198.78,101.82 197.58,101.82 197.35,101.6 197.35,101.46 v1(197.56,101.25)
  IN3 w0.099: v1(170.05,103) 170.23,102.82 170.39,102.82 171.06,102.15 178.09,102.15 178.45,101.79 189.45,101.79 191.17,100.07 192.32,100.07 194.22,101.97 197.16,101.97 197.41,101.72 197.41,101.39 v1(197.56,101.25)
  BOTTOM w0.076: v1(170.05,103) 170.05,102.96 CPU1.E14
PEG_CRX_GTX_N4_C: length 28.1
  TOP w0.099: v1(222.17,90.2) 222.24,90.13 222.38,90.13 222.57,90.32 222.57,90.48 222.35,90.71 219.13,90.71 216.35,93.49 216.35,94.52 211.96,98.91 206.75,98.91 203.78,101.89 203.02,101.89 202.99,101.86 202.41,101.86 202.38,101.89 201.53,101.89 CG10.1
  BOTTOM w0.099: v1(222.17,90.2) 221.72,90.65 UG1.AK39
PEG_CRX_GTX_N5: length 37.1
  TOP w0.099: v1(195.5,102.5) 195.64,102.64 195.64,102.97 196.06,103.39 202.26,103.39 CG12.2
  IN3 w0.099: v1(195.5,102.5) 195.59,102.58 195.59,102.72 195.41,102.9 194.61,102.9 194.16,102.45 192.99,102.45 192.81,102.27 192.81,101.65 192.6,101.44 192.15,101.44 191.94,101.65 191.94,102.17 191.84,102.27 191.54,102.27 191.45,102.17 191.45,101.65 191.24,101.44 190.79,101.44 190.58,101.65 190.58,102.17 189.88,102.87 178.72,102.87 178.6,102.99 173.73,103 173.19,102.46 171.38,102.46 171.08,102.76 171.08,102.9 170.9,103.08 170.76,103.08 v1(170.71,103.02)
  BOTTOM w0.076: v1(170.71,103.02) CPU1.E15
PEG_CRX_GTX_N5_C: length 26.6
  TOP w0.099: CG12.1 203.21,103.32 204.02,103.32 v3(204.52,102.82) 205.76,101.58 205.8,101.58 206.2,101.17 206.2,101.13 207.43,99.91 212.51,99.91 215.17,97.25 215.46,97.25 217.37,95.34 217.37,94.09 219.1,92.36 220.05,92.36 220.42,91.99 222.53,91.99 222.97,92.44 v1(222.97,92.6)
  BOTTOM w0.099: v1(222.97,92.6) 223.42,92.15 UG1.AJ37
PEG_CRX_GTX_N6: length 34.4
  TOP w0.099: v1(196.49,103.88) 196.73,104.13 196.73,104.49 197.43,105.19 CG14.2
  IN3 w0.099: v1(170.06,103.81) 169.95,103.92 169.95,104.07 170.06,104.17 170.29,104.17 170.93,103.54 193.81,103.54 194.72,104.45 196.77,104.45 196.91,104.31 196.91,103.98 196.72,103.79 196.58,103.79 v1(196.49,103.88)
  BOTTOM w0.089: v1(170.06,103.81) 170.06,103.88 CPU1.E16
PEG_CRX_GTX_N6_C: length 31.4
  TOP w0.099: v1(222.17,92.6) 221.94,92.83 221.94,92.95 221.67,93.23 219.38,93.23 218.17,94.44 218.17,101.24 214.83,104.58 209.85,104.58 209.29,104.02 207.74,104.02 206.83,104.93 206.19,104.93 206.17,104.96 205.59,104.96 205.56,104.93 201.6,104.93 CG14.1
  BOTTOM w0.099: UG1.AJ38 222.17,92.45 v1(222.17,92.6)
PEG_CRX_GTX_N7: length 35.4
  TOP w0.099: CG16.2 196.91,106.46 196.16,105.7 196.16,105.37 195.91,105.13 v1(195.85,105.13)
  IN3 w0.099: v1(195.85,105.13) 196,105.13 196.16,105.29 196.16,105.43 195.98,105.61 191.13,105.61 189.71,104.2 176.25,104.2 175.83,104.62 173.16,104.62 172.52,103.98 171.16,103.98 170.96,104.19 170.96,104.53 170.86,104.63 170.68,104.63 v1(170.65,104.6)
  BOTTOM w0.076: CPU1.E17 170.65,104.67 v1(170.65,104.6)
PEG_CRX_GTX_N7_C: length 29.2
  TOP w0.099: v1(222.17,93.8) 221.94,94.03 221.94,94.29 221.64,94.58 219.33,94.58 219.1,94.81 219.1,101.44 215.16,105.38 210.04,105.38 209.39,106.04 207.67,106.04 207.67,106.04 205.81,106.04 205.61,106.24 v3(204.42,106.24) 203.21,106.24 CG16.1
  BOTTOM w0.099: v1(222.17,93.8) 222.17,93.65 UG1.AG38
PEG_CRX_GTX_N8: length 116.6
  IN3 w0.099: v1(170.06,105.39) 170.24,105.57 170.44,105.57 171,105 173.7,105 174.25,105.55 174.25,106.03 175.12,106.9 175.12,107.59 176.15,108.62 177.52,108.62 183.02,114.12 183.02,120.76 184.53,122.27 189.82,127.56 189.82,145.93 185.71,150.04 177.62,150.04 176.81,150.84 174.39,150.84 173.67,151.56 167.25,151.56 165.53,153.28 163.85,153.28 162.77,152.2 158.72,152.2 155.58,155.35 141.66,155.35 141.45,155.14 139.88,155.14 134.82,150.08 134.82,149.64 v1(134.75,149.57)
  BOTTOM w0.076: CPU1.F18 169.73,105.71 v1(170.06,105.39)
  BOTTOM w0.099: CM69.1 135.01,150.22 135.01,149.83 v1(134.75,149.57)
PEG_CRX_GTX_N9: length 115.8
  IN3 w0.099: v1(171.36,106.17) 171.34,106.2 171.19,106.2 171.06,106.06 171.06,105.79 171.16,105.69 172.59,105.69 174.19,107.29 174.19,107.88 175.88,109.57 175.88,110.77 177.09,111.98 179.49,111.98 182.16,114.65 182.16,121.11 183.68,122.63 183.68,122.63 188.97,127.92 188.97,145.57 185.36,149.18 177.26,149.18 176.49,149.96 167.55,149.96 166.16,151.35 158.37,151.35 155.62,154.1 141.96,154.1 138.54,150.68 137.55,150.68 135.28,148.41 132.9,148.41 132.47,148.84 132.47,149.12 132.08,149.5 131.94,149.5 v1(131.89,149.45)
  BOTTOM w0.076: v1(171.36,106.17) 171.03,106.5 CPU1.D19
  BOTTOM w0.099: v1(131.89,149.45) 132.28,149.84 132.28,150.35 CM66.1
PEG_CRX_GTX_N10: length 113.9
  IN3 w0.099: v1(170.07,106.96) 170.57,106.96 170.89,106.64 172.59,106.64 173.24,107.28 173.24,108.05 173.49,108.3 173.95,108.3 175.37,109.71 175.37,110.89 176.73,112.25 176.73,112.84 177.21,113.32 180.15,113.32 181.68,114.85 181.68,121.31 188.49,128.11 188.49,145.37 185.16,148.7 177.06,148.7 176.35,149.41 167.42,149.41 165.96,150.87 158.16,150.87 155.41,153.62 142.29,153.62 137.6,148.93 136.48,148.93 135.48,147.93 134.03,147.93 133.49,147.39 133.49,147.14 133.39,147.04 v1(133.21,147.04)
  BOTTOM w0.076: v1(170.07,106.96) 169.73,107.3 CPU1.F20
  BOTTOM w0.099: CM62.1 133.55,148.32 133.55,147.38 v1(133.21,147.04)
PEG_CRX_GTX_N11: length 107.3
  IN3 w0.099: v1(171.42,107.75) 171.42,107.76 171.3,107.88 171.16,107.88 171.02,107.73 171.02,107.58 171.32,107.28 172.22,107.28 172.54,107.61 172.54,109.2 173.16,109.82 173.82,109.82 174.38,110.38 174.38,111 175.6,112.22 175.6,112.92 177,114.33 178.8,114.33 180.82,116.35 180.82,122.12 187.59,128.89 187.59,145.07 184.81,147.85 176.71,147.85 176,148.56 167.06,148.56 165.61,150.02 157.8,150.02 155.04,152.77 142.97,152.77 138.31,148.12 138.31,147.48 137.66,146.82 136.98,146.82 136.54,147.27 136.51,147.27 136.17,147.61 v1(136.09,147.61)
  BOTTOM w0.076: v1(171.42,107.75) 171.36,107.75 171.03,108.07 CPU1.D21
  BOTTOM w0.099: CM65.1 136.34,148.32 136.34,147.86 v1(136.09,147.61)
PEG_CRX_GTX_P0: length 38.1
  TOP w0.099: CG1.2 200.54,96.14 199.96,96.14 199.86,96.04 198.51,96.04 198.38,96.17 196.12,96.17 195.95,96 195.95,95.81 196.03,95.73 196.25,95.73 196.35,95.63 196.35,95.47 v1(196.28,95.4)
  IN3 w0.099: v1(196.28,95.4) 195.92,95.05 195.92,94.56 195.72,94.36 195.03,94.36 194.55,94.83 191.72,94.83 190.37,93.48 187.79,93.48 185.63,95.65 173.37,95.65 172.67,96.35 172.67,98.32 172.27,98.72 171.06,98.72 170.43,99.35 170.16,99.35 170.06,99.25 170.06,99.05 v1(170.06,99.05)
  BOTTOM w0.076: v1(170.06,99.05) 170.06,99.09 169.73,99.41 CPU1.F10
PEG_CRX_GTX_P0_C: length 26.3
  TOP w0.099: CG1.1 203.08,95.92 204.77,94.23 v3(205.56,94.23) 210.88,94.23 219.34,85.77 221.55,85.77 221.76,85.98 221.76,86.16 v1(222.17,86.56)
  BOTTOM w0.099: v1(222.17,86.56) 222.17,86.75 UG1.AR38
PEG_CRX_GTX_P1: length 37
  TOP w0.099: CG3.2 202.18,97.16 200.15,97.16 199.99,97 199.59,97 199.56,96.97 198.98,96.97 198.95,97 198.47,97 198.19,97.28 198.19,97.75 v1(197.95,97.99)
  IN3 w0.099: v1(197.95,97.99) 198.19,97.99 198.29,97.89 198.29,96.66 198.06,96.43 189.43,96.43 188.79,95.79 187.08,95.79 184.65,98.22 174.25,98.22 173.07,99.41 171.23,99.41 171.13,99.51 171.13,99.65 v1(171.36,99.87)
  BOTTOM w0.076: v1(171.36,99.87) 171.31,99.87 171.03,100.15 CPU1.D11
PEG_CRX_GTX_P1_C: length 25.4
  TOP w0.099: v1(222.97,86.6) 222.97,86.87 222.83,87.01 219.23,87.01 210.83,95.41 205.47,95.41 204.38,96.51 204.34,96.51 203.93,96.92 203.93,96.96 203.7,97.18 203.24,97.18 CG3.1
  BOTTOM w0.099: UG1.AR37 223.42,87.05 v1(222.97,86.6)
PEG_CRX_GTX_P2: length 36.2
  TOP w0.099: v1(197.83,98.81) 197.74,98.72 197.6,98.72 197.49,98.83 197.49,99.07 197.71,99.28 198.57,99.28 199.59,98.26 200.44,98.26 CG5.2
  IN3 w0.099: v1(197.83,98.81) 197.62,99.02 197.62,99.22 197.37,99.47 195.06,99.47 194.25,98.66 190.7,98.66 188.9,100.46 179.3,100.46 179.09,100.26 179.09,99.69 178.99,99.59 178.7,99.59 178.6,99.69 178.6,100.26 178.39,100.46 171.17,100.46 170.38,101.25 170.21,101.25 v1(170.04,101.42)
  BOTTOM w0.089: CPU1.F12 169.93,101.05 170.04,101.16 170.04,101.41 v1(170.04,101.42)
PEG_CRX_GTX_P2_C: length 27
  TOP w0.099: CG5.1 201.36,97.97 201.65,97.97 201.75,98.07 201.75,98.19 201.85,98.29 204.11,98.29 205.28,97.12 v3(205.88,97.12) 206.67,97.12 206.77,97.02 206.77,96.64 206.98,96.43 207.44,96.43 207.65,96.64 207.65,96.96 207.94,97.25 210.12,97.25 219.01,88.36 220.92,88.36 221.01,88.28 221.37,88.28 221.55,88.1 221.55,87.96 221.41,87.81 v1(221.28,87.81)
  BOTTOM w0.099: v1(221.28,87.81) 221.72,88.25 UG1.AN39
PEG_CRX_GTX_P3: length 37.5
  TOP w0.099: CG7.2 202.13,99.09 202.07,99.16 202.07,99.31 201.97,99.41 201.13,99.41 200.92,99.62 200.92,100.16 200.82,100.26 200.5,100.26 200.35,100.11 200.35,99.43 200.14,99.22 199.77,99.22 198.5,100.49 194.86,100.49 194.7,100.33 194.7,100.16 194.86,100 v1(194.99,100)
  IN3 w0.099: v1(171.36,101.45) 171.23,101.32 171.23,101.09 171.33,100.99 172.38,100.99 173.07,101.68 177.94,101.68 178.49,101.13 189.17,101.13 190.9,99.4 192.72,99.4 194.01,100.69 194.62,100.69 194.84,100.47 194.84,100.14 v1(194.99,100)
  BOTTOM w0.076: v1(171.36,101.45) 171.03,101.77 CPU1.D13
PEG_CRX_GTX_P3_C: length 25.2
  TOP w0.099: v1(221.34,89.08) 221.69,89.08 221.79,89.18 221.79,89.38 221.53,89.64 218.99,89.64 212.75,95.88 212.75,96.99 211.63,98.11 205.46,98.11 204.83,98.74 204.79,98.74 204.38,99.15 204.38,99.19 204.16,99.41 203.31,99.41 CG7.1
  BOTTOM w0.099: v1(221.34,89.08) 221.38,89.08 221.72,89.42 UG1.AM39
PEG_CRX_GTX_P4: length 35.3
  TOP w0.099: CG9.2 199.02,102.33 198.7,102.02 197.5,102.02 197.16,101.68 197.16,101.43 v1(196.97,101.25)
  IN3 w0.099: v1(170.06,102.22) 169.96,102.22 169.86,102.32 169.86,102.51 169.98,102.63 170.32,102.63 170.98,101.97 178.02,101.97 178.38,101.61 189.37,101.61 191.1,99.88 192.39,99.88 194.3,101.79 197.08,101.79 197.23,101.64 197.23,101.48 196.99,101.25 v1(196.97,101.25)
  BOTTOM w0.076: CPU1.F14 170.06,102.31 v1(170.06,102.22)
PEG_CRX_GTX_P4_C: length 28.1
  TOP w0.099: v1(222.96,90.2) 222.76,90.4 222.76,90.56 222.43,90.9 219.21,90.9 216.54,93.57 216.54,94.6 212.04,99.11 206.83,99.11 203.86,102.08 v3(202.7,102.08) 201.59,102.08 CG9.1
  BOTTOM w0.099: v1(222.96,90.2) 222.62,90.54 UG1.AK38
PEG_CRX_GTX_P5: length 36.8
  TOP w0.099: CG11.2 202.35,102.84 202.1,102.84 202,102.94 202,103.13 201.94,103.19 196.14,103.19 195.84,102.89 195.84,102.75 v1(196.09,102.5)
  IN3 w0.099: v1(196.09,102.5) 196.07,102.5 195.49,103.09 194.54,103.09 194.09,102.64 192.91,102.64 192.62,102.35 192.62,101.73 192.52,101.63 192.23,101.63 192.13,101.73 192.13,102.25 191.92,102.46 191.47,102.46 191.26,102.25 191.26,101.73 191.16,101.63 190.86,101.63 190.76,101.73 190.76,102.25 189.96,103.06 178.8,103.06 178.67,103.18 173.65,103.19 173.11,102.65 171.46,102.65 171.32,102.78 171.32,102.92 v1(171.42,103.02)
  BOTTOM w0.076: CPU1.D15 v1(171.42,103.02)
PEG_CRX_GTX_P5_C: length 26.6
  TOP w0.099: v1(222.97,91.4) 222.97,91.65 222.82,91.8 220.34,91.8 219.97,92.17 219.02,92.17 217.18,94.01 217.18,95.26 215.38,97.05 215.09,97.05 212.43,99.71 207.35,99.71 v3(205.84,101.22) 204.61,102.46 204.57,102.46 204.16,102.86 204.16,102.9 203.94,103.12 203.21,103.12 CG11.1
  BOTTOM w0.099: UG1.AK37 223.42,90.88 222.97,91.33 v1(222.97,91.4)
PEG_CRX_GTX_P6: length 34
  TOP w0.099: v1(197.32,103.88) 196.93,104.28 196.93,104.42 197.51,104.99 200.25,104.99 200.59,104.65 200.6,104.65 CG13.2
  IN3 w0.099: v1(170.06,104.6) 170.3,104.36 170.37,104.36 171,103.72 193.73,103.72 194.64,104.63 196.85,104.63 197.09,104.39 197.09,104.11 v1(197.32,103.88)
  BOTTOM w0.089: CPU1.F16 170.06,104.53 v1(170.06,104.6)
PEG_CRX_GTX_P6_C: length 31.3
  TOP w0.099: CG13.1 201.59,104.74 v3(205.88,104.74) 206.75,104.74 207.66,103.83 209.37,103.83 209.93,104.39 214.75,104.39 217.98,101.16 217.98,94.36 219.3,93.03 221.59,93.03 221.73,92.89 221.73,92.7 221.63,92.6 v1(221.27,92.6)
  BOTTOM w0.099: UG1.AJ39 221.27,92.45 v1(221.27,92.6)
PEG_CRX_GTX_P7: length 35
  TOP w0.099: CG15.2 202.19,105.82 202.07,105.95 202.07,106.16 201.97,106.26 196.99,106.26 196.35,105.62 196.35,105.23 196.45,105.13 v1(196.53,105.13)
  IN3 w0.099: v1(171.36,104.6) 171.14,104.38 171.14,104.27 171.24,104.17 172.45,104.17 173.08,104.8 175.91,104.8 176.32,104.39 189.64,104.39 191.05,105.8 196.06,105.8 196.35,105.51 196.35,105.31 v1(196.53,105.13)
  BOTTOM w0.076: CPU1.D17 171.36,104.67 v1(171.36,104.6)
PEG_CRX_GTX_P7_C: length 29.2
  TOP w0.099: CG15.1 203.21,106.04 204.1,106.04 204.13,106.02 204.7,106.02 204.73,106.04 205.53,106.04 205.73,105.85 207.75,105.85 207.75,105.85 209.31,105.85 209.96,105.19 215.08,105.19 218.91,101.36 218.91,94.73 219.25,94.39 221.56,94.39 221.75,94.21 221.75,93.98 221.65,93.89 221.36,93.89 v1(221.27,93.8)
  BOTTOM w0.099: UG1.AG39 221.27,93.65 v1(221.27,93.8)
PEG_CRX_GTX_P8: length 116.7
  IN3 w0.099: v1(170.06,106.22) 170.02,106.22 169.89,106.09 169.89,105.95 170.09,105.75 170.14,105.75 170.51,105.75 171.08,105.19 173.63,105.19 174.06,105.62 174.06,106.11 174.93,106.98 174.93,107.67 176.07,108.81 177.44,108.81 182.83,114.2 182.83,120.83 184.35,122.35 184.35,122.35 189.64,127.64 189.64,145.85 185.63,149.85 177.54,149.85 176.74,150.65 174.32,150.65 173.6,151.38 167.17,151.38 165.46,153.09 163.92,153.09 162.85,152.02 158.65,152.02 155.5,155.16 141.74,155.16 141.53,154.95 139.95,154.95 135,150.01 135,149.89 135.13,149.76 135.13,149.7 135.31,149.52 135.45,149.52 v1(135.5,149.57)
  BOTTOM w0.089: v1(170.06,106.22) 170.06,106.17 170.38,105.85 CPU1.E18
  BOTTOM w0.099: v1(135.5,149.57) 135.2,149.86 135.2,150.19 CM67.1
PEG_CRX_GTX_P9: length 115.8
  IN3 w0.099: v1(170.71,106.17) 170.87,106.01 170.87,105.71 171.08,105.5 172.67,105.5 174.38,107.22 174.38,107.8 176.07,109.49 176.07,110.69 177.17,111.79 179.56,111.79 182.35,114.58 182.35,121.03 183.87,122.55 189.16,127.84 189.16,145.65 185.43,149.37 177.34,149.37 176.56,150.15 167.63,150.15 166.24,151.54 158.45,151.54 155.7,154.29 141.88,154.29 138.46,150.86 137.47,150.86 135.2,148.6 132.97,148.6 132.65,148.92 v1(132.65,149.51)
  BOTTOM w0.076: v1(170.71,106.17) 170.38,106.5 CPU1.E19
  BOTTOM w0.099: CM63.1 132.47,150.06 132.47,149.69 v1(132.65,149.51)
PEG_CRX_GTX_P10: length 114
  IN3 w0.099: v1(134.11,147.18) 134.11,146.97 134.01,146.87 133.83,146.87 133.7,147.01 133.7,147.34 134.1,147.75 135.56,147.75 136.56,148.75 137.68,148.75 142.37,153.44 155.33,153.44 158.08,150.69 165.88,150.69 167.34,149.23 176.28,149.23 176.99,148.52 185.08,148.52 188.3,145.3 188.3,128.19 181.5,121.39 181.5,114.93 180.08,113.51 177.13,113.51 176.54,112.92 176.54,112.33 175.18,110.97 175.18,109.79 173.87,108.48 173.41,108.48 173.05,108.12 173.05,107.36 172.52,106.83 170.97,106.83 170.65,107.15 170.47,107.15 170.37,107.25 170.37,107.45 v1(170.05,107.77)
  BOTTOM w0.076: v1(170.05,107.77) 170.05,107.69 CPU1.E20
  BOTTOM w0.099: CM68.1 133.74,148.28 133.74,147.35 133.92,147.18 v1(134.11,147.18)
PEG_CRX_GTX_P11: length 107.3
  IN3 w0.099: v1(170.64,107.75) 170.73,107.75 170.83,107.64 170.83,107.5 171.24,107.1 172.3,107.1 172.73,107.53 172.73,109.12 173.24,109.63 173.9,109.63 174.57,110.3 174.57,110.93 175.78,112.15 175.78,112.85 177.08,114.14 178.88,114.14 181.01,116.27 181.01,122.04 187.78,128.81 187.78,145.14 184.88,148.04 176.79,148.04 176.08,148.75 167.14,148.75 165.68,150.21 157.87,150.21 155.12,152.96 142.89,152.96 138.13,148.19 138.13,147.56 137.58,147.01 137.06,147.01 136.73,147.34 v1(136.73,147.63)
  BOTTOM w0.076: v1(170.64,107.75) 170.64,108.06 170.56,108.14 CPU1.E21
  BOTTOM w0.099: v1(136.73,147.63) 136.53,147.82 136.53,148.28 CM64.1
PEG_CRX_TTX_N12: length 99.2
  TOP w0.099: CT16.1 189.08,160.89 189.35,160.62 189.87,160.62 189.9,160.59 190.48,160.59 190.51,160.62 191.39,160.62 192.09,161.32 192.09,162.44 192.45,162.8 192.45,163.93 v1(192.56,164.04)
  IN4 w0.097: v1(170.05,108.53) 170.05,108.53 170.46,108.11 174.37,108.11 175.76,106.73 176.93,106.73 177.54,107.34 177.54,107.84 178.3,108.6 191.12,108.6 193.82,111.29 193.82,112.33 197.92,116.43 197.92,122.34 198.14,122.55 198.14,135.42 198.68,135.96 198.68,143.71 204.37,149.4 204.37,155.06 202.51,156.92 198.27,156.92 195.84,159.34 195.84,160.88 195.25,161.47 195.25,162.02 193.22,164.04 v1(192.56,164.04)
  BOTTOM w0.089: CPU1.F22 169.73,108.84 v1(170.05,108.53)
PEG_CRX_TTX_N12_C: length 2.6
  TOP w0.089: UT1.V22 185.81,161.79 186.57,161.79 187.27,161.1 187.56,161.1 CT16.2
PEG_CRX_TTX_N13: length 92.7
  TOP w0.099: v1(191.11,162.48) 190.89,162.7 189.49,162.7 188.84,163.35 188.52,163.35 CT2.1
  IN4 w0.097: v1(191.11,162.48) 191.11,162.49 191.5,162.89 191.93,162.89 192.09,162.72 193.36,162.72 194.27,161.81 194.27,161.12 194.46,160.93 194.46,159.92 194.72,159.66 194.72,159.15 197.78,156.09 202.09,156.09 203.54,154.64 203.54,149.86 197.86,144.17 197.86,136.63 197.22,135.99 197.22,122.9 197.1,122.79 197.1,116.77 191.78,111.46 190.49,111.46 188.46,109.42 178.37,109.42 177.78,108.83 175.52,108.83 174.82,109.53 173.52,109.53 172.84,108.84 171.23,108.84 171.01,109.06 171.01,109.47 171.11,109.56 171.33,109.56 171.43,109.47 v1(171.43,109.32)
  BOTTOM w0.089: v1(171.43,109.32) 171.39,109.32 171.03,109.68 CPU1.D23
PEG_CRX_TTX_N13_C: length 2.5
  TOP w0.089: UT1.P22 185.81,163.63 186.24,163.63 186.32,163.71 186.71,163.71 187.17,163.25 187.69,163.25 CT2.2
PEG_CRX_TTX_N14: length 81.1
  TOP w0.099: CT108.1 188.55,165.83 188.69,165.83 v1(188.89,166.04)
  IN4 w0.097: v1(188.89,166.04) 189.5,166.04 189.72,165.82 189.72,165.46 188.79,164.54 188.79,160.71 190.45,159.06 190.45,153.54 194.78,149.21 194.78,137.91 194.14,137.27 194.14,124.2 194.02,124.09 194.02,118.83 192.53,117.34 190.53,117.34 188.49,115.3 186.2,115.3 185.06,114.16 183.41,114.16 182.92,113.66 177.46,113.66 176.79,113 176.79,112.36 176.35,111.92 176.35,111.22 174.95,109.82 172.38,109.82 172.34,109.78 170.94,109.78 170.41,110.31 170.27,110.31 v1(170.06,110.1)
  BOTTOM w0.089: CPU1.F24 169.73,110.42 v1(170.06,110.1)
PEG_CRX_TTX_N14_C: length 2.4
  TOP w0.089: UT1.K22 185.84,165.93 186.58,165.93 186.71,165.8 186.96,165.8 187.05,165.8 187.14,165.89 187.59,165.89 187.74,166.04 CT108.2
PEG_CRX_TTX_N15: length 83
  TOP w0.099: v1(189.11,167.29) 189.44,167.29 189.68,167.52 189.68,167.66 189.41,167.93 188.52,167.93 CT110.1
  IN4 w0.097: v1(189.11,167.29) 189.24,167.42 189.43,167.42 189.53,167.32 189.53,166.87 189.34,166.69 187.75,166.69 187.12,166.06 187.12,159.7 188.41,158.41 188.41,154.41 193.96,148.87 193.96,138.25 193.32,137.61 193.32,124.54 193.2,124.42 193.2,120.01 191.94,118.75 189.6,118.75 187.99,117.14 187.99,116.86 187.75,116.63 187.13,116.63 186.68,116.17 185.91,116.17 185.15,115.42 183.32,115.42 182.39,114.48 177.27,114.48 175.99,113.2 175.99,112.44 175.08,111.54 173.17,111.54 172.03,110.4 171.2,110.4 171.09,110.51 171.09,110.71 171.25,110.88 v1(171.32,110.88)
  BOTTOM w0.089: CPU1.D25 171.03,111.16 v1(171.32,110.88)
PEG_CRX_TTX_N15_C: length 2.5
  TOP w0.089: UT1.F22 185.81,167.31 186.61,167.31 187.06,167.75 CT110.2
PEG_CRX_TTX_P12: length 99.2
  TOP w0.099: CT14.1 188.68,161.47 188.78,161.37 188.78,161.19 188.88,161.09 189.16,161.09 189.43,160.81 v3(190.19,160.81) 191.31,160.81 191.89,161.4 191.89,162.52 192.26,162.88 192.26,163.76 v1(191.98,164.04)
  IN4 w0.097: v1(170.68,108.53) 170.68,108.38 170.78,108.29 174.44,108.29 175.83,106.9 176.86,106.9 177.36,107.41 177.36,107.91 178.22,108.77 191.05,108.77 193.64,111.36 193.64,112.4 197.75,116.51 197.75,122.41 197.96,122.63 197.96,135.49 198.51,136.03 198.51,143.78 204.19,149.47 204.19,154.99 202.44,156.74 198.2,156.74 195.67,159.27 195.67,160.81 195.07,161.4 195.07,161.95 193.15,163.87 192.96,163.87 192.54,163.46 192.26,163.46 191.94,163.78 191.94,164.01 v1(191.98,164.04)
  BOTTOM w0.089: v1(170.68,108.53) 170.38,108.83 CPU1.E22
