# Allegro board LAD752PR10-0816.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
FFS_INT2_CONN: length 122.4
  TOP w0.107: DS1.2 188.1,69.31 187.71,68.93 RS1.2 187.71,65 181.58,58.87 181.58,51.91 183.02,50.47 183.02,41.72 182.83,41.53 182.83,33.74 181.18,32.09 181.18,28.79 181.37,28.6 184.66,28.6 184.86,28.41 184.86,25.24 181.11,21.49 v2(181.11,21.05) v1(181.11,20.04)
  IN4 w0.097: v1(181.11,20.04) 181.11,20.03 177.92,16.85 139.27,16.85 131.92,9.49 123.9,9.49 123.33,8.92 v1(123.33,8.91)
  BOTTOM w0.107: JHDD.20 122.92,9.33 123.33,8.92 v1(123.33,8.91)
G-SYNC#: length 3.1
  TOP w0.107: v2(160.75,182.59) 161.46,182.59 161.65,182.4 RV10.1 161.62,182.07 JEDP.21
GATE: length 1.5
  TOP w0.089: v1(238.02,88.75) 237.43,88.75 TV8.1
  BOTTOM w0.089: UG1.AM21 237.57,89.2 238.02,88.75 v1(238.02,88.75)
GC6_FB_EN: length 127.3
  TOP w0.107: v1(213.41,26.25) 213.72,25.94 214.85,25.94 215.59,26.68 217.64,26.68 217.85,26.47 221.42,26.47 222.26,27.31 222.26,30.26 221.75,30.77 221.75,32.43 223.78,34.46 223.78,38.86 223.34,39.3 v2(223.34,41.88) v1(223.34,43.16) ; UE10.9 311.19,50.58 v1(311.29,50.67)
  IN1 w0.097: v1(281.43,48.21) 274.02,48.21 272.6,46.8 266.6,46.8 264.6,44.8 255.34,44.8 254.34,43.8 243.4,43.8 242.28,44.93 225.11,44.93 v1(223.34,43.16)
  IN4 w0.097: v1(281.43,48.21) 283.4,48.21 283.72,48.54 285.1,48.54 285.32,48.31 291.48,48.31 292.47,49.3 292.47,54.43 292.72,54.69 294.35,54.69 296.16,52.88 309.49,52.88 309.89,52.47 309.89,52.07 v1(311.29,50.67)
  BOTTOM w0.089: v1(213.41,26.25) 213.75,26.59 UH1.AW27
GPIO15_VDDCI_VID: length 1.7
  TOP w0.089: TV15.1 227.29,90.98 227.35,90.98 v1(227.77,91.4)
  BOTTOM w0.1: UG1.AJ31 227.77,91.55 v1(227.77,91.4)
GPIO19_CTF: length 17.3
  TOP w0.089: v2(215.95,98.01) 215.95,98.8 v1(216.55,99.41)
  IN3 w0.089: v1(227.77,98.6) 227.34,99.03 216.92,99.03 216.55,99.4 v1(216.55,99.41)
  BOTTOM w0.1: UG1.AC31 227.77,98.45 v1(227.77,98.6)
  BOTTOM w0.107: RG38.1 216.55,100.94 v1(216.55,99.41)
GPIO30_PCC: length 32.5
  IN4 w0.089: v1(228.57,93.8) 227.73,94.64 219.32,94.64 218.54,95.42 v1(218.54,98.67)
  BOTTOM w0.089: 215.65,98.44 215.76,98.33 216.73,98.33 217.07,98.67 v1(218.54,98.67) ; v1(228.57,93.8) 229.02,93.35 UG1.AG30
  BOTTOM w0.107: 215.65,98.44 213.97,100.11 213.97,100.76 213.67,101.06 212.23,101.06 211.98,101.3 211.98,102.79 214.08,104.89 214.08,106.58 RV534.2 RV536.2 212.56,107.91 212.37,108.09 UV23.1
GPIO_0: length 2.2
  TOP w0.089: v1(221.49,103.41) 221.88,103.41 v2(222.04,103.57)
  TOP w0.107: v1(221.49,103.41) 221.18,103.11 RG147.1
  BOTTOM w0.107: UG1.V39 221.72,103.18 v1(221.49,103.41)
GPIO_1: length 14.7
  TOP w0.107: v1(36.6,32.98) 35.43,32.98 v2(34.93,32.49)
  IN1 w0.254: v1(37.66,22.96) 37.66,26.73 36.01,28.38 36.01,32.42 36.58,32.98 v1(36.6,32.98)
  BOTTOM w0.107: v1(36.6,32.98) 36.32,32.71 UA1.2
  BOTTOM w0.254: DA2.2 37.93,23.22 v1(37.66,22.96)
GPIO_1_28749953: length 9.2
  BOTTOM w0.107: RG156.1 215.72,104.93 v2(215.97,104.68) 217.31,103.35 218.32,103.35 218.58,103.09 218.58,102.46 218.77,102.27 222.09,102.27 UG1.V38
GPIO_2: length 3.7
  TOP w0.107: RG148.1 222,101.95 v2(222.13,101.82) 222.51,101.44 223.33,101.44 v1(223.77,101)
  BOTTOM w0.1: UG1.W37 223.77,101.25 v1(223.77,101)
GPIO_8_ROMSO: length 47
  TOP w0.089: v2(231.15,82.65) 230.62,82.65 RG157.1 229.66,82.29 228.48,83.47 228.48,84.58 228.72,84.82 RG27.2 229.18,85.07 229.18,86.24 228.81,86.61 228.81,87.56 v1(228.42,87.95)
  IN1 w0.089: v1(228.42,87.95) 228.06,88.31 216.97,88.31 215.65,86.99 215.65,82.74
  IN1 w0.097: v1(208.63,68.26) 208.63,75.72 215.65,82.74
  BOTTOM w0.107: UH5.2 207.36,68.88 207.98,68.26 v1(208.63,68.26)
  BOTTOM w0.135: UG1.AN30 228.57,87.95 v1(228.42,87.95)
GPIO_9_ROMSI: length 43.6
  IN1 w0.089: 215.65,82.1 216.11,82.57 216.11,86.67 216.59,87.15 227.11,87.15 v1(227.21,87.25)
  IN1 w0.097: v1(209.9,61.42) 209.89,61.44 209.89,64.33 209.27,64.95 209.27,75.72 215.65,82.1
  BOTTOM w0.089: UG1.AP32 227.59,87.6 227.25,87.25 v1(227.21,87.25)
  BOTTOM w0.107: UH5.5 v1(209.9,61.42)
GPIO_10_ROMSCK: length 49.6
  IN1 w0.089: 215.65,88.56 228.23,88.56 v1(228.42,88.75)
  IN1 w0.097: 215.65,88.56 214.11,88.56 213.33,87.79 212.64,87.79 209.95,85.1 209.95,79.31 208.2,77.56 208.2,62.32 v1(209.06,61.45)
  BOTTOM w0.089: UG1.AM30 228.87,89.2 v1(228.42,88.75)
  BOTTOM w0.107: UH5.6 208.63,61.88 v1(209.06,61.45) 209.06,61.36 v2(208.61,60.9)
GPIO_11: length 3.7
  BOTTOM w0.089: UG1.V43 216.65,102.8 v2(216.1,103.35) 215.65,103.8
  BOTTOM w0.107: 215.65,103.8 215.15,104.3 RG153.1
GPIO_12: length 2.8
  TOP w0.089: v1(218.83,103.41) 218.13,104.11 v2(218.13,104.24) RG154.1
  BOTTOM w0.135: UG1.V42 218.83,102.99 v1(218.83,103.41)
GPIO_13: length 3
  TOP w0.089: 219.02,103.85 219.02,104.81 219.4,105.19 RG155.1
  TOP w0.1: 219.02,103.85 v1(219.47,103.4)
  BOTTOM w0.135: UG1.V41 219.47,103.25 v1(219.47,103.4)
GPIO_20: length 21.7
  IN4 w0.097: v1(226.2,91.28) 226.2,91.41 225.69,91.92 219.53,91.92 217.83,93.62 217.83,98.95 v1(217.37,99.41)
  BOTTOM w0.089: UG1.AK33 226.62,90.86 v1(226.2,91.28) ; v1(217.37,99.41) 217.37,100.24 217.75,100.62 217.75,101.19 215.65,103.29
  BOTTOM w0.107: RG146.1 215.27,103.66 215.65,103.29
GPIO_22_ROMCSB: length 90.1
  TOP w0.089: RG144.1 226.79,88.38 v1(227.22,87.95)
  IN1 w0.089: v1(227.22,87.95) 226.89,87.95 226.37,87.43 216.53,87.43 215.9,86.8 215.9,82.67 215.65,82.42
  IN1 w0.097: v1(208.64,67.57) 209.04,67.97 209.04,75.82 215.65,82.42
  IN3 w0.091: v1(208.64,67.57) 208.15,68.07 208.15,69.14 208.57,69.56 208.57,75.08 207.22,76.43 207.22,79.32 208.71,80.8 213.62,80.8 214.17,81.35 214.17,83.64 214.66,84.13 214.66,89.15 209.05,94.76 209.05,104.78 207.97,105.86 207.15,105.86 v1(206.66,105.37)
  BOTTOM w0.089: UG1.AN32 227.67,88.4 v1(227.22,87.95)
  BOTTOM w0.107: v1(208.64,67.57) 208.03,67.57 206.09,69.51 UH5.1 ; RG499.2 206.74,105.45 v1(206.66,105.37)
GPIO_29: length 20.3
  IN4 w0.097: v1(227.77,93.8) 227.24,94.33 218.79,94.33 218.17,94.95 218.17,100.13 v1(217.31,101)
  BOTTOM w0.1: v1(227.77,93.8) 227.77,93.65 UG1.AG31
  BOTTOM w0.107: v1(217.31,101) 215.27,103.03 RG145.1
GPU_ALERT#: length 3
  TOP w0.107: v2(312.3,52.29) 311.98,51.98 RE644.1 311.98,51.08 UE10.10
GPU_AUXN/DDC: length 97.9
  TOP w0.107: RG402.1 230.45,84.4 230.71,84.4 230.83,84.27 v1(230.83,84.13)
  IN4 w0.097: v1(202.01,111.46) 201.8,111.25 201.8,110.92 201.89,110.67 204.46,108.1 204.46,104.35 209.22,99.6 209.22,89.97 209.72,89.47 209.72,87.26 211.81,85.17 213.72,85.17 217.59,81.29 220.28,81.29 220.65,81.66 220.65,83.7 221.46,84.51 224.07,84.51 225.61,82.96 228.66,82.96 228.96,82.66 230.95,82.66 231.36,83.07 231.36,84.29 231.11,84.54 230.61,84.54 230.51,84.44 230.51,84.23 230.61,84.13 v1(230.83,84.13)
  BOTTOM w0.107: CV425.2 187.16,123.41 187.16,124.38 RV670.1 186.99,124.58 187.37,124.96 187.37,128.58 191.37,132.58 193.98,132.58 196.92,129.64 196.92,119.22 202.01,114.13 v1(202.01,111.46) ; UG1.AV27 231.1,84.4 v1(230.83,84.13)
GPU_AUXN/DDC_C: length 2.9
  BOTTOM w0.099: UV21.27 188.19,120.91 188.28,121.01 188.28,121.25 v3(187.93,121.6) 187.7,121.82 187.53,121.82 187.32,122.03 187.32,122.23 CV425.1
GPU_AUXP/DDC: length 97.8
  TOP w0.107: v1(230.83,84.92) 230.83,84.78 230.66,84.61 230.48,84.61 RG403.1
  IN4 w0.097: v1(230.83,84.92) 230.97,84.92 231.53,84.36 231.53,83 231.02,82.49 228.89,82.49 228.59,82.79 225.54,82.79 224,84.34 221.53,84.34 220.82,83.63 220.82,81.59 220.35,81.12 217.52,81.12 213.65,85 211.74,85 209.55,87.19 209.55,89.4 209.04,89.9 209.04,99.53 204.29,104.28 204.29,108.03 201.74,110.58 201.63,110.89 201.63,111.26 v1(201.43,111.46)
  BOTTOM w0.107: v1(230.83,84.92) 230.84,84.91 231.07,84.91 231.35,85.2 UG1.AU27 ; v1(201.43,111.46) 201.8,111.82 201.8,114.04 196.71,119.13 196.71,129.55 193.89,132.36 191.45,132.36 187.59,128.49 187.59,124.91 187.92,124.58 RV669.1 187.37,124 187.37,123.73 187.48,123.63 187.82,123.63 187.89,123.55 CV424.2
GPU_AUXP/DDC_C: length 2.9
  BOTTOM w0.099: CV424.1 187.51,122.23 187.51,122.11 187.61,122.02 187.83,122.02 188.3,121.55 188.3,121.5 188.47,121.33 188.47,121.12 188.48,121.11 188.48,121.05 188.59,120.94 UV21.28
GPU_B+: length 25.5
  IN3 w0.508: v1(293.48,52.07) 292.65,51.25 292.65,49.72 291.44,48.51 289.43,48.51 286.93,46.01 279.85,46.01 278.33,47.53 275.6,47.53 274.46,48.67 v1(274.46,49.55)
  BOTTOM w0.508: v1(293.48,52.07) 293.48,52.71 PR6003.1
  vias: v1(225.86,51.67) v1(226.49,51.67) v1(227.13,51.67) v1(227.76,51.67) v1(228.4,51.67) v1(229.03,51.67) v1(234.58,50.58) v1(235.21,50.58) v1(235.85,50.58) v1(236.48,50.58) v1(237.12,50.58) v1(237.75,50.58) v1(243.15,50.58) v1(243.79,50.58) v1(244.42,50.58) v1(245.06,50.58) v1(245.69,50.58) v1(246.33,50.58) v1(251.72,50.57) v1(252.35,50.57) v1(252.99,50.57) v1(253.62,50.57) v1(254.26,50.57) v1(254.89,50.57) v1(258.2,39.78) v1(258.2,39.08) v1(258.2,38.45) v1(258.83,39.78) v1(258.83,39.08) v1(258.83,38.45) v1(259.46,38.49) v1(259.52,39.76) v1(259.52,39.12) v1(260.16,39.76) v1(260.16,39.12) v1(260.16,38.49) v1(260.85,39.76) v1(260.85,39.12) v1(260.85,38.49) v1(261.55,39.76) v1(261.55,39.12) v1(261.5,38.51) v1(271.28,49.55) v1(271.92,49.55) v1(272.55,49.55) v1(273.19,49.55) v1(273.82,49.55) v2(232.16,46.96)
GPU_DMINUS: length 31.4
  IN1 w0.254: v1(225.4,97.4) 224.61,96.61 221,96.61 220.61,96.22 214.76,96.22 209.18,101.79 209.18,105.37 206.85,107.7 v1(205.76,107.7)
  BOTTOM w0.254: v1(225.4,97.4) 225.82,97.83 UG1.AC34 ; v1(205.76,107.7) 205.4,107.7 204.94,108.17 C2503.2 205.12,109.14 UG3.3
GPU_DPC_AUX: length 0.8
  BOTTOM w0.107: RV619.1 227.54,155.16 CV24.2
GPU_DPC_AUX#: length 0.8
  BOTTOM w0.107: CV25.2 227.54,156.05 RV618.1
GPU_DPLUS: length 31.4
  IN1 w0.254: v1(224.63,97.42) 224.65,97.4 224.65,97.14 224.46,96.96 220.86,96.96 220.51,96.6 214.92,96.6 209.57,101.95 209.57,105.53 207.01,108.08 206.4,108.08 206.15,108.34 206.15,108.79 205.89,109.05 205.53,109.05 205.35,108.87 205.35,108.42 205.47,108.31 v1(205.48,108.31)
  BOTTOM w0.254: v1(224.63,97.42) 225.02,97.8 UG1.AC35 ; v1(205.48,108.31) 205.85,108.68 C2503.1 205.77,109.04 UG3.2
GPU_FAN_FB: length 75.2
  TOP w0.107: RF4.1 287.06,73.55 286.28,73.55 285.9,73.93 285.9,78.55 287.03,79.68 292.08,79.68 293.29,78.46 293.29,72.24 DF2.2 293.42,71.54 v1(292.46,70.58) ; v1(292.93,34.32) 292.93,29.42 294.87,27.48 294.87,25.45 294.34,24.92 UE5.29
  IN3 w0.091: v1(292.93,34.32) 292.37,34.32 291.21,35.48 291.21,36.44 294.72,39.95 294.72,46.98 295.54,47.79 295.54,59.37 292.98,61.93 292.98,70.07 v1(292.46,70.58)
GPU_FAN_PWM: length 62.5
  TOP w0.107: UE5.27 295.14,24.92 295.34,25.12 295.34,27.96 294.07,29.23 294.07,29.83 v2(293.57,30.32) 293.38,30.51 293.38,32.81 293.38,32.81 v1(293.38,33.84) ; JFAN2.2 289.62,76.13 289.43,75.94 288.58,75.94 v1(288.05,75.41) 288.03,75.41 RF5.1
  IN3 w0.091: v1(293.38,33.84) 292.54,33.84 290.99,35.39 290.99,36.53 294.51,40.04 294.51,47.07 295.32,47.88 295.32,59.28 292.76,61.84 292.76,69.68 290.88,71.56 290.88,72.36 288.05,75.19 v1(288.05,75.41)
GPU_MDP_N0: length 110
  IN2 w0.099: v1(224.74,82.2) 224.64,82.2 224.48,82.04 224.48,81.82 224.27,81.61 223.17,81.61 222.96,81.82 222.96,84.14 222.42,84.68 219.32,84.68 218.26,85.74 218.26,86.25 216.68,87.84 216.68,89.32 214.36,91.64 214.36,99.75 215.15,100.54 215.15,108.43 215.53,108.81 215.53,121.94 215.28,122.19 215.28,126.79 217.69,129.2 217.69,145.45 218.45,146.2 223.99,146.2 224.49,145.7 225.24,145.7 225.43,145.89 229.81,145.89 231.17,147.25 231.17,147.9 229.06,150.01 229.06,157.1 230.68,158.72 230.68,162.93 229.51,164.09 v1(229.51,164.8)
  BOTTOM w0.107: v1(229.51,164.8) 229.7,164.99 229.7,165.35 229.68,165.37 229.68,165.89 229.69,165.9 229.69,166.32 CV27.1 ; v1(224.74,82.2) 225.13,82.6 UG1.AY35
GPU_MDP_N1: length 118.6
  TOP w0.107: v1(230.15,147.51) 229.97,147.7 229.97,150.18 229.34,150.82 229.34,155.39 v3(231.52,157.58) 233.07,159.12 233.07,160.08 234.95,161.96 237.93,161.96 238.83,162.86 238.83,166.16 239.76,167.09 240.58,167.09 240.95,166.72 241.79,166.72 242.02,166.95 242.02,167.16 CV30.1
  IN2 w0.099: v1(230.15,147.51) 229.81,147.17 229.81,147.02 229.6,146.81 218.2,146.81 217.05,145.67 217.05,129.45 214.67,127.07 214.67,121.86 214.89,121.64 214.89,109.19 214.54,108.84 214.54,100.8 213.75,100 213.75,91.39 216.23,88.91 216.23,86.83 219.21,83.84 219.7,83.84 221.8,81.75 221.8,80.69 223.32,79.17 223.85,79.17 224.05,79.37 224.05,79.98 224.26,80.19 224.43,80.19 v1(224.82,80.59)
  BOTTOM w0.107: v1(224.82,80.59) 225.21,80.59 UG1.BB35
GPU_MDP_N2: length 122.5
  IN2 w0.099: v1(225.88,79.34) 225.81,79.41 225.57,79.41 224.64,78.47 222.75,78.47 220.33,80.9 220.33,81.49 219.53,82.29 218.65,82.29 217.95,82.99 217.95,83.72 215.12,86.54 215.12,88.64 212.77,90.98 212.77,98.66 212.14,99.29 212.14,100.66 213.23,101.75 213.23,103.4 213.57,103.74 213.57,109.89 213.88,110.21 213.88,120.98 213.56,121.3 213.56,127.36 216.04,129.84 216.04,146.04 217.79,147.79 224.34,147.79 225.28,148.73 225.28,149.7 228.02,152.44 228.02,157.18 229.47,158.64 229.47,162.48 228.25,163.71 228.25,165.15 228.83,165.73 240.03,165.73 v1(240.21,165.91)
  BOTTOM w0.107: CV33.1 241.28,166.16 241.28,165.98 240.84,165.54 240.58,165.54 v1(240.21,165.91) ; v1(225.88,79.34) 226.43,79.9 UG1.BC33
GPU_MDP_N3: length 110.5
  IN2 w0.099: v1(227.21,82.2) 226.82,82.2 226.71,82.31 226.71,82.9 226.21,83.4 225.57,83.4 224.69,84.29 224.69,85.62 224.18,86.13 219.91,86.13 217.55,88.49 217.55,89.89 215.34,92.11 215.34,99.35 216.1,100.11 216.1,107.98 216.54,108.43 216.54,126.59 218.7,128.75 218.7,144.17 219.41,144.88 223.9,144.88 224.09,144.69 226.15,144.69 226.34,144.88 230.17,144.88 232.14,146.85 232.14,149.85 231.66,150.33 230.77,150.33 230.26,150.84 230.26,152.05 230.45,152.24 230.45,153.96 231.71,155.22 231.71,157.13 233.37,158.79 233.37,160.5 235.37,162.49 235.37,163.56 v1(235.61,163.8)
  BOTTOM w0.107: CV31.1 235.15,166.32 235.15,165.9 235.15,165.89 235.37,165.68 235.37,164.04 v1(235.61,163.8) ; UG1.AY32 227.61,82.6 v1(227.21,82.2)
GPU_MDP_P0: length 110
  IN2 w0.099: v1(230.1,164.8) 230.09,164.8 229.7,164.42 229.7,164.17 230.86,163.01 230.86,158.64 229.24,157.03 229.24,150.08 231.35,147.97 231.35,147.17 229.88,145.71 225.5,145.71 225.31,145.52 224.41,145.52 223.91,146.02 218.53,146.02 217.88,145.37 217.88,129.13 215.46,126.71 215.46,122.27 215.72,122.02 215.72,108.74 215.34,108.35 215.34,100.47 214.54,99.67 214.54,91.72 216.86,89.4 216.86,87.92 218.45,86.33 218.45,85.82 219.4,84.87 222.5,84.87 223.15,84.22 223.15,81.89 223.25,81.8 224.19,81.8 224.29,81.9 224.29,82.14 224.24,82.2 v1(223.66,82.2)
  BOTTOM w0.107: UG1.AY36 224.22,82.43 223.99,82.2 v1(223.66,82.2) ; CV26.1 229.91,166.31 v3(229.91,165.64) 229.91,164.99 v1(230.1,164.8)
GPU_MDP_P1: length 118.6
  TOP w0.107: CV28.1 241.81,167.18 241.81,167.04 241.7,166.94 241.04,166.94 240.67,167.3 239.67,167.3 238.62,166.25 238.62,162.95 237.84,162.17 234.86,162.17 232.85,160.17 232.85,159.21 231.57,157.94 231.55,157.94 231.17,157.55 231.17,157.53 229.12,155.48 229.12,150.73 229.75,150.09 229.75,147.7 v1(229.57,147.51)
  IN2 w0.099: v1(224.82,80) 224.34,80 224.24,79.9 224.24,79.3 223.92,78.98 223.25,78.98 221.61,80.62 221.61,81.67 219.63,83.66 219.14,83.66 216.04,86.75 216.04,88.84 213.57,91.31 213.57,100.08 214.36,100.87 214.36,108.92 214.71,109.27 214.71,121.57 214.49,121.79 214.49,127.14 216.87,129.52 216.87,145.74 218.12,147 229.53,147 229.62,147.1 229.62,147.45 v1(229.57,147.51)
  BOTTOM w0.107: v1(224.82,80) 225.32,80 UG1.BC35
GPU_MDP_P2: length 122.4
  IN2 w0.099: v1(225.88,80.3) 225.88,79.87 225.6,79.59 225.5,79.59 224.56,78.66 222.83,78.66 220.52,80.97 220.52,81.56 219.61,82.47 218.72,82.47 218.13,83.06 218.13,83.8 215.31,86.62 215.31,88.71 212.96,91.06 212.96,98.74 212.33,99.37 212.33,100.58 213.42,101.68 213.42,103.33 213.75,103.66 213.75,109.82 214.07,110.13 214.07,121.06 213.74,121.38 213.74,127.28 216.23,129.76 216.23,145.96 217.87,147.6 224.42,147.6 225.47,148.66 225.47,149.62 228.2,152.36 228.2,157.11 229.66,158.56 229.66,162.56 228.43,163.79 228.43,165.07 228.91,165.55 239.99,165.55 v1(240.21,165.33)
  BOTTOM w0.107: v1(225.88,80.3) 226.12,80.3 UG1.BB33 ; CV32.1 241.5,166.53 241.5,165.89 240.93,165.33 v1(240.21,165.33)
GPU_MDP_P3: length 110.5
  IN2 w0.099: v1(226.01,82.2) 226.4,82.2 226.52,82.33 226.52,82.82 226.13,83.22 225.5,83.22 224.5,84.21 224.5,85.54 224.1,85.95 219.84,85.95 217.37,88.42 217.37,89.81 215.15,92.03 215.15,99.42 215.91,100.18 215.91,108.06 216.36,108.5 216.36,126.66 216.84,127.14 218.52,128.82 218.52,144.25 219.33,145.06 223.98,145.06 224.16,144.88 226.07,144.88 226.26,145.06 230.1,145.06 231.96,146.92 231.96,149.77 231.58,150.15 230.69,150.15 230.07,150.77 230.07,152.13 230.26,152.32 230.26,154.03 231.53,155.29 231.53,157.21 233.19,158.87 233.19,160.57 235.18,162.57 235.18,163.64 v1(235.02,163.8)
  BOTTOM w0.107: v1(235.02,163.8) 235.04,163.8 235.15,163.91 235.15,165.59 234.93,165.81 234.93,165.91 234.93,166.3 CV29.1 ; v1(226.01,82.2) 226.4,82.6 UG1.AY33
GPU_OVERT#: length 74.2
  TOP w0.107: v2(327.86,43.64) 327.96,43.64 328.35,43.26 v1(328.45,43.26) 328.75,42.95 UE6.21 ; RE102.1 289.06,12.41 v1(289.19,12.54)
  IN3 w0.091: v1(328.45,43.26) 328.7,43.26 329.64,42.32 329.64,41.62 329.93,41.33 329.93,39.41 329.78,39.26 329.78,35.41 328.94,34.58 328.63,34.58 327.02,32.97 327.02,31.96 320.59,25.53 320.59,14.6 317.17,11.18 317.17,10.25 315.06,8.14 292.13,8.14 291.22,9.05 291.22,11.97 290.65,12.54 v1(289.19,12.54)
GPU_TX0N: length 78.4
  IN4 w0.097: v1(188.67,99.03) 188.67,99.17 188.76,99.27 189.44,99.27 190.76,97.95 190.76,96.79 192.73,94.82 194.32,94.82 196.19,92.95 196.98,92.95 198.77,91.15 199.02,91.15 204.26,85.91 204.26,83.31 205.99,81.58 205.99,80.17 206.82,79.35 206.82,78.47 208.19,77.1 225.67,77.1 226.1,77.53 228.39,77.53 229.07,78.21 230.29,78.21 230.49,78.42 231.59,78.42 233.96,80.79 233.96,80.96 234.24,81.25 v1(234.42,81.25)
  BOTTOM w0.107: v1(188.67,99.03) 188.47,99.22 188.36,99.22 187.79,99.79 187.47,99.79 181.9,105.37 181.9,109.1 180.56,110.43 180.56,111.49 180.8,111.72 180.95,111.72 CV417.2 ; v1(234.42,81.25) 234.57,81.25 UG1.BA24
GPU_TX0N_C: length 3.8
  BOTTOM w0.099: UV21.2 184.55,112.54 183.98,111.97 183.98,111.83 183.8,111.65 183.63,111.65 183.6,111.67 183.02,111.67 182.99,111.65 182.76,111.65 182.63,111.77 182.31,111.77 CV417.1
GPU_TX0P: length 78.3
  IN4 w0.097: v1(233.22,81.25) 233.32,81.35 233.53,81.35 233.79,81.09 233.79,80.86 231.52,78.59 230.42,78.59 230.21,78.39 229,78.39 228.32,77.71 226.03,77.71 225.59,77.27 208.27,77.27 206.99,78.55 206.99,79.42 206.16,80.25 206.16,81.65 204.43,83.38 204.43,85.98 199.09,91.33 198.85,91.33 197.05,93.12 196.26,93.12 194.39,94.99 192.8,94.99 190.94,96.86 190.94,98.02 189.31,99.64 188.88,99.64 v1(188.68,99.85)
  BOTTOM w0.107: CV416.2 181.04,111.5 180.89,111.5 180.78,111.4 180.78,110.52 182.11,109.19 182.11,105.45 187.52,100.04 187.84,100.04 188.45,99.44 188.81,99.44 188.92,99.54 188.92,99.74 188.81,99.85 v1(188.68,99.85) ; UG1.BA25 233.37,81.25 v1(233.22,81.25)
GPU_TX0P_C: length 3.8
  BOTTOM w0.099: UV21.1 184.61,112.14 184.57,112.18 184.47,112.18 184.17,111.89 184.17,111.75 183.88,111.45 v3(183.31,111.45) 182.68,111.45 182.55,111.57 182.34,111.57 CV416.1
GPU_TX1N: length 85.7
  IN4 w0.097: v1(187.68,98.21) 187.86,98.39 188.92,98.39 189.99,97.33 189.99,96.07 191.7,94.36 191.7,92.9 192.74,91.86 195.86,91.86 197.45,90.27 198.81,90.27 202.83,86.24 202.83,83.63 204.95,81.51 204.95,80.11 206.04,79.02 206.04,78.1 207.82,76.32 226.02,76.32 226.4,76.7 228.66,76.7 229.35,77.39 230.66,77.39 230.91,77.64 231.91,77.64 232.61,78.35 234.28,78.35 235.13,79.2 235.13,79.84 234.93,80.04 234.73,80.04 v1(234.42,80.35)
  BOTTOM w0.107: v1(187.68,98.21) 187.48,98.41 187.19,98.41 184.01,101.59 183.99,101.59 183.61,101.97 183.61,101.99 181.05,104.55 181.05,108.78 179.7,110.12 179.7,112.28 180.32,112.9 180.32,112.9 180.42,113 181.62,113 181.72,113.1 182.47,113.1 CV419.2 ; v1(234.42,80.35) 234.57,80.35 UG1.BB24
GPU_TX1N_C: length 2.5
  BOTTOM w0.099: CV419.1 183.35,113.27 183.35,113.08 183.43,113 183.57,113 183.71,113.15 183.71,113.38 183.97,113.63 184.48,113.63 184.58,113.74 UV21.5
GPU_TX1P: length 85.3
  IN4 w0.097: v1(234.45,79.6) 234.45,79.72 234.6,79.87 234.86,79.87 234.96,79.77 234.96,79.27 234.21,78.52 232.54,78.52 231.84,77.82 230.84,77.82 230.59,77.57 229.28,77.57 228.59,76.87 226.33,76.87 225.95,76.49 207.89,76.49 206.21,78.17 206.21,79.1 205.13,80.18 205.13,81.59 203.01,83.71 203.01,86.31 198.88,90.44 197.52,90.44 195.93,92.03 192.81,92.03 191.87,92.97 191.87,94.43 190.16,96.14 190.16,97.4 188.99,98.57 188.1,98.57 v1(187.65,99.01)
  BOTTOM w0.107: UG1.BC24 234.97,79.85 234.56,79.85 234.45,79.74 v1(234.45,79.6) ; v1(187.65,99.01) 187.67,99.01 187.77,98.9 187.77,98.75 187.65,98.63 187.28,98.63 v3(183.96,101.94) 181.26,104.64 181.26,108.87 179.92,110.21 179.92,112.19 180.41,112.68 180.51,112.78 181.71,112.78 181.81,112.89 182.57,112.89 182.7,112.76 CV418.2
GPU_TX1P_C: length 2.5
  BOTTOM w0.099: CV418.1 183.46,112.56 183.46,112.65 183.56,112.75 183.59,112.75 183.65,112.81 183.91,113.07 183.91,113.3 184.05,113.44 184.48,113.44 184.58,113.34 UV21.4
GPU_TX2N: length 87.5
  IN4 w0.097: v1(188.36,97.16) 188.42,97.23 188.99,97.23 189.21,97.01 189.21,94.02 192.36,90.88 195.74,90.88 201.93,84.69 201.93,83.44 203.88,81.49 203.88,79.15 207.49,75.54 229.46,75.54 230.23,76.32 230.75,76.32 231.07,76.63 232.93,76.63 233.81,77.52 234.67,77.52 236.17,79.01 236.17,79.48 236.38,79.69 236.72,79.69 236.82,79.6 v1(236.82,79.45)
  BOTTOM w0.107: UG1.BC23 236.67,79.45 v1(236.82,79.45) ; CV421.2 180.54,114.36 179.8,114.36 178.86,113.42 178.86,109.79 180.13,108.52 180.13,105.71 180.13,105.52 180.13,104.27 187.05,97.35 188.17,97.35 v1(188.36,97.16)
GPU_TX2N_C: length 4.1
  BOTTOM w0.099: UV21.7 184.57,114.54 184.46,114.43 184.46,114.43 183.8,114.43 183.52,114.16 v3(182.16,114.16) 181.7,114.16 CV421.1
GPU_TX2P: length 87.9
  IN4 w0.097: v1(236.82,80.35) 236.82,79.96 236.72,79.87 236.3,79.87 235.99,79.55 235.99,79.09 234.6,77.69 233.74,77.69 232.86,76.81 231,76.81 230.68,76.49 230.16,76.49 229.39,75.72 207.56,75.72 204.05,79.22 204.05,81.56 202.1,83.51 202.1,84.76 195.81,91.05 192.43,91.05 189.38,94.09 189.38,97.08 189.06,97.4 188.69,97.4 188.39,97.7 v1(188.39,97.88)
  BOTTOM w0.107: v1(188.39,97.88) 188.43,97.84 188.43,97.68 188.32,97.57 187.14,97.57 180.35,104.36 180.35,105.52 180.35,105.71 180.35,108.61 179.08,109.88 179.08,113.33 179.53,113.78 179.89,114.14 180.62,114.14 180.73,114.03 CV420.2 ; UG1.BB23 236.67,80.35 v1(236.82,80.35)
GPU_TX2P_C: length 4.1
  BOTTOM w0.099: UV21.6 184.48,114.14 184.38,114.24 183.88,114.24 183.6,113.96 182.49,113.96 182.45,113.93 181.87,113.93 181.83,113.96 181.69,113.96 CV420.1
GPU_TX3N: length 98.1
  IN4 w0.097: v1(236.8,83.03) 237.05,82.77 237.25,82.77 237.44,82.59 237.44,79.18 235.74,77.49 235.74,77.06 234.54,75.86 231.39,75.86 230.3,74.77 205.07,74.77 201.04,78.79 201.04,84.47 195.42,90.1 192.03,90.1 188.35,93.78 188.35,96.17 188.25,96.27 v1(187.78,96.27)
  BOTTOM w0.107: UG1.AY21 237.23,82.6 v1(236.8,83.03) ; v1(187.78,96.27) 186.96,96.27 179.23,104 179.23,108.38 178.05,109.56 178.05,113.99 179.54,115.48 181.51,115.48 181.85,115.82 182.37,115.82 182.43,115.88 CV423.2
GPU_TX3N_C: length 2.1
  BOTTOM w0.099: CV423.1 183.67,115.49 184.02,115.49 184.07,115.53 184.24,115.53 184.45,115.74 UV21.10
GPU_TX3P: length 98
  IN4 w0.097: v1(236.82,82.15) 236.64,82.33 236.64,82.5 236.73,82.6 237.17,82.6 237.26,82.5 237.26,79.26 235.57,77.56 235.57,77.13 234.46,76.03 231.32,76.03 230.23,74.94 205.14,74.94 201.21,78.86 201.21,84.55 195.49,90.27 192.11,90.27 188.52,93.85 188.52,96.24 188.29,96.47 188.15,96.47 187.78,96.84 v1(187.78,96.85)
  BOTTOM w0.107: v1(236.82,82.15) 236.37,82.6 UG1.AY23 ; CV422.2 182.7,115.24 182.34,115.6 181.94,115.6 181.6,115.27 179.63,115.27 178.27,113.9 178.27,109.65 179.45,108.46 179.45,104.09 187.05,96.48 187.41,96.48 v1(187.78,96.85)
GPU_TX3P_C: length 2
  BOTTOM w0.099: UV21.9 184.15,115.34 184.1,115.29 184.03,115.29 184.02,115.29 183.75,115.29 183.75,115.29 183.65,115.29 CV422.1
GPU_WP#: length 13.3
  BOTTOM w0.107: RG30.1 v2(209.97,60.29) 210.07,60.29 210.41,60.64 210.41,67.3 208.63,69.08 UH5.3
H_CPUPWRGD: length 226.4
  TOP w0.107: v1(115.71,34.87) 115.75,34.87 v4(116.21,35.34)
  IN1 w0.097: v1(199.51,50.96) 199.51,50.96 201.09,49.38 201.09,46.99 203.32,44.76 206.57,44.76 209.69,41.64 v1(209.69,41.6)
  IN3 w0.091: v1(131.2,115.8) 131.5,115.8 133.8,113.5 133.8,112.43 132.9,111.52 132.9,105.31 129.87,102.28 129.87,100.33 129.36,99.83 129.36,99.17 126.94,96.75 126.94,86.27 123.14,82.46 123.14,78.56 116.57,72 116.57,71.19 116.15,70.77 115.34,70.77 109.13,64.56 109.13,61.74 109.36,61.51 109.36,57.14 109.13,56.9 109.13,41.92 109.8,41.25 111.04,41.25 113.78,38.51 115.83,38.51 116.47,37.88 116.47,35.63 v1(115.71,34.87)
  IN4 w0.097: v1(199.51,50.96) 198.25,49.7 194.42,49.7 192.07,52.04 189.88,52.04 189.44,51.6 189.44,48.54 190.74,47.24 190.74,42.58 180.76,32.6 171.11,32.6 166.3,27.78 132.72,27.78 127.37,33.14 117.44,33.14 v1(115.71,34.87)
  BOTTOM w0.089: UH1.AM3 210.02,38.45 209.79,38.69 209.79,39.49 210.02,39.72 210.02,41.27 v1(209.69,41.6)
  BOTTOM w0.107: CH194.1 130.26,116.75 v1(131.2,115.8) 131.24,115.76 CPU1.BT31
H_DRAMRST#: length 150.3
  TOP w0.107: v1(134.06,53.69) v2(134.82,53.69) 135.12,53.69 RD35.2 CD69.1 RD31.2
  IN1 w0.097: v1(202.82,54.61) 202.82,53.77 203.88,52.7 206.63,52.7 209.14,50.19 209.14,44.27 211.31,42.1 211.31,41.33 211.61,41.03 211.61,37.87 211.63,37.85 211.63,35.3 212.62,34.31 212.62,33.13 213.03,32.72 215.57,32.72 215.78,32.5 217.79,32.5 v1(218.14,32.85)
  IN3 w0.091: v1(135.33,30.24) 135.33,33.81 134.85,34.29 134.85,52.9 v1(134.06,53.69)
  IN4 w0.097: v1(202.82,54.61) 202.49,54.61 200.51,52.63 194.89,52.63 193.07,54.45 188.88,54.45 187.03,52.6 187.03,42.28 179.76,35.01 170.11,35.01 165.35,30.24 v1(135.33,30.24)
  BOTTOM w0.089: UH1.BC14 215.42,33.24 215.66,33.01 216.13,33.01 216.45,32.69 216.65,32.69 216.84,32.51 217.79,32.51 v1(218.14,32.85)
H_PECI: length 346.5
  TOP w0.107: RE76.2 v1(310.63,18.62)
  IN3 w0.089: 219.18,42.02 219.12,42.08
  IN3 w0.091: 219.18,42.02 219.25,41.94 223.34,41.94 224.31,40.97 226.48,40.97 227.12,40.33 230.18,40.33 230.68,39.83 241.2,39.83 241.31,39.72 257.37,39.72 258.15,40.49 266.89,40.49 268.42,38.96 284.91,38.96 286.08,37.78 287.43,37.78 288.17,37.04 288.17,36.06 292.05,32.18 302.18,32.18 305.94,28.42 305.94,24.84 307.09,23.68 307.09,22.22 310.63,18.68 v1(310.63,18.62) ; v1(117.04,34.83) 117.04,37.87 116,38.91 113.95,38.91 111.21,41.65 109.96,41.65 109.53,42.08 109.53,56.74 109.76,56.97 109.76,59.11 111.48,60.83 111.48,62.1 124.5,75.12 124.5,82.75 129.95,88.2 129.95,90.22 132.68,92.95 132.68,98.49 132.06,99.11 132.06,102.56 136.25,106.74 136.25,113.47 135.43,114.29 133.27,114.29 132.47,115.09 132.47,116.17 130.82,117.82 v1(130.82,118.59) ; v1(211.78,48.48) 211.78,48.23 216.87,43.14 218.06,43.14 219.12,42.08
  IN4 w0.097: v1(211.78,48.48) 210.83,49.44 210.83,50.25 207.27,53.81 202.86,53.81 200.88,51.83 194.56,51.83 192.74,53.65 189.22,53.65 187.83,52.26 187.83,41.94 180.09,34.2 170.44,34.2 165.63,29.39 135.04,29.39 133.69,30.75 132.3,30.75 127.73,35.32 117.53,35.32 v1(117.04,34.83)
  BOTTOM w0.089: CPU1.BT34 131.26,117.28 130.82,117.72 v1(130.82,118.59)
  BOTTOM w0.107: RH73.2 209.11,45.26 v2(210.7,46.84) 211.72,47.86 211.72,48.42 v1(211.78,48.48)
H_PM_DOWN: length 225.6
  IN1 w0.097: v1(208.1,40.68) 207.28,40.68 206.03,41.93 203.32,41.93 198.95,46.29 198.95,48.65 196.73,50.87 v1(196.73,50.9)
  IN3 w0.091: v1(105.5,35.74) 104.98,36.26 104.98,50.14 103.29,51.83 103.29,57.11 104.34,58.16 104.34,60.34 104.61,60.61 104.61,65.4 117.09,77.88 117.09,93.61 124.4,100.92 124.4,103.4 128.42,107.42 128.42,111.63 126.56,113.49 126.56,116.3 v1(126.05,116.81)
  IN4 w0.097: v1(105.5,35.74) 105.58,35.66 109.86,35.66 110.24,35.27 116.02,35.27 116.87,34.43 117.21,34.43 117.7,34.92 127.57,34.92 132.14,30.34 133.52,30.34 134.88,28.99 165.8,28.99 170.61,33.8 180.26,33.8 189.54,43.08 189.54,46.68 188.23,47.98 188.23,52.1 189.38,53.25 192.57,53.25 194.91,50.9 v1(196.73,50.9)
  BOTTOM w0.089: v1(208.1,40.68) 208.1,40.56 208.29,40.37 208.52,40.13 208.52,39.69 208.48,39.64 208.48,39.28 UH1.AH2
  BOTTOM w0.107: v1(126.05,116.81) 126.08,116.78 RH155.1
H_PM_SYNC_R: length 226.7
  IN1 w0.097: v1(197.94,50.8) 197.97,50.77 197.97,50.77 199.84,48.9 199.84,46.54 202.82,43.56 206.07,43.56 207.84,41.78 208.08,41.78 208.48,41.38 208.48,40.69 v1(208.68,40.49)
  IN3 w0.091: v1(131.2,117.95) 132.65,116.5 132.65,115.17 133.35,114.47 135.51,114.47 136.43,113.55 136.43,106.67 132.24,102.48 132.24,99.18 132.86,98.57 132.86,92.88 130.13,90.15 130.13,87.82 124.9,82.59 124.9,74.95 111.88,61.93 111.88,51.18 112.58,50.48 112.58,40.84 114.11,39.31 117.33,39.31 118.37,38.26 118.37,35.02 v1(117.86,34.51)
  IN4 w0.097: v1(197.94,50.8) 197.94,50.8 197.45,50.8 197.15,50.5 194.75,50.5 192.4,52.85 189.55,52.85 188.63,51.93 188.63,48.21 189.94,46.9 189.94,42.92 180.42,33.4 170.78,33.4 165.96,28.59 133.05,28.59 127.12,34.52 118.38,34.52 118.37,34.51 v1(117.86,34.51)
  BOTTOM w0.076: CPU1.BM34 134.56,117.75 133.28,117.75 133.2,117.66 132.62,117.66 132.54,117.59 131.56,117.59 v1(131.2,117.95)
  BOTTOM w0.089: v1(208.68,40.49) 208.75,40.42 208.75,39.63 208.66,39.54 208.66,38.73 208.56,38.64 208.56,38.23 UH1.AJ4
H_PROCHOT#: length 410.4
  TOP w0.107: v1(52.21,22.89) PR724.1 ; v1(73.53,15.06) v2(74.98,13.6) 75.41,13.18 75.41,11.5 75.71,11.2 75.71,9.28 75.41,8.97 75.41,8.57 74.94,8.1 PQ8.1 ; v1(307.18,6.08) 307.69,6.59 RE78.2 308.64,6.59 QE2.1
  IN1 w0.097: v1(175.46,19.91) 176.73,21.18 177.56,21.18 178.91,19.83 178.91,18.3 186.48,10.73 190.64,10.73 191.54,9.83 192.99,9.83 193.67,9.15 204.61,9.15 205.16,9.71 206.49,9.71 206.7,9.5 213.93,9.5 213.94,9.49 221.98,9.49 222.76,10.27 232.52,10.27 233.38,11.12 233.64,11.39 239.84,11.39 241.06,12.6 264.39,12.6 265.47,13.68 273.99,13.68 275.54,15.23 277.56,15.23 278.52,14.27 292.54,14.27 293.78,13.03 295.86,13.03 296.9,11.98 297.81,11.98 298.64,11.16 298.64,9.38 300.17,7.85 304,7.85 306.04,5.81 306.91,5.81 v1(307.18,6.08)
  IN3 w0.091: v1(128.27,115.83) 127.83,115.4 127.83,113.9 129.44,112.29 129.44,105.73 125.59,101.87 125.59,100.42 118.28,93.11 118.28,77.38 106.12,65.22 106.12,58.18 105.04,57.1 105.04,54.94 105.46,54.52 105.46,52.3 106.32,51.43 106.32,34.46 105.57,33.7 105.57,32.21 100.19,26.83 99.29,26.83 98.57,26.11 98.57,22.26 v1(98.18,21.88)
  IN4 w0.097: v1(52.21,22.89) 53.22,22.89 54.68,21.43 54.68,18.64 56.36,16.96 56.36,14.17 57.13,13.39 71.87,13.39 v1(73.53,15.06) 75.18,16.71 81.21,16.71 83.71,19.21 92.06,19.21 94.72,21.88 v1(98.18,21.88) 98.18,21.24 97.48,20.54 97.48,17.37 98.12,16.73 109.29,16.73 109.86,17.3 135.01,17.3 137.61,19.91 v1(175.46,19.91)
  BOTTOM w0.107: RH165.2 v1(128.27,115.83) RH158.1
H_THERMTRIP#: length 107.1
  TOP w0.254: RH163.2 167.02,115.42 v1(167.6,116)
  IN4 w0.097: v1(167.6,116) 168.01,115.59 168.01,104.39 168.98,103.41 172.28,103.41 172.41,103.29 172.41,95.43 177.3,90.54 177.3,81.69 179.52,79.47 179.52,64.68 180.22,63.98 v1(185.55,63.98)
  BOTTOM w0.076: v1(167.6,116) 167.93,115.66 CPU1.J31
  BOTTOM w0.107: RH79.2 207.85,43.79 203.14,43.79 200.41,46.51 200.41,50.77 203.23,53.59 203.23,55.19 202.41,56.01 202.41,57.85 199.6,60.66 196.43,60.66 193.12,63.98 v1(185.55,63.98)
H_THERMTRIP#_R: length 5.4
  BOTTOM w0.089: UH1.AJ3 208.33,38.42 208.24,38.33 208.06,38.33 208,38.39 208,39.18 208.3,39.48 208.3,39.72 208.35,39.76 208.35,40.06 208.13,40.27 207.99,40.27 207.65,40.62 207.65,41.02 207.62,41.05 207.62,41.29
  BOTTOM w0.107: RH79.1 208.16,41.83 207.62,41.29
H_VCCST_PWRGD: length 222.7
  TOP w0.107: Q7.3 319.89,44.64 319.29,44.04 319.29,40.16 318.27,39.15 318.27,31.77 314.59,28.08 v1(314.59,24.69) ; UE5.123 v1(305.43,20.21) ; v1(177.61,96.87) 177.05,97.44 175.64,97.44 CH193.1 174.7,98.38 174.7,99.43 RH164.2 RH154.1
  IN1 w0.097: v1(305.43,20.21) 309.68,20.21 314.15,24.69 v1(314.59,24.69)
  IN3 w0.089: 218.56,42.08 219.09,41.55 219.18,41.55
  IN3 w0.091: 218.56,42.08 217.9,42.74 216.7,42.74 211.32,48.13 211.32,49.92 211.78,50.39 211.78,58.88 210.59,60.08 209.37,60.08 207.01,62.44 v1(207.01,67.68) ; v1(305.43,20.21) 305.43,21.89 302.97,24.34 302.97,29.18 302.04,30.1 292.11,30.1 287.79,34.43 284.88,34.43 283.19,36.12 278.7,36.12 278.03,36.78 258.1,36.78 257.53,37.36 248.37,37.36 247.63,36.62 239.44,36.62 237.22,38.84 230.55,38.84 229.85,39.54 227.25,39.54 226.56,38.84 225.04,38.84 222.34,41.55 219.18,41.55
  IN4 w0.097: v1(207.01,67.68) 207,67.68 204,70.68 203.54,70.68 200.04,74.18 199.29,74.18 198.33,75.14 195.77,75.14 195.18,75.74 194.37,75.74 192.67,77.45 191.94,77.45 186.83,82.56 186.83,94.14 184.35,96.62 177.87,96.62 v1(177.61,96.87)
HDA_SPKR: length 263.5
  TOP w0.107: v1(36.2,50.58) 36.37,50.41 v2(36.37,46.58) 36.37,39.56 39.63,36.31 39.63,34.38 41.39,32.62 41.39,31.36 41.41,31.34 41.41,26.51 41.29,26.39 DA1.3
  IN1 w0.097: v1(200.05,51.19) 201.56,49.68 201.56,47.09 203.49,45.16 206.73,45.16 210.24,41.65 210.24,40.28 209.62,39.67 209.62,34.99 210.51,34.1 210.51,32.42 211.4,31.53 212.35,31.53 213.37,30.51 213.88,30.51 214.45,29.94 214.45,29.43 216.74,27.14 217,27.14 217.44,26.7 v1(217.44,26.31)
  IN4 w0.097: v1(36.2,50.58) 36.61,50.17 45.31,50.17 45.81,49.67 54.93,49.67 55.39,50.13 66.74,50.13 67.29,49.57 67.46,49.41 83.98,49.41 85.14,50.57 90.21,50.57 91.12,49.67 97.06,49.67 97.29,49.44 99.36,49.44 104.96,43.83 104.96,35.71 105.91,34.76 108.47,34.76 110.5,32.73 127.2,32.73 132.55,27.38 166.46,27.38 171.27,32.2 180.92,32.2 191.14,42.42 191.14,47.4 189.84,48.71 189.84,51.43 190.05,51.64 191.91,51.64 194.25,49.3 198.42,49.3 200.05,50.93 v1(200.05,51.19)
  BOTTOM w0.089: UH1.BD26 216.17,27.14 216.94,27.14 217.44,26.63 v1(217.44,26.31)
HDMI_CTRLCLK: length 103.6
  IN1 w0.089: v1(212.09,96.95) 212.36,96.68 212.49,96.68 212.62,96.81 212.62,97.11 207.73,102 207.73,103.31 205.99,105.05 205.99,105.51 205.55,105.95 205.09,105.95 203.15,107.89 203.15,111.7 198.74,116.11 198.74,124.09 198.29,124.54 198.29,143.64 202.75,148.1 209.35,148.1 209.64,148.39 215.46,148.39 216.83,149.76 216.83,150.93 217.43,151.53 217.43,152.11 v1(217.05,152.5)
  IN4 w0.089: v1(212.09,96.95) 210.95,96.95 209.88,95.87 209.88,90.57 210.35,90.1 210.35,87.77 212.29,85.82 213.91,85.82 217.27,82.47 218.41,82.47 218.78,82.16 218.83,81.92 v1(218.83,81.69)
  BOTTOM w0.089: U1.34 217.16,153.06 217.25,152.97 217.25,152.7 v1(217.05,152.5)
  BOTTOM w0.107: v1(218.83,81.69) 218.98,81.69 219.58,81.09 219.58,80.94 219.78,80.74 219.78,80.68 219.94,80.52 UG1.BC41
HDMI_CTRLDAT: length 103.6
  IN1 w0.089: v1(217.64,152.5) 217.64,151.45 217.03,150.84 217.03,149.67 215.54,148.19 209.73,148.19 209.44,147.9 202.83,147.9 198.49,143.55 198.49,124.63 198.94,124.17 198.94,116.19 203.35,111.78 203.35,107.98 205.18,106.15 205.63,106.15 206.19,105.59 206.19,105.14 207.93,103.4 207.93,102.08 212.82,97.2 212.82,96.72 212.57,96.47 212.2,96.47 v1(212.09,96.36)
  IN4 w0.089: v1(219.4,81.81) 219.28,81.81 218.98,82.1 218.95,82.27 218.48,82.65 218.47,82.65 217.38,82.65 214,86.02 212.38,86.02 210.55,87.85 210.55,90.18 210.08,90.65 210.08,95.79 211.03,96.75 211.71,96.75 v1(212.09,96.36)
  BOTTOM w0.089: U1.33 217.56,153.07 217.47,152.98 217.47,152.66 v1(217.64,152.5)
  BOTTOM w0.107: UG1.BB40 220.62,80.55 220.51,80.44 220.32,80.44 220,80.77 220,80.83 219.8,81.03 219.8,81.18 219.4,81.57 v1(219.4,81.81)
HDMI_DCIN_EN: length 2.6
  BOTTOM w0.107: RV203.1 215.65,161.16 216.55,160.26 216.88,160.26 217.16,159.98 U1.3
HDMI_EQ: length 2.6
  BOTTOM w0.107: U1.5 217.96,159.98 217.62,160.32 217.62,161.16 RV199.1 RV198.2
HDMI_HPD: length 9.8
  TOP w0.107: v1(214.32,160.88) v2(214.32,161.47)
  IN2 w0.091: v1(214.32,160.88) 214.3,160.88 213.06,159.65 213.06,157.12 v1(214.73,155.45)
  BOTTOM w0.107: v1(214.73,155.45) 214.87,155.58 U1.40 ; RX6.2 CX2.1 214.16,161.04 v1(214.32,160.88)
HDMI_HPD_GPU: length 143.5
  TOP w0.107: v1(227.39,160.57) 227.57,160.75 v2(228.06,160.75) 228.23,160.59 RX7.2
  IN1 w0.097: v1(227.39,160.57) 227.38,160.58 226.1,160.58 222.79,157.27 214.4,157.27 213.57,158.1 212.11,158.1 v1(210.67,156.66)
  IN4 w0.097: v1(229.62,85.55) 227.6,83.53 225.92,83.53 224.54,84.91 224.54,85.02 223.78,85.78 219.33,85.78 218.13,84.58 216.61,84.58 214.53,86.66 214.53,88.4 213.13,89.8 213.13,97.72 212.29,98.56 212.29,100.62 212.89,101.22 212.89,101.67 212.59,101.96 212.24,101.96 211.4,101.12 208.93,101.12 205.07,104.98 205.07,108.35 202.42,111 202.42,132.44 204.82,134.84 204.82,139.5 206.13,140.81 208.03,140.81 210.51,143.29 210.51,144.24 212.15,145.88 215.96,145.88 216.87,146.79 226.25,146.79 228.06,148.61 228.06,150.51 227.66,150.92 227.66,160.31 v1(227.39,160.57)
  BOTTOM w0.089: v1(229.62,85.55) 230.07,86 UG1.AT29
  BOTTOM w0.107: UX2.4 209.93,157.41 v1(210.67,156.66)
HDMI_HPD_PCH: length 173.6
  IN2 w0.091: v1(210.39,155.24) 210.91,154.72 210.91,151.02 209.15,149.26 203.77,149.26 200.71,146.21 200.71,121.78 202.69,119.8 202.69,110.85 203.03,110.51 203.03,98.21 204.19,97.05 204.19,91.04 203.89,90.74 203.89,86.08 204.53,85.43 204.53,79.09 205.15,78.47 205.15,73.54 v1(204.67,73.06)
  IN3 w0.089: v1(213.18,20.42) 212.86,20.73 212.86,21.3 212.67,21.5 212.27,21.5 210.72,23.05 210.72,24.24 209.51,25.44 206.83,25.44 206.74,25.35 202.89,25.35 202.5,25.74 202.5,29.99 203.09,30.59 203.09,31.74 203.82,32.46 203.82,39.52 201.4,41.94 201.4,42.08
  IN3 w0.091: 201.4,42.08 201.4,42.19 200.86,42.72 200.86,50.2 201.56,50.89 201.56,57.9 198.5,60.96 196.72,60.96 195.74,61.93 195.74,64.31 197.12,65.68 197.12,69.51 198.6,70.99 201.98,70.99 204.04,73.06 v1(204.67,73.06)
  BOTTOM w0.089: v1(213.18,20.42) 212.66,19.9 UH1.AU41
  BOTTOM w0.107: v1(210.39,155.24) RX8.1 209.7,156.67 209.22,157.16 209.22,157.82 209.4,158.01 210.74,158.01 211.44,158.71 UX2.1 211.7,159.69 QX3.3
HDMI_HPLUG: length 32.4
  TOP w0.107: v1(222.58,155.63) 223.48,155.63 v2(223.53,155.68)
  IN4 w0.097: JHDMI.19 221.12,173.81 222.09,172.84 222.09,168.08 225.93,164.24 225.93,158.99 227.1,157.82 227.1,153.31 226.36,152.57 224.18,152.57 223.49,153.26 223.49,154.73 v1(222.58,155.63)
  BOTTOM w0.107: v1(222.58,155.63) 222.53,155.58 U1.21
HDMI_I2C_ADDR: length 2.2
  BOTTOM w0.107: U1.31 218.36,152.69 v2(218.59,152.47) 218.59,152 RV202.2
HDMI_ID: length 2
  BOTTOM w0.107: RV204.2 218.12,152.89 217.96,153.04 U1.32
HDMI_PRE: length 1.9
  BOTTOM w0.107: U1.6 218.36,160.33 218.44,160.41 218.44,160.99 218.61,161.16 RV197.1
HP2_D_L1_JK: length 27.9
  TOP w0.254: LA12.1 21.34,23.9 CA50.1 21.12,24.37 20.8,24.68 19.64,24.68 19.38,24.95 v2(19.38,26.54) 19.1,26.82 19.1,28.65 v1(20.07,29.62)
  BOTTOM w0.254: JACK2.1 15.45,17 16.46,18.01 16.46,23.63 17.03,24.2 17.03,27.53 18.49,28.99 18.49,29.88 19.6,30.99 DA6.3 20.06,30 20.07,29.99 v1(20.07,29.62)
HP2_D_L_C:
  vias: v1(26.93,26.19) v1(26.93,25.56) v2(26.62,27.02)
HP2_D_L_R: length 7.7
  TOP w0.107: RA46.1 v2(25.28,28.86)
  TOP w0.254: RA46.1 24.46,28.84 RA43.2 24.46,27.34 24.79,27.01 RA41.2 24.53,26.57 24.28,26.32 24.28,25.31 23.95,24.99 RA44.1 22.68,24.92 LA12.2
HP2_D_R1_JK: length 29.6
  TOP w0.254: v1(20.8,30) 20.54,30.26 19.82,30.26 v2(19.1,29.53) 18.68,29.12 18.68,24.77 19.8,23.65 20.09,23.65 CA48.1 22,22.56 LA11.1
  IN1 w0.254: JACK2.2 8.82,27.35 16.91,27.35 20.56,30.99 v1(20.99,30.99)
  BOTTOM w0.254: v1(20.99,30.99) DA6.2 21.99,30.21 21.73,29.94 20.86,29.94 v1(20.8,30)
HP2_D_R_C: length 0.7
  TOP w0.127: v1(25.15,23.53) v2(25.15,22.83)
  vias: v1(25.79,23.53)
HP2_D_R_R: length 6.5
  TOP w0.254: RA45.1 23.61,21.71 LA11.2 22.96,22.55 23.71,23.29 v2(23.71,23.3) 24.46,24.05 RA42.2 24.69,24.46 24.69,25.02 RA40.2 24.79,25.72 v1(24.78,25.72)
  IN3 w0.254: v1(23.69,25.72) v1(24.78,25.72)
  vias: v1(23.48,26.27)
HP_LINE1_JD: length 6.6
  TOP w0.107: RA34.1 RA36.1 37.14,30.57 v1(36.56,29.99) 36.26,29.99 35.95,29.69 v2(34.87,29.69)
  BOTTOM w0.107: UA1.9 36.47,29.91 v1(36.56,29.99) 37.16,29.99 RA34.1 RA32.2
HP_MUTE#: length 29.6
  TOP w0.203: v1(19.88,26.13) 19.88,26.66 19.66,26.89 19.66,28.48 20.53,29.36 v2(20.87,29.36) 21.42,29.36 UA2.B1 ; UA3.B1 18.88,23.58 18.83,23.58 v1(18.75,23.65)
  TOP w0.254: v1(19.88,26.13) 19.94,26.08 RA13.2
  IN1 w0.254: v1(19.88,26.13) 18.75,25 v1(18.75,23.65)
  IN3 w0.254: v1(18.75,23.65) 23.01,23.65 23.85,22.82 26.76,22.82 28.05,24.11 35.01,24.11 v1(36.09,23.03)
  BOTTOM w0.254: v1(36.09,23.03) 36.55,22.57 DA2.1
HPOUT-L: length 14.7
  IN4 w0.254: v1(27.52,28.77) 27.66,28.77 28.41,28.02 28.41,25.33 24.9,21.81 v1(24.9,20.16)
  BOTTOM w0.203: v1(27.52,28.77) 27.6,28.77 27.94,29.11 UA1.32
  BOTTOM w0.254: v1(24.9,20.16) 24.9,19.59 25.47,19.02 25.47,18.33 RA35.1
HPOUT-R: length 22.3
  TOP w0.254: v1(19.4,19.91) RA37.1
  IN4 w0.254: v1(27.52,29.39) 27.87,29.39 28.99,28.28 28.99,24.75 27.63,23.4 27.63,20.36 26.17,18.89 24.33,18.89 22.93,20.29 19.78,20.29 v1(19.4,19.91)
  BOTTOM w0.203: v1(27.52,29.39) 27.64,29.51 UA1.33
HPOUT_JD: length 38.6
  TOP w0.107: v1(39.86,28.79) 39.41,29.24 v2(39.38,29.24) 38.83,29.24 RA34.2
  IN2 w0.254: v1(39.86,28.79) 38.17,28.79 37.16,27.78 36.62,27.78 36.43,27.96 35.44,27.96 34.43,26.96 32.19,26.96 31.53,26.3 29.38,26.3 25.41,22.32 22.14,22.32 20.67,20.85 20.67,19.31 18.12,16.76 18.12,16.14 17.62,15.64 12.57,15.64 10.73,13.8 JACK1.6
I2C0_SCL_EC: length 374.1
  TOP w0.107: v1(327.09,14.85) 326.59,15.36 JIO.12 ; RA56.1 40.08,16.82 41.53,16.82 42.34,16.01 42.34,12.64 41.62,11.93 v1(41.44,11.93) ; UE5.83 v1(300.34,6.91)
  IN1 w0.097: v1(300.34,6.91) 300.81,6.45 301.2,6.45 301.96,7.21 303.76,7.21 305.78,5.19 312.92,5.19 313.78,6.04 325.4,6.04 328.02,8.67 328.02,12.87 326.87,14.03 326.87,14.64 v1(327.09,14.85)
  IN2 w0.091: v1(327.09,14.85) 326.67,15.27 326.3,15.27 325.48,14.45 323.43,14.45 319.21,10.23 312.9,10.23 312.64,10.5 302.2,10.5 300.95,11.75 296.18,11.75 295.96,11.97 291.15,11.97 289.96,13.16 276.38,13.16 275.45,14.09 266.98,14.09 266.87,13.98 256.8,13.98 255.83,13.02 234.17,13.02 233.75,13.45 231.56,13.45 230.59,12.48 227.83,12.48 226.35,13.96 215.41,13.96 213.06,11.61 207.29,11.61 206.28,10.6 204.09,10.6 203.68,10.19 202.04,10.19 201.49,10.73 194.33,10.73 193.3,11.76 188.22,11.76 184.05,15.93 184.04,15.93 183.65,16.32 101.34,16.32 100.42,15.4 98.5,15.4 97.23,14.13 85.73,14.13 84.6,13 84.31,12.71 70.07,12.71 68.48,11.12 62.37,11.12 62.03,11.45 56.17,11.45 53.76,13.86 41.28,13.86 40.79,13.37 40.79,12.4 41.26,11.93 v1(41.44,11.93)
  IN4 w0.097: v1(36.96,28.26) 36.7,28.01 36.7,18.98 38.49,17.2 38.49,14.51 37.35,13.37 37.35,11.21 38.03,10.52 39.32,10.52 40.72,11.93 v1(41.44,11.93)
  BOTTOM w0.107: v1(36.96,28.26) 36.61,28.26 36.17,28.71 UA1.12
I2C0_SCL_EC_R: length 8.4
  TOP w0.107: RA56.2 39.57,13.31 40.08,12.8 40.08,10.95 v2(39.47,10.35) 39.24,10.12 v1(38.49,10.12) 38.35,10.12 38.25,10.01 UA4.8
  BOTTOM w0.107: v1(38.49,10.12) 38.84,10.12 RA50.2
I2C0_SDA_EC: length 368
  TOP w0.107: JIO.11 v1(326.45,14.85) ; v1(41.41,12.53) 41.59,12.53 42,12.93 v2(42,13.99) 42,15.72 41.41,16.31 RA55.1 ; UE5.84 300.74,7.11 v1(300.94,6.91)
  IN1 w0.097: v1(300.94,6.91) 301.47,7.45 303.84,7.45 305.87,5.41 312.83,5.41 313.68,6.26 325.3,6.26 327.8,8.76 327.8,12.73 326.65,13.88 326.65,14.66 v1(326.45,14.85)
  IN2 w0.091: v1(326.45,14.85) 325.83,14.23 323.52,14.23 319.3,10.01 312.81,10.01 312.54,10.28 302.11,10.28 300.86,11.54 296.09,11.54 295.87,11.75 291.05,11.75 289.87,12.94 276.29,12.94 275.36,13.87 267.07,13.87 266.96,13.76 256.89,13.76 255.93,12.8 234.08,12.8 233.65,13.23 231.65,13.23 230.68,12.26 227.74,12.26 226.26,13.74 215.5,13.74 213.15,11.39 207.38,11.39 206.37,10.38 204.18,10.38 203.77,9.97 201.95,9.97 201.4,10.51 194.23,10.51 193.21,11.54 188.13,11.54 183.96,15.72 183.95,15.72 183.56,16.1 101.44,16.1 100.51,15.18 98.59,15.18 97.32,13.91 85.82,13.91 84.69,12.78 84.4,12.49 70.16,12.49 68.57,10.9 62.28,10.9 61.94,11.23 56.08,11.23 53.67,13.65 41.37,13.65 41,13.28 41,12.62 41.1,12.53 v1(41.41,12.53)
  IN4 w0.097: v1(41.41,12.53) 41,12.53 39.22,10.75 38.12,10.75 37.57,11.3 37.57,13.27 38.74,14.45 38.74,17.3 37.2,18.85 37.2,27.09 37.36,27.26 37.36,28.58 37.11,28.83 36.62,28.83 v1(36.54,28.91)
  BOTTOM w0.107: UA1.11 36.34,29.11 v1(36.54,28.91)
I2C0_SDA_EC_R: length 9.2
  TOP w0.107: RA55.2 40.45,13.12 v2(40.46,13.11) 40.65,12.92 40.65,10.7 39.43,9.48 v1(38.49,9.48) 38.45,9.48 38.31,9.61 UA4.7
  BOTTOM w0.107: RA53.2 39.09,9.48 v1(38.49,9.48)
I2C_CLK: length 492.5
  TOP w0.107: v1(226.26,153.79) 226.06,153.99 224.37,153.99 224.02,153.63 222.34,153.63 221.87,154.1 221.87,154.86 221.77,154.97 221.61,154.97 221.47,154.83 UE3.25 ; UE4.25 189.6,23.18 v1(189.49,23.3) ; CE58.1 RE2.2 312.13,19.39 312.13,19.01 v1(312.3,18.84) ; UE1.29 313.24,13.13 313.52,12.84 314.28,12.84 314.59,12.54 314.59,12.31 v1(314.8,12.1)
  IN1 w0.097: v1(197.1,172.16) 196.92,172.34 196.31,172.34 195.2,173.45 194.4,173.45 193.42,174.43 191.39,174.43 189.51,176.31 188.07,176.31 187.08,175.32 175.52,175.32 174.94,175.9 173.63,175.9 172.75,175.02 171.11,175.02 170.76,175.37 170.76,175.64 v1(170.58,175.82) ; v1(181.87,24.18) 182.05,24 182.32,24 182.55,23.78 182.55,22.62 181.94,22 181.94,18.51 186.22,14.23 189.43,14.23 190.1,13.56 190.24,13.56 v1(190.31,13.62) 190.53,13.4 190.71,13.4 192.77,11.33 198.7,11.33 198.7,11.34 202.37,11.34 202.7,11 203.38,11 203.6,11.21 207.38,11.21 207.59,11 213.52,11 214.29,11.77 230.3,11.77 231.42,12.89 239.22,12.89 240.44,14.11 263.76,14.11 266.92,17.27 273.47,17.27 273.95,17.75 277.16,17.75 278.11,18.69 299.91,18.69 300.74,19.52 309.88,19.52 310.26,19.9 311.8,19.9 312.11,19.59 312.11,19.03 v1(312.3,18.84)
  IN3 w0.091: v1(226.26,153.79) 226.42,153.94 226.66,153.94 226.84,153.75 226.84,153.23 226.59,152.98 223.93,152.98 222.66,151.71 215.58,151.71 213.82,149.96 206.74,149.96 206.37,150.33 202.89,150.33 200.61,148.05 197.62,148.05 196.79,147.22 196.79,111.26 201.3,106.75 201.3,102.8 204.55,99.56 204.55,92.42 201.35,89.23 200.59,89.23 198.98,87.62 192.38,87.62 189.06,84.3 189.06,73.38 188.36,72.68 188.36,49.3 189.76,47.91 189.76,41.62 191.56,39.82 191.56,35.11 190.19,33.74 190.19,32.04 184.32,26.17 184.32,25.65 182.61,23.94 182.12,23.94 v1(181.87,24.18) ; v1(312.3,18.84) 308.97,22.16 308.97,27.78 303.44,33.31 292.4,33.31 289.77,35.94 289.77,38.93 287.59,41.12 287.59,41.54 287.7,41.66 287.82,41.66 v1(288.01,41.47) 288.19,41.66 288.67,41.66 288.91,41.9 288.91,44.38 290.14,45.61 292.97,45.61 293.94,46.58 293.94,47.17 294.85,48.08 294.85,55.84 294.18,56.51 293.73,56.51 v1(293.51,56.74)
  IN4 w0.097: v1(197.1,172.16) 197.29,172.35 198.42,172.35 199.2,173.12 201.32,173.12 201.72,172.72 201.72,171.9 203.65,169.96 207.78,169.96 209.24,168.5 220.91,168.5 223.18,166.23 223.18,163.26 224.25,162.19 224.25,154.7 224.95,153.99 226.06,153.99 v1(226.26,153.79)
  BOTTOM w0.107: v1(170.58,175.82) 170.76,176 170.76,176.37 170.47,176.66 JCDRA.45 ; v1(314.8,12.1) 314.62,12.28 314.62,13.78 312.1,16.3 312.1,18.63 v1(312.3,18.84) ; v1(189.49,23.3) 189.29,23.1 189.29,22.44 188.54,21.69 188.54,14.38 189.49,13.43 190.12,13.43 v1(190.31,13.62) ; UE8.25 288.46,41.55 288.42,41.59 288.13,41.59 v1(288.01,41.47) ; v1(293.51,56.74) PR6079.1
I2C_CTL_EN: length 5.6
  BOTTOM w0.107: RV22.1 186.73,107.67 186.73,109.03 RV21.1 187.3,109.49 187.82,110.02 188.35,110.02 188.59,110.26 UV21.53
I2C_DAT: length 491.1
  TOP w0.107: UE3.26 221.52,155.33 221.65,155.2 221.86,155.2 222.11,154.96 222.11,154.2 222.44,153.87 223.92,153.87 224.28,154.22 226.12,154.22 226.26,154.36 v1(226.26,154.37) ; v1(314.21,12.1) 314.35,12.24 314.35,12.44 314.19,12.61 313.57,12.61 313.3,12.33 UE1.30 ; v1(311.72,18.84) 311.89,19.01 311.89,19.39 RE1.2 ; v1(188.91,23.3) 189.1,23.1 UE4.26
  IN1 w0.097: v1(311.72,18.84) 311.89,19.01 311.89,19.5 311.71,19.68 310.36,19.68 309.98,19.3 300.83,19.3 300.01,18.47 278.2,18.47 277.26,17.52 274.04,17.52 273.56,17.04 267.01,17.04 263.86,13.88 240.53,13.88 239.31,12.67 231.51,12.67 230.4,11.55 214.38,11.55 213.61,10.78 207.5,10.78 207.28,10.99 203.69,10.99 203.48,10.78 202.61,10.78 202.27,11.11 198.79,11.11 198.79,11.11 192.68,11.11 190.61,13.18 190.45,13.18 v1(190.31,13.04) 190.16,13.18 190.16,13.18 189.34,14 186.12,14 181.71,18.42 181.71,22.1 182.32,22.71 182.32,23.68 182.23,23.78 182.05,23.78 v1(181.87,23.6) ; v1(171.16,175.82) 170.98,175.64 170.98,175.46 171.2,175.24 172.65,175.24 173.54,176.13 175.03,176.13 175.62,175.54 186.99,175.54 187.98,176.53 189.6,176.53 190.38,175.76 191.48,174.65 193.51,174.65 194.49,173.67 195.29,173.67 196.4,172.56 196.92,172.56 v1(197.1,172.74)
  IN3 w0.091: v1(293.51,56.1) 293.7,56.29 294.09,56.29 294.63,55.75 294.63,48.17 293.72,47.26 293.72,46.67 292.88,45.83 290.05,45.83 288.69,44.47 288.69,41.99 288.58,41.88 288.18,41.88 v1(288.01,42.06) 287.83,41.88 287.61,41.88 287.37,41.63 287.37,41.03 289.55,38.84 289.55,35.85 292.31,33.09 303.35,33.09 308.76,27.68 308.76,21.8 v1(311.72,18.84) ; v1(181.87,23.6) 181.99,23.72 182.7,23.72 184.54,25.56 184.54,26.08 190.41,31.95 190.41,33.65 191.78,35.02 191.78,39.91 189.98,41.71 189.98,48 188.58,49.39 188.58,72.59 189.28,73.29 189.28,84.21 192.47,87.4 199.07,87.4 200.68,89.01 201.44,89.01 204.77,92.33 204.77,99.65 201.52,102.89 201.52,106.84 197.01,111.35 197.01,147.13 197.71,147.83 200.7,147.83 202.98,150.11 206.28,150.11 206.65,149.74 213.91,149.74 215.67,151.49 222.75,151.49 224.02,152.76 226.68,152.76 227.06,153.14 227.06,153.84 226.75,154.16 226.48,154.16 v1(226.26,154.37)
  IN4 w0.097: v1(197.1,172.74) 197.27,172.57 198.33,172.57 199.1,173.34 201.41,173.34 201.94,172.82 201.94,171.99 203.75,170.18 207.87,170.18 209.33,168.72 221.01,168.72 223.4,166.33 223.4,163.35 224.47,162.28 224.47,154.79 225.04,154.22 226.11,154.22 v1(226.26,154.37)
  BOTTOM w0.107: PR6080.1 293.25,55.85 v1(293.51,56.1) ; v1(314.21,12.1) 314.39,12.28 314.39,13.68 311.87,16.2 311.87,18.68 311.81,18.74 311.81,18.74 v1(311.72,18.84) ; v1(171.16,175.82) 170.99,175.99 170.99,176.38 171.27,176.66 JCDRA.46 ; UE8.26 288.47,42.05 288.34,41.92 288.15,41.92 v1(288.01,42.06) ; v1(190.31,13.04) 190.15,13.2 189.4,13.2 188.31,14.29 188.31,21.78 189.06,22.54 189.06,23.14 v1(188.91,23.3)
I2S_DATA_OUT: length 332.4
  TOP w0.107: UA4.14 38.24,12.41 38.42,12.59 v1(38.42,12.68) ; JIO.18 326.37,18.36 v1(326.45,18.27) ; v1(39.5,31.97) 39.85,32.32 39.85,32.78 40.11,33.04 40.11,33.56 39.66,34.02 39.02,34.02 38.55,33.55 RA33.2
  IN2 w0.091: v1(38.42,12.68) 39.13,12.68 39.51,13.05 39.51,13.33 40.92,14.74 54.12,14.74 56.53,12.32 62.4,12.32 62.73,11.99 68.11,11.99 68.33,12.21 69.7,13.58 83.94,13.58 84.23,13.87 85.37,15.01 96.87,15.01 98.14,16.27 100.06,16.27 100.98,17.19 184.02,17.19 184.33,16.88 184.76,16.88 184.79,16.85 185.55,16.09 190.2,16.09 194.69,11.61 201.85,11.61 202.4,11.06 203.32,11.06 203.73,11.47 205.92,11.47 206.93,12.49 212.7,12.49 215.05,14.84 226.71,14.84 228.19,13.35 230.23,13.35 231.08,14.2 231.08,15.03 231.33,15.28 232.23,15.28 232.83,14.69 241.59,14.69 242.39,13.89 255.47,13.89 256.43,14.85 264.92,14.85 267.56,17.5 268.54,17.5 269.13,18.09 270.92,18.09 272.06,16.94 273.83,16.94 276.74,14.04 290.32,14.04 291.51,12.85 296.32,12.85 296.54,12.63 302.39,12.63 303.24,11.78 309.13,11.78 310.03,12.68 320.07,12.68 324.54,17.15 325.33,17.15 v1(326.45,18.27)
  IN4 w0.097: v1(38.42,12.68) 38.42,13.17 39.79,14.54 39.79,27.24 38.61,28.42 38.61,30.9 39.5,31.79 v1(39.5,31.97)
