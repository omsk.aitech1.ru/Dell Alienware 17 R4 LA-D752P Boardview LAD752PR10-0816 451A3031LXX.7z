# Allegro board LAD752PR10-0816.brd (continued)
## Nets (continued)
DDR_A_D58: CPU1.L4 JDIMM1.245
DDR_A_D59: CPU1.L2 JDIMM1.246
DDR_A_D60: CPU1.M5 JDIMM1.237
DDR_A_D61: CPU1.M2 JDIMM1.232
DDR_A_D62: CPU1.L5 JDIMM1.249
DDR_A_D63: CPU1.L1 JDIMM1.250
DDR_A_DQS0: CPU1.BP5 JDIMM1.13
DDR_A_DQS1: CPU1.BK3 JDIMM1.34
DDR_A_DQS2: CPU1.BF3 JDIMM1.55
DDR_A_DQS3: CPU1.BC3 JDIMM1.76
DDR_A_DQS4: CPU1.AB3 JDIMM1.179
DDR_A_DQS5: CPU1.V3 JDIMM1.200
DDR_A_DQS6: CPU1.R3 JDIMM1.221
DDR_A_DQS7: CPU1.M3 JDIMM1.242
DDR_A_DQS#0: CPU1.BR5 JDIMM1.11
DDR_A_DQS#1: CPU1.BL3 JDIMM1.32
DDR_A_DQS#2: CPU1.BG3 JDIMM1.53
DDR_A_DQS#3: CPU1.BD3 JDIMM1.74
DDR_A_DQS#4: CPU1.AA3 JDIMM1.177
DDR_A_DQS#5: CPU1.U3 JDIMM1.198
DDR_A_DQS#6: CPU1.P3 JDIMM1.219
DDR_A_DQS#7: CPU1.L3 JDIMM1.240
DDR_A_MA0: CPU1.AH3 JDIMM1.144
DDR_A_MA1: CPU1.AP4 JDIMM1.133
DDR_A_MA2: CPU1.AN4 JDIMM1.132
DDR_A_MA3: CPU1.AP5 JDIMM1.131
DDR_A_MA4: CPU1.AP2 JDIMM1.128
DDR_A_MA5: CPU1.AP1 JDIMM1.126
DDR_A_MA6: CPU1.AP3 JDIMM1.127
DDR_A_MA7: CPU1.AN1 JDIMM1.122
DDR_A_MA8: CPU1.AN3 JDIMM1.125
DDR_A_MA9: CPU1.AT4 JDIMM1.121
DDR_A_MA10: CPU1.AH2 JDIMM1.146
DDR_A_MA11: CPU1.AN2 JDIMM1.120
DDR_A_MA12: CPU1.AU4 JDIMM1.119
DDR_A_MA13: CPU1.AE3 JDIMM1.158
DDR_A_PAR: CPU1.AG3 JDIMM1.143
DDR_A_RAS#: CPU1.AH4 JDIMM1.152
DDR_A_WE#: CPU1.AG4 JDIMM1.151
DDR_B_ACT#: CPU1.AT9 JDIMM2.114
DDR_B_ALERT#: CPU1.AR8 JDIMM2.116
DDR_B_BG0: CPU1.AR9 JDIMM2.115
DDR_B_BG1: CPU1.AR7 JDIMM2.113
DDR_B_BS0: CPU1.AH8 JDIMM2.150
DDR_B_BS1: CPU1.AH9 JDIMM2.145
DDR_B_CAS#: CPU1.AF8 JDIMM2.156
DDR_B_D0: CPU1.BT11 JDIMM2.3
DDR_B_D1: CPU1.BR11 JDIMM2.8
DDR_B_D2: CPU1.BT8 JDIMM2.16
DDR_B_D3: CPU1.BR8 JDIMM2.21
DDR_B_D4: CPU1.BP11 JDIMM2.7
DDR_B_D5: CPU1.BN11 JDIMM2.4
DDR_B_D6: CPU1.BP8 JDIMM2.17
DDR_B_D7: CPU1.BN8 JDIMM2.20
DDR_B_D8: CPU1.BL12 JDIMM2.24
DDR_B_D9: CPU1.BL11 JDIMM2.28
DDR_B_D10: CPU1.BL8 JDIMM2.25
DDR_B_D11: CPU1.BJ8 JDIMM2.42
DDR_B_D12: CPU1.BJ11 JDIMM2.37
DDR_B_D13: CPU1.BJ10 JDIMM2.41
DDR_B_D14: CPU1.BL7 JDIMM2.29
DDR_B_D15: CPU1.BJ7 JDIMM2.38
DDR_B_D16: CPU1.BG11 JDIMM2.45
DDR_B_D17: CPU1.BG10 JDIMM2.49
DDR_B_D18: CPU1.BG8 JDIMM2.50
DDR_B_D19: CPU1.BF8 JDIMM2.59
DDR_B_D20: CPU1.BF11 JDIMM2.62
DDR_B_D21: CPU1.BF10 JDIMM2.58
DDR_B_D22: CPU1.BG7 JDIMM2.46
DDR_B_D23: CPU1.BF7 JDIMM2.63
DDR_B_D24: CPU1.BB11 JDIMM2.84
DDR_B_D25: CPU1.BC11 JDIMM2.67
DDR_B_D26: CPU1.BB8 JDIMM2.79
DDR_B_D27: CPU1.BC8 JDIMM2.66
DDR_B_D28: CPU1.BC10 JDIMM2.71
DDR_B_D29: CPU1.BB10 JDIMM2.80
DDR_B_D30: CPU1.BC7 JDIMM2.70
DDR_B_D31: CPU1.BB7 JDIMM2.83
DDR_B_D32: CPU1.AA11 JDIMM2.187
DDR_B_D33: CPU1.AA10 JDIMM2.183
DDR_B_D34: CPU1.AC11 JDIMM2.174
DDR_B_D35: CPU1.AC10 JDIMM2.170
DDR_B_D36: CPU1.AA7 JDIMM2.182
DDR_B_D37: CPU1.AA8 JDIMM2.186
DDR_B_D38: CPU1.AC8 JDIMM2.169
DDR_B_D39: CPU1.AC7 JDIMM2.173
DDR_B_D40: CPU1.W8 JDIMM2.191
DDR_B_D41: CPU1.W7 JDIMM2.195
DDR_B_D42: CPU1.V10 JDIMM2.203
DDR_B_D43: CPU1.V11 JDIMM2.207
DDR_B_D44: CPU1.W11 JDIMM2.190
DDR_B_D45: CPU1.W10 JDIMM2.194
DDR_B_D46: CPU1.V7 JDIMM2.208
DDR_B_D47: CPU1.V8 JDIMM2.204
DDR_B_D48: CPU1.R11 JDIMM2.216
DDR_B_D49: CPU1.P11 JDIMM2.228
DDR_B_D50: CPU1.P7 JDIMM2.225
DDR_B_D51: CPU1.R8 JDIMM2.215
DDR_B_D52: CPU1.R10 JDIMM2.211
DDR_B_D53: CPU1.P10 JDIMM2.224
DDR_B_D54: CPU1.R7 JDIMM2.212
DDR_B_D55: CPU1.P8 JDIMM2.229
DDR_B_D56: CPU1.L11 JDIMM2.245
DDR_B_D57: CPU1.M11 JDIMM2.236
DDR_B_D58: CPU1.L7 JDIMM2.250
DDR_B_D59: CPU1.M8 JDIMM2.232
DDR_B_D60: CPU1.L10 JDIMM2.249
DDR_B_D61: CPU1.M10 JDIMM2.233
DDR_B_D62: CPU1.M7 JDIMM2.237
DDR_B_D63: CPU1.L8 JDIMM2.246
DDR_B_DQS0: CPU1.BR9 JDIMM2.13
DDR_B_DQS1: CPU1.BJ9 JDIMM2.34
DDR_B_DQS2: CPU1.BF9 JDIMM2.55
DDR_B_DQS3: CPU1.BB9 JDIMM2.76
DDR_B_DQS4: CPU1.AA9 JDIMM2.179
DDR_B_DQS5: CPU1.V9 JDIMM2.200
DDR_B_DQS6: CPU1.P9 JDIMM2.221
DDR_B_DQS7: CPU1.L9 JDIMM2.242
DDR_B_DQS#0: CPU1.BP9 JDIMM2.11
DDR_B_DQS#1: CPU1.BL9 JDIMM2.32
DDR_B_DQS#2: CPU1.BG9 JDIMM2.53
DDR_B_DQS#3: CPU1.BC9 JDIMM2.74
DDR_B_DQS#4: CPU1.AC9 JDIMM2.177
DDR_B_DQS#5: CPU1.W9 JDIMM2.198
DDR_B_DQS#6: CPU1.R9 JDIMM2.219
DDR_B_DQS#7: CPU1.M9 JDIMM2.240
DDR_B_MA0: CPU1.AJ9 JDIMM2.144
DDR_B_MA1: CPU1.AK6 JDIMM2.133
DDR_B_MA2: CPU1.AK5 JDIMM2.132
DDR_B_MA3: CPU1.AL5 JDIMM2.131
DDR_B_MA4: CPU1.AL6 JDIMM2.128
DDR_B_MA5: CPU1.AM6 JDIMM2.126
DDR_B_MA6: CPU1.AN7 JDIMM2.127
DDR_B_MA7: CPU1.AN10 JDIMM2.122
DDR_B_MA8: CPU1.AN8 JDIMM2.125
DDR_B_MA9: CPU1.AR11 JDIMM2.121
DDR_B_MA10: CPU1.AH7 JDIMM2.146
DDR_B_MA11: CPU1.AN11 JDIMM2.120
DDR_B_MA12: CPU1.AR10 JDIMM2.119
DDR_B_MA13: CPU1.AF9 JDIMM2.158
DDR_B_PAR: CPU1.AJ7 JDIMM2.143
DDR_B_RAS#: CPU1.AH10 JDIMM2.152
DDR_B_WE#: CPU1.AH11 JDIMM2.151
DDR_CKE0_DIMMA: CPU1.AT1 JDIMM1.109
DDR_CKE1_DIMMA: CPU1.AT2 JDIMM1.110
DDR_CKE2_DIMMB: CPU1.AT8 JDIMM2.109
DDR_CKE3_DIMMB: CPU1.AT10 JDIMM2.110
DDR_CS0_DIMMA#: CPU1.AD5 JDIMM1.149
DDR_CS1_DIMMA#: CPU1.AE2 JDIMM1.157
DDR_CS2_DIMMB#: CPU1.AF11 JDIMM2.149
DDR_CS3_DIMMB#: CPU1.AE7 JDIMM2.157
DDR_RCOMP0: CPU1.G1 RH148.2
DDR_RCOMP1: CPU1.H1 RH149.2
DDR_RCOMP2: CPU1.J2 RH150.2
DDR_VTT_PG_CTRL: CPU1.BT13 UC1.2
DEBUG_CTL1: RT66.2 UT4.E4
DEBUG_CTL2: RT67.2 UT4.D5
DEMB0: RM75.2 RM79.2 UM8.53
DEMB1: RM62.2 RM86.2 UM8.54
DEPOP#_EC: DA2.3 UE6.2
DET: JEDP.28 RH584.1 RH585.2 UH1.R35
DEVSLP0: JSSD3.38 UH1.AG42
DEVSLP1: JSSD1.38 UH1.AG43
DEVSLP3: JHDD.13 UH1.AB41
DEVSLP4: JSSD2.38 UH1.AB42
DGPU_ENBKL: RG25.1 UG1.AK26 UV22.11
DGPU_ENVDD: RG26.1 UG1.AK25 UV22.5
DGPU_HOLD_RST#: RG2.1 UG2.1 UH1.AL36
DGPU_INV_PWM: RG24.1 UG1.AL26 UV22.2
DGPU_PEX_RST#: RG152.2 UX1.2 UX2.2
DGPU_PRSNT#: RH135.2 UH1.BC19
DGPU_PWR_EN: DG1.1 PR801.2 PR1303.2 PR6017.2 PR8212.2 QG505.2 QG507.2 RG50.2 RH537.1 UE5.1 UH1.AJ39
DGPU_PWR_EN#: QG3.1 RG47.2 RG49.1 RG51.2
DGPU_PWR_ENP: PC8211.1 PR8212.1 PU8200.3
DGPU_PWROK: PR6018.1 PR6056.1 RH516.2 UE6.19 UH1.AJ44
DH_1.2V: PQ200.4 PU201.17
DH_CHG: PQ704.4 PU700.26
DIMM_CHA_SA0: JDIMM1.256 RD1.2 RD28.1
DIMM_CHA_SA1: JDIMM1.260 RD2.2 RD29.1
DIMM_CHA_SA2: JDIMM1.166 RD3.2 RD30.1
DIMM_CHB_SA0: JDIMM2.256 RD4.2 RD38.1
DIMM_CHB_SA1: JDIMM2.260 RD5.2 RD39.1
DIMM_CHB_SA2: JDIMM2.166 RD6.2 RD40.1
DISP_CEC: JDP.6 RV18.2
DISP_CLK_AUXP_CONN: JDP.16 RV15.2 UV3.4
DISP_DAT_AUXN_CONN: JDP.18 RV16.2 UV3.7
DISPOFF#: DV1.1 JEDP.35 RV1.1
DL_1.2V: PQ201.4 PU201.15
DL_CHG: PQ706.4 PU700.23
DMI_CRX_PTX_N0: CPU1.E8 UH1.C27
DMI_CRX_PTX_N1: CPU1.F6 UH1.B28
DMI_CRX_PTX_N2: CPU1.E5 UH1.B29
DMI_CRX_PTX_N3: CPU1.J9 UH1.B30
DMI_CRX_PTX_P0: CPU1.D8 UH1.B27
DMI_CRX_PTX_P1: CPU1.E6 UH1.A28
DMI_CRX_PTX_P2: CPU1.D5 UH1.C29
DMI_CRX_PTX_P3: CPU1.J8 UH1.A30
DMI_CTX_PRX_N0: CPU1.A8 UH1.L27
DMI_CTX_PRX_N1: CPU1.B6 UH1.E24
DMI_CTX_PRX_N2: CPU1.A5 UH1.G27
DMI_CTX_PRX_N3: CPU1.B4 UH1.L29
DMI_CTX_PRX_P0: CPU1.B8 UH1.N27
DMI_CTX_PRX_P1: CPU1.C6 UH1.G24
DMI_CTX_PRX_P2: CPU1.B5 UH1.E26
DMI_CTX_PRX_P3: CPU1.D4 UH1.K29
DMIC_CLK1_R: LA6.2 UA1.53
DMIC_DATA1_R: RA19.2 UA1.54
DP_AUXN_C: CV25.1 UV3.5
DP_AUXP_C: CV24.1 UV3.2
DP_CBL_DET: JDP.4 RV17.1 UV3.1
DP_HPD_GPU: RX5.2 UG1.AU29 UX1.4
DP_HPD_PCH: QX2.3 RX4.1 UH1.AT44 UX1.1
DPSNK_RBIAS: RT19.1 UT1.Y18
DPSRC_RBIAS: RT5.1 UT1.N6
DRAIN: TV9.1(TP-1) UG1.AM20
DRAM_RST#_AB: RG63.2 RG65.1 UG13.J2 UG14.J2 UG15.J2 UG16.J2
DRAM_RST#_CD: RG80.2 RG81.1 UG17.J2 UG18.J2 UG19.J2 UG20.J2
DRAM_RST#_RA: RG620.1 UG1.W30
DRAM_RST#_RB: RG66.2 RG68.2 RG620.2 UG1.M14
DRAM_RST#_RC: RG621.1 UG1.P12
DRAM_RST#_RD: RG82.2 RG85.2 RG621.2 UG1.AK19
DRVON: DG1.2 PU6102.2 PU6201.2 PU6202.2 PU6301.2 PU6400.2 PU8201.32
EAPD#: DA3.2 RA21.2 RA22.1 UA1.52
EC_AC_BAT#: RG40.2 UE6.9 UG4.2
EC_ESB_CLK: RE642.2 UE5.17 UE6.1 UE10.1
EC_ESB_DAT: RE643.2 UE5.18 UE6.4 UE10.4
EC_MUTE#: DA3.3 UE10.11
EC_ON: PD100.2 UE5.112
EC_RSMRST#: DE2.2 RH88.2 UE5.100 UH1.BA11
EC_RTCRST: QE5.2 RE650.1 UE5.34
EC_RX: JEC.7 JWLAN.32 UE5.31
EC_SCI#: RH521.2 UE5.20 UH1.AV29
EC_SMB_CK1: PD2.2 PR19.2 PR721.1 RE90.4 UE5.77
EC_SMB_CK2: QG1.3 QH5.1 RE90.2 RT60.1 U2407.10 UE5.79 UM8.50
EC_SMB_DA1: PD2.3 PR21.2 PR720.1 RE90.3 UE5.78
EC_SMB_DA2: QG1.6 QH5.4 RE90.1 RT59.1 U2407.9 UE5.80 UM8.49
EC_TX: JEC.6 JWLAN.30 RM31.1 UE5.30
ECAGND: CE33.2 CE35.1 LE2.2 PH1.2 UE5.69
EDP_AUX#_C: CV13.1 JEDP.14
EDP_AUX_C: CV12.1 JEDP.13
EDP_HPD: JEDP.16 RG28.1 RH657.1 UV21.44
EDP_HPD_CPU: RH656.1 UV21.13
EDP_HPD_GPU: RG29.1 UV21.3
EDP_MUX_PD: QV95.2 RV658.1 UH1.AU43
EDP_RCOMP: CPU1.D37 RC30.1
EDP_SW: RV659.1 UE5.98 UH1.AV44 UV21.54 UV22.1
EDP_TX0#_C: CV2.1 JEDP.2
EDP_TX0_C: CV1.1 JEDP.1
EDP_TX1#_C: CV4.1 JEDP.5
EDP_TX1_C: CV3.1 JEDP.4
EDP_TX2#_C: CV6.1 JEDP.8
EDP_TX2_C: CV8.1 JEDP.7
EDP_TX3#_C: CV11.1 JEDP.11
EDP_TX3_C: CV7.1 JEDP.10
ELC_8051_C2CK_RST#: JELC.2 RE7.2 UE1.9
ELC_8051_C2D_P3: JELC.3 UE1.10
ELC_EC#: QE13.5 QE21.5 QE22.5 UE10.6
EN_0.6VSP: PC214.1 PR209.2 PR211.1 PU201.7
EN_1.2V: PC213.1 PR208.1 PU201.8
EN_+1.8VGS: PC811.1 PR807.1 PR808.1 PU802.5
EN_+1VALWP: PC300.1 PR300.2 PU300.3
EN_+VGA_PCIE: PC801.1 PR801.1 PR802.1 PU800.11
EN_INVPWR: QV2.2 UE5.68
EN_TPLED: C2509.1 Q2409.3 Q2410.1 R179.1 R180.1
EN_WOL#: CL42.1 RE79.2 UE10.14 UL2.4
ENBKL: UE5.76 UV22.9
ENVDD: RV600.2 UV17.4 UV22.7
EQA0: RM81.2 RM84.2 UM8.20
EQA1: RM70.2 RM76.2 UM8.19
EQB0: RM82.2 RM85.2 UM8.46
EQB1: RM23.2 RM26.2 UM8.47
FB_3V: PR101.2 PR103.2 PU100.4
FB_5V: PR102.1 PR104.1 PU100.2
FB_+1.8VGS: PC819.2 PR810.1 PR811.1 PU802.6
FB_+1VALWP: PR307.1 PR308.1 PU300.4
FB_+VGA_PCIE: PC809.2 PR804.2 PR805.1 PU800.14
FB_VDDQ_SENSE: PR8209.1 PU8200.12
FBA_ABI#_H: UG1.J36 UG14.J4
FBA_ABI#_L: UG1.P36 UG13.J4
FBA_CAS#_H: UG1.L35 UG14.G3
FBA_CAS#_L: UG1.R32 UG13.L3
FBA_CKE_H: UG1.M34 UG14.J3
FBA_CKE_L: UG1.P34 UG13.J3
FBA_CLK0: RG57.1 UG1.W32 UG13.J12
FBA_CLK0#: RG58.1 UG1.W33 UG13.J11
FBA_CLK1: RG52.1 UG1.M29 UG14.J12
FBA_CLK1#: RG53.1 UG1.L29 UG14.J11
FBA_CS#_H: UG1.M27 UG14.L12
FBA_CS#_L: UG1.Y34 UG13.G12
FBA_D0: UG1.U43 UG13.A11
FBA_D1: UG1.U41 UG13.A13
FBA_D2: UG1.U40 UG13.B11
FBA_D3: UG1.R42 UG13.B13
FBA_D4: UG1.P42 UG13.F13
FBA_D5: UG1.M43 UG13.E13
FBA_D6: UG1.M41 UG13.F11
FBA_D7: UG1.M40 UG13.E11
FBA_D8: UG1.J43 UG13.E2
FBA_D9: UG1.J42 UG13.E4
FBA_D10: UG1.H43 UG13.F4
FBA_D11: UG1.H41 UG13.F2
FBA_D12: UG1.F41 UG13.B2
FBA_D13: UG1.E43 UG13.B4
FBA_D14: UG1.C43 UG13.A4
FBA_D15: UG1.D42 UG13.A2
FBA_D16: UG1.U38 UG13.N13
FBA_D17: UG1.U37 UG13.M13
FBA_D18: UG1.R38 UG13.U13
FBA_D19: UG1.R36 UG13.T13
FBA_D20: UG1.P39 UG13.U11
FBA_D21: UG1.P37 UG13.T11
FBA_D22: UG1.M38 UG13.N11
FBA_D23: UG1.M37 UG13.M11
FBA_D24: UG1.L36 UG13.T2
FBA_D25: UG1.J40 UG13.T4
FBA_D26: UG1.J39 UG13.U4
FBA_D27: UG1.J37 UG13.U2
FBA_D28: UG1.E40 UG13.M2
FBA_D29: UG1.E41 UG13.N2
FBA_D30: UG1.D39 UG13.N4
FBA_D31: UG1.C39 UG13.M4
FBA_D32: UG1.A41 UG14.U4
FBA_D33: UG1.B40 UG14.U2
FBA_D34: UG1.A39 UG14.T4
FBA_D35: UG1.C38 UG14.T2
FBA_D36: UG1.C36 UG14.M2
FBA_D37: UG1.A36 UG14.N2
FBA_D38: UG1.B35 UG14.M4
FBA_D39: UG1.A35 UG14.N4
FBA_D40: UG1.A32 UG14.M11
FBA_D41: UG1.C32 UG14.N11
FBA_D42: UG1.D32 UG14.N13
FBA_D43: UG1.B30 UG14.M13
FBA_D44: UG1.B29 UG14.T13
FBA_D45: UG1.D27 UG14.T11
FBA_D46: UG1.C27 UG14.U13
FBA_D47: UG1.A27 UG14.U11
FBA_D48: UG1.E38 UG14.E4
FBA_D49: UG1.H36 UG14.F4
FBA_D50: UG1.F36 UG14.F2
FBA_D51: UG1.G35 UG14.E2
FBA_D52: UG1.E33 UG14.B2
FBA_D53: UG1.F33 UG14.A2
FBA_D54: UG1.F32 UG14.B4
FBA_D55: UG1.G32 UG14.A4
FBA_D56: UG1.G30 UG14.F11
FBA_D57: UG1.J29 UG14.E11
FBA_D58: UG1.E29 UG14.B11
FBA_D59: UG1.F29 UG14.A11
FBA_D60: UG1.F27 UG14.A13
FBA_D61: UG1.D26 UG14.E13
FBA_D62: UG1.E26 UG14.B13
FBA_D63: UG1.G26 UG14.F13
FBA_DBI0#: UG1.P43 UG13.D13
FBA_DBI1#: UG1.H40 UG13.D2
FBA_DBI2#: UG1.P40 UG13.P13
FBA_DBI3#: UG1.F39 UG13.P2
FBA_DBI4#: UG1.D36 UG14.P2
FBA_DBI5#: UG1.A30 UG14.P13
FBA_DBI6#: UG1.E35 UG14.D2
FBA_DBI7#: UG1.H29 UG14.D13
FBA_EDC0: UG1.R41 UG13.C13
FBA_EDC1: UG1.F42 UG13.C2
FBA_EDC2: UG1.R39 UG13.R13
FBA_EDC3: UG1.H38 UG13.R2
FBA_EDC4: UG1.B38 UG14.R2
FBA_EDC5: UG1.C29 UG14.R13
FBA_EDC6: UG1.D35 UG14.C2
FBA_EDC7: UG1.G27 UG14.C13
FBA_MA0_H: UG1.H33 UG14.K4
FBA_MA0_L: UG1.U32 UG13.H4
FBA_MA1_H: UG1.M32 UG14.K5
FBA_MA1_L: UG1.U34 UG13.H5
FBA_MA2_H: UG1.J32 UG14.K11
FBA_MA2_L: UG1.V31 UG13.H11
FBA_MA3_H: UG1.K32 UG14.K10
FBA_MA3_L: UG1.U35 UG13.H10
FBA_MA4_H: UG1.K30 UG14.H11
FBA_MA4_L: UG1.V36 UG13.K11
FBA_MA5_H: UG1.L30 UG14.H10
FBA_MA5_L: UG1.V33 UG13.K10
FBA_MA6_H: UG1.H35 UG14.H5
FBA_MA6_L: UG1.R33 UG13.K5
FBA_MA7_H: UG1.L33 UG14.H4
FBA_MA7_L: UG1.R35 UG13.K4
FBA_MA8_H: UG1.J33 UG14.J5
FBA_MA8_L: UG1.U31 UG13.J5
FBA_RAS#_H: UG1.M35 UG14.L3
FBA_RAS#_L: UG1.P33 UG13.G3
FBA_WCK0: UG1.L42 UG13.D4
FBA_WCK0_N: UG1.L41 UG13.D5
FBA_WCK1: UG1.L39 UG13.P4
FBA_WCK1_N: UG1.L38 UG13.P5
FBA_WCK2: UG1.B33 UG14.P4
FBA_WCK2_N: UG1.C33 UG14.P5
FBA_WCK3: UG1.D30 UG14.D4
FBA_WCK3_N: UG1.E30 UG14.D5
FBA_WE#_H: UG1.H30 UG14.G12
FBA_WE#_L: UG1.V34 UG13.L12
FBB_ABI#_H: UG1.L19 UG16.J4
FBB_ABI#_L: UG1.L21 UG15.J4
FBB_CAS#_H: UG1.M19 UG16.G3
FBB_CAS#_L: UG1.K21 UG15.L3
FBB_CKE_H: UG1.N20 UG16.J3
FBB_CKE_L: UG1.N21 UG15.J3
FBB_CLK0: RG54.1 UG1.P26 UG15.J12
FBB_CLK0#: RG59.1 UG1.N26 UG15.J11
FBB_CLK1: RG55.1 UG1.H14 UG16.J12
FBB_CLK1#: RG56.1 UG1.G14 UG16.J11
FBB_CS#_H: UG1.K12 UG16.L12
FBB_CS#_L: UG1.L26 UG15.G12
FBB_D0: UG1.K26 UG15.M13
FBB_D1: UG1.E25 UG15.N13
FBB_D2: UG1.F25 UG15.T13
FBB_D3: UG1.H25 UG15.U13
FBB_D4: UG1.J24 UG15.U11
FBB_D5: UG1.D23 UG15.T11
FBB_D6: UG1.E23 UG15.N11
FBB_D7: UG1.G23 UG15.M11
FBB_D8: UG1.E21 UG15.U4
FBB_D9: UG1.J20 UG15.T4
FBB_D10: UG1.G20 UG15.T2
FBB_D11: UG1.F20 UG15.U2
FBB_D12: UG1.E19 UG15.N2
FBB_D13: UG1.F19 UG15.M2
FBB_D14: UG1.E18 UG15.N4
FBB_D15: UG1.D18 UG15.M4
FBB_D16: UG1.C20 UG15.E4
FBB_D17: UG1.A20 UG15.E2
FBB_D18: UG1.D20 UG15.F4
FBB_D19: UG1.B19 UG15.F2
FBB_D20: UG1.B18 UG15.B2
FBB_D21: UG1.A17 UG15.A2
FBB_D22: UG1.C17 UG15.B4
FBB_D23: UG1.D17 UG15.A4
FBB_D24: UG1.A26 UG15.A13
FBB_D25: UG1.B26 UG15.A11
FBB_D26: UG1.C25 UG15.B11
FBB_D27: UG1.B25 UG15.B13
FBB_D28: UG1.A24 UG15.E13
FBB_D29: UG1.A23 UG15.F11
FBB_D30: UG1.B23 UG15.F13
FBB_D31: UG1.D21 UG15.E11
FBB_D32: UG1.G18 UG16.E4
FBB_D33: UG1.H18 UG16.F4
FBB_D34: UG1.F17 UG16.F2
FBB_D35: UG1.G17 UG16.E2
FBB_D36: UG1.F15 UG16.A2
FBB_D37: UG1.H15 UG16.B2
FBB_D38: UG1.D14 UG16.B4
FBB_D39: UG1.E14 UG16.A4
FBB_D40: UG1.J12 UG16.F11
FBB_D41: UG1.E11 UG16.B11
FBB_D42: UG1.F11 UG16.E11
FBB_D43: UG1.H11 UG16.A11
FBB_D44: UG1.E9 UG16.A13
FBB_D45: UG1.G9 UG16.B13
FBB_D46: UG1.H9 UG16.F13
FBB_D47: UG1.F8 UG16.E13
FBB_D48: UG1.B15 UG16.U4
FBB_D49: UG1.C15 UG16.U2
FBB_D50: UG1.A14 UG16.T4
FBB_D51: UG1.B14 UG16.T2
FBB_D52: UG1.D12 UG16.M2
FBB_D53: UG1.B11 UG16.N2
FBB_D54: UG1.C11 UG16.M4
FBB_D55: UG1.A9 UG16.N4
FBB_D56: UG1.C8 UG16.N13
FBB_D57: UG1.D8 UG16.N11
FBB_D58: UG1.C6 UG16.M13
FBB_D59: UG1.B6 UG16.M11
FBB_D60: UG1.D5 UG16.T13
FBB_D61: UG1.C4 UG16.U11
FBB_D62: UG1.B4 UG16.T11
FBB_D63: UG1.A3 UG16.U13
FBB_DBI0#: UG1.G24 UG15.P13
FBB_DBI1#: UG1.H19 UG15.P2
FBB_DBI2#: UG1.C19 UG15.D2
FBB_DBI3#: UG1.C24 UG15.D13
FBB_DBI4#: UG1.J17 UG16.D2
FBB_DBI5#: UG1.J11 UG16.D13
FBB_DBI6#: UG1.C12 UG16.P2
FBB_DBI7#: UG1.A5 UG16.P13
FBB_EDC0: UG1.F24 UG15.R13
FBB_EDC1: UG1.J19 UG15.R2
FBB_EDC2: UG1.A18 UG15.C2
FBB_EDC3: UG1.D24 UG15.C13
FBB_EDC4: UG1.E15 UG16.C2
FBB_EDC5: UG1.D9 UG16.C13
FBB_EDC6: UG1.A12 UG16.R2
FBB_EDC7: UG1.B5 UG16.R13
FBB_MA0_H: UG1.N18 UG16.K4
FBB_MA0_L: UG1.H23 UG15.H4
FBB_MA1_H: UG1.K17 UG16.K5
FBB_MA1_L: UG1.N24 UG15.H5
FBB_MA2_H: UG1.N17 UG16.K11
FBB_MA2_L: UG1.K24 UG15.H11
FBB_MA3_H: UG1.M17 UG16.K10
FBB_MA3_L: UG1.M24 UG15.H10
FBB_MA4_H: UG1.L15 UG16.H11
FBB_MA4_L: UG1.L25 UG15.K11
FBB_MA5_H: UG1.J15 UG16.H10
FBB_MA5_L: UG1.M25 UG15.K10
FBB_MA6_H: UG1.P19 UG16.H5
FBB_MA6_L: UG1.N23 UG15.K5
FBB_MA7_H: UG1.K18 UG16.H4
FBB_MA7_L: UG1.L23 UG15.K4
FBB_MA8_H: UG1.L18 UG16.J5
FBB_MA8_L: UG1.K23 UG15.J5
FBB_RAS#_H: UG1.M20 UG16.L3
FBB_RAS#_L: UG1.K20 UG15.G3
FBB_WCK0: UG1.G21 UG15.P4
FBB_WCK0_N: UG1.H21 UG15.P5
FBB_WCK1: UG1.A21 UG15.D4
FBB_WCK1_N: UG1.B21 UG15.D5
FBB_WCK2: UG1.F12 UG16.D4
FBB_WCK2_N: UG1.G12 UG16.D5
FBB_WCK3: UG1.A8 UG16.P4
FBB_WCK3_N: UG1.B9 UG16.P5
FBB_WE#_H: UG1.M15 UG16.G12
FBB_WE#_L: UG1.J25 UG15.L12
FBC_ABI#_H: UG1.AA11 UG18.J4
FBC_ABI#_L: UG1.W11 UG17.J4
FBC_CAS#_H: UG1.AA10 UG18.G3
FBC_CAS#_L: UG1.W12 UG17.L3
FBC_CKE_H: UG1.AA13 UG18.J3
FBC_CKE_L: UG1.Y13 UG17.J3
FBC_CLK0: RG70.1 UG1.P8 UG17.J12
FBC_CLK0#: RG71.1 UG1.P7 UG17.J11
FBC_CLK1: RG72.1 UG1.AF14 UG18.J12
FBC_CLK1#: RG73.1 UG1.AF13 UG18.J11
FBC_CS#_H: UG1.AF11 UG18.L12
FBC_CS#_L: UG1.M10 UG17.G12
FBC_D0: UG1.C1 UG17.A13
FBC_D1: UG1.D2 UG17.B11
FBC_D2: UG1.D3 UG17.A11
FBC_D3: UG1.E4 UG17.B13
FBC_D4: UG1.F2 UG17.F11
FBC_D5: UG1.F3 UG17.F13
FBC_D6: UG1.H4 UG17.E11
FBC_D7: UG1.H3 UG17.E13
FBC_D8: UG1.J1 UG17.E4
FBC_D9: UG1.L3 UG17.F4
FBC_D10: UG1.L2 UG17.E2
FBC_D11: UG1.M4 UG17.F2
FBC_D12: UG1.P2 UG17.B2
FBC_D13: UG1.P1 UG17.B4
FBC_D14: UG1.R3 UG17.A2
FBC_D15: UG1.R2 UG17.A4
FBC_D16: UG1.H6 UG17.N13
FBC_D17: UG1.J8 UG17.M13
FBC_D18: UG1.J7 UG17.T13
FBC_D19: UG1.J5 UG17.U13
FBC_D20: UG1.L8 UG17.U11
FBC_D21: UG1.L6 UG17.N11
FBC_D22: UG1.L5 UG17.T11
FBC_D23: UG1.M9 UG17.M11
FBC_D24: UG1.P5 UG17.U2
FBC_D25: UG1.P4 UG17.U4
FBC_D26: UG1.R8 UG17.T4
FBC_D27: UG1.R6 UG17.T2
FBC_D28: UG1.U7 UG17.N2
FBC_D29: UG1.U6 UG17.M2
FBC_D30: UG1.V8 UG17.N4
FBC_D31: UG1.V7 UG17.M4
FBC_D32: UG1.AA4 UG18.N11
FBC_D33: UG1.AC2 UG18.M13
FBC_D34: UG1.AC1 UG18.M11
FBC_D35: UG1.AD1 UG18.N13
FBC_D36: UG1.AE3 UG18.T11
FBC_D37: UG1.AE2 UG18.T13
FBC_D38: UG1.AF2 UG18.U11
FBC_D39: UG1.AF1 UG18.U13
FBC_D40: UG1.U4 UG18.U4
FBC_D41: UG1.U3 UG18.U2
FBC_D42: UG1.U1 UG18.T4
FBC_D43: UG1.V2 UG18.T2
FBC_D44: UG1.W2 UG18.M2
FBC_D45: UG1.Y4 UG18.M4
FBC_D46: UG1.Y1 UG18.N2
FBC_D47: UG1.Y3 UG18.N4
FBC_D48: UG1.V4 UG18.F4
FBC_D49: UG1.V5 UG18.E4
FBC_D50: UG1.W6 UG18.F2
FBC_D51: UG1.W5 UG18.E2
FBC_D52: UG1.Y6 UG18.A2
FBC_D53: UG1.Y7 UG18.B2
FBC_D54: UG1.Y9 UG18.B4
FBC_D55: UG1.AA5 UG18.A4
FBC_D56: UG1.AC7 UG18.F11
FBC_D57: UG1.AC5 UG18.E11
FBC_D58: UG1.AC4 UG18.B11
FBC_D59: UG1.AD9 UG18.A11
FBC_D60: UG1.AE8 UG18.A13
FBC_D61: UG1.AE6 UG18.B13
FBC_D62: UG1.AE5 UG18.E13
FBC_D63: UG1.AF10 UG18.F13
FBC_DBI0#: UG1.E1 UG17.D13
FBC_DBI1#: UG1.M3 UG17.D2
FBC_DBI2#: UG1.L9 UG17.P13
FBC_DBI3#: UG1.U9 UG17.P2
FBC_DBI4#: UG1.AD3 UG18.P13
FBC_DBI5#: UG1.W3 UG18.P2
FBC_DBI6#: UG1.W8 UG18.D2
FBC_DBI7#: UG1.AD7 UG18.D13
FBC_EDC0: UG1.E2 UG17.C13
FBC_EDC1: UG1.M1 UG17.C2
FBC_EDC2: UG1.J4 UG17.R13
FBC_EDC3: UG1.R5 UG17.R2
FBC_EDC4: UG1.AD4 UG18.R13
FBC_EDC5: UG1.V1 UG18.R2
FBC_EDC6: UG1.W9 UG18.C2
FBC_EDC7: UG1.AD6 UG18.C13
FBC_MA0_H: UG1.AC8 UG18.K4
FBC_MA0_L: UG1.V13 UG17.H4
FBC_MA1_H: UG1.AD13 UG18.K5
FBC_MA1_L: UG1.U10 UG17.H5
FBC_MA2_H: UG1.AD10 UG18.K11
FBC_MA2_L: UG1.U13 UG17.H11
FBC_MA3_H: UG1.AD12 UG18.K10
FBC_MA3_L: UG1.U12 UG17.H10
FBC_MA4_H: UG1.AE11 UG18.H11
FBC_MA4_L: UG1.R11 UG17.K11
FBC_MA5_H: UG1.AE12 UG18.H10
FBC_MA5_L: UG1.R9 UG17.K10
FBC_MA6_H: UG1.AC13 UG18.H5
FBC_MA6_L: UG1.W14 UG17.K5
FBC_MA7_H: UG1.AC11 UG18.H4
FBC_MA7_L: UG1.V10 UG17.K4
FBC_MA8_H: UG1.AC10 UG18.J5
FBC_MA8_L: UG1.V11 UG17.J5
FBC_RAS#_H: UG1.Y10 UG18.L3
FBC_RAS#_L: UG1.Y12 UG17.G3
FBC_WCK0: UG1.H1 UG17.D4
FBC_WCK0_N: UG1.J2 UG17.D5
FBC_WCK1: UG1.M6 UG17.P4
FBC_WCK1_N: UG1.M7 UG17.P5
FBC_WCK2: UG1.AA1 UG18.P4
FBC_WCK2_N: UG1.AA2 UG18.P5
FBC_WCK3: UG1.AA7 UG18.D4
FBC_WCK3_N: UG1.AA8 UG18.D5
FBC_WE#_H: UG1.AE9 UG18.G12
FBC_WE#_L: UG1.R12 UG17.L12
FBD_ABI#_H: UG1.AT14 UG20.J4
FBD_ABI#_L: UG1.AT9 UG19.J4
FBD_CAS#_H: UG1.AM15 UG20.G3
FBD_CAS#_L: UG1.AR11 UG19.L3
FBD_CKE_H: UG1.AP14 UG20.J3
FBD_CKE_L: UG1.AP12 UG19.J3
FBD_CLK0: RG74.1 UG1.AJ12 UG19.J12
FBD_CLK0#: RG75.1 UG1.AJ11 UG19.J11
FBD_CLK1: RG76.1 UG1.AM19 UG20.J12
FBD_CLK1#: RG77.1 UG1.AN19 UG20.J11
FBD_CS#_H: UG1.AP20 UG20.L12
FBD_CS#_L: UG1.AG12 UG19.G12
FBD_D0: UG1.AF7 UG19.M13
FBD_D1: UG1.AF5 UG19.T13
FBD_D2: UG1.AF4 UG19.N13
FBD_D3: UG1.AG6 UG19.U13
FBD_D4: UG1.AJ6 UG19.U11
FBD_D5: UG1.AJ5 UG19.T11
FBD_D6: UG1.AJ9 UG19.N11
FBD_D7: UG1.AK7 UG19.M11
FBD_D8: UG1.AM7 UG19.U4
FBD_D9: UG1.AM6 UG19.T4
FBD_D10: UG1.AN6 UG19.U2
FBD_D11: UG1.AN5 UG19.T2
FBD_D12: UG1.AR7 UG19.N2
FBD_D13: UG1.AT6 UG19.M2
FBD_D14: UG1.AT8 UG19.M4
FBD_D15: UG1.AV5 UG19.N4
FBD_D16: UG1.AG1 UG19.A11
FBD_D17: UG1.AG3 UG19.A13
FBD_D18: UG1.AG4 UG19.B11
FBD_D19: UG1.AJ2 UG19.B13
FBD_D20: UG1.AK2 UG19.F13
FBD_D21: UG1.AM4 UG19.E13
FBD_D22: UG1.AM3 UG19.E11
FBD_D23: UG1.AM1 UG19.F11
FBD_D24: UG1.AR1 UG19.E4
FBD_D25: UG1.AR2 UG19.F4
FBD_D26: UG1.AT1 UG19.E2
FBD_D27: UG1.AT3 UG19.F2
FBD_D28: UG1.AV3 UG19.B2
FBD_D29: UG1.AW1 UG19.B4
FBD_D30: UG1.AY2 UG19.A2
FBD_D31: UG1.BA1 UG19.A4
FBD_D32: UG1.AW3 UG20.F4
FBD_D33: UG1.AW4 UG20.E4
FBD_D34: UG1.BA5 UG20.E2
FBD_D35: UG1.AY5 UG20.F2
FBD_D36: UG1.AU9 UG20.A2
FBD_D37: UG1.AW9 UG20.A4
FBD_D38: UG1.AY9 UG20.B4
FBD_D39: UG1.AT11 UG20.B2
FBD_D40: UG1.AU12 UG20.F11
FBD_D41: UG1.AV12 UG20.E11
FBD_D42: UG1.AU14 UG20.B11
FBD_D43: UG1.AW14 UG20.A11
FBD_D44: UG1.AT15 UG20.B13
FBD_D45: UG1.AV15 UG20.A13
FBD_D46: UG1.AU17 UG20.F13
FBD_D47: UG1.AV17 UG20.E13
FBD_D48: UG1.BB4 UG20.U2
FBD_D49: UG1.BC3 UG20.U4
FBD_D50: UG1.BC5 UG20.T4
FBD_D51: UG1.BA6 UG20.T2
FBD_D52: UG1.BA8 UG20.M2
FBD_D53: UG1.BC8 UG20.M4
FBD_D54: UG1.BB9 UG20.N4
FBD_D55: UG1.BC9 UG20.N2
FBD_D56: UG1.AY12 UG20.N11
FBD_D57: UG1.BA12 UG20.M11
FBD_D58: UG1.BC12 UG20.N13
FBD_D59: UG1.BB14 UG20.M13
FBD_D60: UG1.BB15 UG20.T13
FBD_D61: UG1.AY17 UG20.T11
FBD_D62: UG1.BA17 UG20.U13
FBD_D63: UG1.BC17 UG20.U11
FBD_DBI0#: UG1.AJ8 UG19.P13
FBD_DBI1#: UG1.AR5 UG19.P2
FBD_DBI2#: UG1.AK1 UG19.D13
FBD_DBI3#: UG1.AT4 UG19.D2
FBD_DBI4#: UG1.AW6 UG20.D2
FBD_DBI5#: UG1.AY14 UG20.D13
FBD_DBI6#: UG1.AY8 UG20.P2
FBD_DBI7#: UG1.BC14 UG20.P13
FBD_EDC0: UG1.AG7 UG19.R13
FBD_EDC1: UG1.AR4 UG19.R2
FBD_EDC2: UG1.AJ3 UG19.C13
FBD_EDC3: UG1.AV2 UG19.C2
FBD_EDC4: UG1.AV8 UG20.C2
FBD_EDC5: UG1.AW15 UG20.C13
FBD_EDC6: UG1.BB6 UG20.R2
FBD_EDC7: UG1.BA15 UG20.R13
FBD_MA0_H: UG1.AM17 UG20.K4
FBD_MA0_L: UG1.AN8 UG19.H4
FBD_MA1_H: UG1.AP17 UG20.K5
FBD_MA1_L: UG1.AM12 UG19.H5
FBD_MA2_H: UG1.AL18 UG20.K11
FBD_MA2_L: UG1.AM9 UG19.H11
FBD_MA3_H: UG1.AR17 UG20.K10
FBD_MA3_L: UG1.AM10 UG19.H10
FBD_MA4_H: UG1.AT18 UG20.H11
FBD_MA4_L: UG1.AK10 UG19.K11
FBD_MA5_H: UG1.AN18 UG20.H10
FBD_MA5_L: UG1.AK11 UG19.K10
FBD_MA6_H: UG1.AN15 UG20.H5
FBD_MA6_L: UG1.AR8 UG19.K5
FBD_MA7_H: UG1.AR15 UG20.H4
FBD_MA7_L: UG1.AN11 UG19.K4
FBD_MA8_H: UG1.AL17 UG20.J5
FBD_MA8_L: UG1.AN9 UG19.J5
FBD_RAS#_H: UG1.AN14 UG20.L3
FBD_RAS#_L: UG1.AR12 UG19.G3
FBD_WCK0: UG1.AK4 UG19.P4
FBD_WCK0_N: UG1.AK5 UG19.P5
FBD_WCK1: UG1.AN2 UG19.D4
FBD_WCK1_N: UG1.AN3 UG19.D5
FBD_WCK2: UG1.AW11 UG20.D4
FBD_WCK2_N: UG1.AV11 UG20.D5
FBD_WCK3: UG1.BB11 UG20.P4
FBD_WCK3_N: UG1.BA11 UG20.P5
FBD_WE#_H: UG1.AP18 UG20.G12
FBD_WE#_L: UG1.AK8 UG19.L12
FBVDD/Q_EN: UE10.16
FCCM_GT: PR585.2 PR594.2 PU500.11
FCCM_SA: PR5006.2 PU500.34
FCCM_VCORE: PR556.2 PR566.2 PR576.2 PU500.24
FFS_INT1: RP5.8 UH1.AN38 US1.11
FFS_INT2: QS3.3 RP5.7 UH1.AN41 US1.9
FFS_INT2_CONN: DS1.2 JHDD.20 RS1.2
G-SYNC#: JEDP.21 RV10.1
GATE: TV8.1(TP-1) UG1.AM21
GC6_EVENT#: UH1.AR24
GC6_FB_EN: UE10.9 UH1.AW27
GPIO15_VDDCI_VID: TV15.1(TP-1) UG1.AJ31
GPIO19_CTF: RG38.1 UG1.AC31
GPIO30_PCC: RV534.2 RV536.2 UG1.AG30 UV23.1
GPIO_0: RG147.1 UG1.V39
GPIO_1: DA2.2 UA1.2
GPIO_1_28749953: RG156.1 UG1.V38
GPIO_2: RG148.1 UG1.W37
GPIO_8_ROMSO: RG27.2 RG157.1 UG1.AN30 UH5.2
GPIO_9_ROMSI: UG1.AP32 UH5.5
GPIO_10_ROMSCK: UG1.AM30 UH5.6
GPIO_11: RG153.1 UG1.V43
GPIO_12: RG154.1 UG1.V42
GPIO_13: RG155.1 UG1.V41
GPIO_20: RG146.1 UG1.AK33
GPIO_22_ROMCSB: RG144.1 RG499.2 UG1.AN32 UH5.1
GPIO_29: RG145.1 UG1.AG31
GPU_ALERT#: RE644.1 UE10.10
GPU_AUXN/DDC: CV425.2 RG402.1 RV670.1 UG1.AV27
GPU_AUXN/DDC_C: CV425.1 UV21.27
GPU_AUXP/DDC: CV424.2 RG403.1 RV669.1 UG1.AU27
GPU_AUXP/DDC_C: CV424.1 UV21.28
GPU_B+: PC6107.1 PC6108.1 PC6109.1 PC6110.1 PC6111.1 PC6112.1 PC6113.1 PC6114.1 PC6129.1 PC6131.1 PC6207.1 PC6208.1 PC6209.1 PC6210.1 PC6211.1 PC6212.1 PC6213.1 PC6214.1 PC6219.1 PC6220.1 PC6221.1 PC6222.1 PC6223.1 PC6224.1 PC6225.1 PC6226.1 PC6307.1 PC6308.1 PC6309.1 PC6310.1 PC6311.1 PC6312.1 PC6313.1 PC6314.1 PC6402.1 PC6403.1 PC6404.1 PC6405.1 PC6406.1 PC6407.1 PC6408.1 PC6409.1 PL6102.2 PR6003.1 PU6102.20 PU6102.21 PU6102.22 PU6102.23 PU6102.24 PU6102.25 PU6201.20 PU6201.21 PU6201.22 PU6201.23 PU6201.24 PU6201.25 PU6202.20 PU6202.21 PU6202.22 PU6202.23 PU6202.24 PU6202.25 PU6301.20 PU6301.21 PU6301.22 PU6301.23 PU6301.24 PU6301.25 PU6400.20 PU6400.21 PU6400.22 PU6400.23 PU6400.24 PU6400.25
GPU_DMINUS: C2503.2 UG1.AC34 UG3.3
GPU_DPC_AUX: CV24.2 RV619.1
GPU_DPC_AUX#: CV25.2 RV618.1
GPU_DPLUS: C2503.1 UG1.AC35 UG3.2
GPU_FAN_FB: DF2.2 RF4.1 UE5.29
GPU_FAN_PWM: JFAN2.2 RF5.1 UE5.27
GPU_GC6_FB_EN_R: UH1.BD32
GPU_MDP_N0: CV27.1 UG1.AY35
GPU_MDP_N1: CV30.1 UG1.BB35
GPU_MDP_N2: CV33.1 UG1.BC33
GPU_MDP_N3: CV31.1 UG1.AY32
GPU_MDP_P0: CV26.1 UG1.AY36
GPU_MDP_P1: CV28.1 UG1.BC35
GPU_MDP_P2: CV32.1 UG1.BB33
GPU_MDP_P3: CV29.1 UG1.AY33
GPU_OVERT#: RE102.1 UE6.21
GPU_TX0N: CV417.2 UG1.BA24
GPU_TX0N_C: CV417.1 UV21.2
GPU_TX0P: CV416.2 UG1.BA25
GPU_TX0P_C: CV416.1 UV21.1
GPU_TX1N: CV419.2 UG1.BB24
GPU_TX1N_C: CV419.1 UV21.5
GPU_TX1P: CV418.2 UG1.BC24
GPU_TX1P_C: CV418.1 UV21.4
GPU_TX2N: CV421.2 UG1.BC23
GPU_TX2N_C: CV421.1 UV21.7
GPU_TX2P: CV420.2 UG1.BB23
GPU_TX2P_C: CV420.1 UV21.6
GPU_TX3N: CV423.2 UG1.AY21
GPU_TX3N_C: CV423.1 UV21.10
GPU_TX3P: CV422.2 UG1.AY23
GPU_TX3P_C: CV422.1 UV21.9
GPU_WP#: RG30.1 UH5.3
H_CPUPWRGD: CH194.1 CPU1.BT31 UH1.AM3
H_DRAMRST#: CD69.1 RD31.2 RD35.2 UH1.BC14
H_PECI: CPU1.BT34 RE76.2 RH73.2
H_PM_DOWN: RH155.1 UH1.AH2
H_PM_SYNC_R: CPU1.BM34 UH1.AJ4
H_PROCHOT#: PQ8.1 PR724.1 QE2.1 RE78.2 RH158.1 RH165.2
H_THERMTRIP#: CPU1.J31 RH79.2 RH163.2
H_THERMTRIP#_R: RH79.1 UH1.AJ3
H_VCCST_PWRGD: CH193.1 Q7.3 RH154.1 RH164.2 UE5.123
HDA_SPKR: DA1.3 UH1.BD26
HDMI_CTRLCLK: U1.34 UG1.BC41
HDMI_CTRLDAT: U1.33 UG1.BB40
HDMI_DCIN_EN: RV203.1 U1.3
HDMI_EQ: RV198.2 RV199.1 U1.5
HDMI_HPD: CX2.1 RX6.2 U1.40
HDMI_HPD_GPU: RX7.2 UG1.AT29 UX2.4
HDMI_HPD_PCH: QX3.3 RX8.1 UH1.AU41 UX2.1
HDMI_HPLUG: JHDMI.19 U1.21
HDMI_I2C_ADDR: RV202.2 U1.31
HDMI_ID: RV204.2 U1.32
HDMI_PRE: RV197.1 U1.6
HP2_D_L1_JK: CA50.1 DA6.3 JACK2.1 LA12.1
HP2_D_L_C: CA49.2 RA43.1
HP2_D_L_R: LA12.2 RA41.2 RA43.2 RA44.1 RA46.1
HP2_D_R1_JK: CA48.1 DA6.2 JACK2.2 LA11.1
HP2_D_R_C: CA47.2 RA42.1
HP2_D_R_R: LA11.2 RA40.2 RA42.2 RA45.1 RA47.1
HP_LINE1_JD: CA41.1 RA32.2 RA34.1 RA36.1 UA1.9
HP_MUTE#: DA2.1 RA13.2 UA2.B1 UA3.B1
HPOUT-L: RA35.1 UA1.32
HPOUT-R: RA37.1 UA1.33
HPOUT_JD: JACK1.6 RA34.2
I2C0_SCL_EC: JIO.12 RA56.1 UA1.12 UE5.83
I2C0_SCL_EC_R: RA50.2 RA56.2 UA4.8
I2C0_SDA_EC: JIO.11 RA55.1 UA1.11 UE5.84
I2C0_SDA_EC_R: RA53.2 RA55.2 UA4.7
I2C_CLK: CE58.1 JCDRA.45 PR6079.1 RE2.2 UE1.29 UE3.25 UE4.25 UE8.25
I2C_CTL_EN: RV21.1 RV22.1 UV21.53
I2C_DAT: JCDRA.46 PR6080.1 RE1.2 UE1.30 UE3.26 UE4.26 UE8.26
I2S_DATA_OUT: JIO.18 RA33.2 UA4.14
I2S_DATA_OUT_R: CA40.1 RA33.1 UA1.5
I2S_LRCK: CA37.1 JIO.16 RA30.2 UA4.11
I2S_LRCK_R: RA30.1 UA1.1
I2S_OUT: CA36.1 JIO.17 RA31.2 UA4.12
I2S_OUT_R: RA31.1 UA1.3
I_OUT: PR6081.1 RV533.1
I_SYS: PR526.2 PR728.2 PU700.9
IGPU_ENBKL: UH1.W35 UV22.10
IGPU_ENVDD: UH1.W42 UV22.6
IGPU_INV_PWM: UH1.W36 UV22.3
IMVP_VR_ON: CE38.1 PR523.2 Q7.6 UE5.121
IN1_PEQ#: RV628.1 RV629.1 RV633.2 UV21.52
IN2_PEQ#: RV630.1 RV631.1 RV632.2 UV21.51
INTRUDER#: RH531.1 UH1.BE11
INV_PWM: JEDP.36 RV8.1 UV22.4
ISEN1_GT: PC528.2 PR587.2 PR589.2 PU500.9
ISEN1_VCORE: PC527.1 PR558.2 PR560.2 PR561.2 PU500.21
ISEN2_GT: PC525.2 PR596.2 PR598.2 PU500.10
ISEN2_VCORE: PC526.1 PR568.2 PR570.2 PR571.2 PU500.22
ISEN3_VCORE: PC524.1 PR578.2 PR580.2 PR581.2 PU500.23
ISENSEP_L: RA58.2 RA77.1 UA4.25
ISENSEP_L_R: CA254.1 LA50.2 RA57.1 RA58.1
ISENSEP_R: RA63.2 RA80.1 UA4.28
ISENSEP_R_R: CA256.1 LA52.2 RA60.1 RA63.1
ISUMN_GT: PC516.2 PC517.2 PC523.1 PC525.1 PC528.1 PH502.2 PR535.2 PR538.1 PR540.1 PR588.1 PR597.1
ISUMN_SA: PC510.1 PC511.1 PC512.1 PH501.1 PR524.2 PR528.1 PR529.1 PR5027.1
ISUMN_VCORE: PC524.2 PC526.2 PC527.2 PC529.1 PC530.1 PC531.1 PH503.1 PR541.2 PR542.1 PR543.2 PR559.1 PR569.1 PR579.1
ISUMP_GT: PC516.1 PC517.1 PR534.1 PR535.1 PR572.2 PR586.1 PR595.1 PU500.7
ISUMP_SA: PC510.2 PC512.2 PR529.2 PR530.2 PR582.2 PR5003.2 PU500.32
ISUMP_VCORE: PC530.2 PC531.2 PR542.2 PR544.2 PR557.1 PR562.2 PR567.1 PR577.1 PU500.19
IVSENSE_L: RA59.2 RA78.1 UA4.26
IVSENSE_R: RA64.2 RA81.1 UA4.29
JKSI0: JKB.30 RE471.1
JKSI1: JKB.29 RE474.1
JKSI2: JKB.28 RE466.1
JKSI3: JKB.27 RE467.1
JKSI4: JKB.26 RE461.1
JKSI5: JKB.25 RE460.1
JKSI6: JKB.24 RE455.1
JKSI7: JKB.23 RE454.1
JKSI8: JKB.22 RE396.1
JKSI9: JKB.21 RE399.1
JKSI10: JKB.20 RE476.1
JKSI11: JKB.19 RE480.1
JKSI12: JKB.18 RE482.1
JKSI13: JKB.17 RE486.1
JKSI14: JKB.16 RE488.1
JKSI15: JKB.15 RE492.1
JKSI16: JKB.14 RE495.1
JKSI17: JKB.13 RE498.1
JKSI18: JKB.12 RE502.1
JKSI19: JKB.11 RE503.1
JKSI20: JKB.10 RE507.1
JKSI21: JKB.9 RE510.1
JKSO0: JKB.8 QE49.6 QE54.6
JKSO1: JKB.7 QE50.6 QE54.3
JKSO2: JKB.6 QE51.6 QE55.6
JKSO3: JKB.5 QE52.6 QE55.3
JKSO4: JKB.4 QE53.6 QE56.6
JRTC1: PD5.2 PR2.1
JTAG_TCK: TV5.1(TP-1) UG1.AF30
JTAG_TDI: TV3.1(TP-1) UG1.AD30
JTAG_TDO: TV2.1(TP-1) UG1.AD31
JTAG_TMS: TV4.1(TP-1) UG1.AE31
JTAG_TRSTB: RG8.1 RG397.1 TV7.1(TP-1) UG1.AC30
KB_LED_B1_DRV#: JKBBL.5 UE4.5
KB_LED_B2_DRV#: JKBBL.8 UE4.9
KB_LED_B3_DRV#: JKBBL.11 UE4.14
KB_LED_B4_DRV#: JKBBL.14 UE4.17
KB_LED_B5_DRV#: JKB3.2 UE8.21
KB_LED_G1_DRV#: JKBBL.4 UE4.4
KB_LED_G2_DRV#: JKBBL.7 UE4.8
KB_LED_G3_DRV#: JKBBL.10 UE4.11
KB_LED_G4_DRV#: JKBBL.13 UE4.16
KB_LED_G5_DRV#: JKB3.3 UE8.20
KB_LED_R1_DRV#: JKBBL.3 UE4.3
KB_LED_R2_DRV#: JKBBL.6 UE4.6
KB_LED_R3_DRV#: JKBBL.9 UE4.10
KB_LED_R4_DRV#: JKBBL.12 UE4.15
KB_LED_R5_DRV#: JKB3.4 UE8.19
KB_RST#: RE646.1 RH518.1 UH1.AT17
KSI0: QE42.3 RE469.2 RE630.1 UE5.55
KSI0_R: JKB2.5 JKB2.6 RE630.2
KSI1: QE42.6 RE470.2 RE632.1 UE5.56
KSI1_R: JKB2.9 JKB2.10 RE632.2
KSI2: QE41.3 RE464.2 RE634.1 UE5.57
KSI2_R: JKB2.13 JKB2.14 RE634.2
KSI3: QE41.6 RE463.2 RE635.1 UE5.58
KSI3_R: JKB2.15 JKB2.16 RE635.2
KSI4: JEC.4 QE40.3 RE459.2 RE633.1 UE5.59
KSI4_R: JKB2.11 JKB2.12 RE633.2
KSI5: JEC.5 QE40.6 RE457.2 RE631.1 UE5.60
KSI5_R: JKB2.7 JKB2.8 RE631.2
KSI6: JEC.2 QE39.3 RE452.2 UE5.61
KSI7: JEC.3 QE39.6 RE451.2 UE5.62
KSI8: QE29.3 RE398.2 UE5.47
KSI9: QE29.6 RE400.2 UE5.48
KSI10: QE43.3 RE475.2 UE5.49
KSI11: QE43.6 RE477.2 UE5.50
KSI12: QE44.3 RE481.2 UE5.51
KSI13: QE44.6 RE483.2 UE5.52
KSI14: QE45.3 RE487.2 UE5.53
KSI15: QE45.6 RE489.2 UE5.54
KSI16: QE46.3 RE493.2 UE5.45
KSI17: QE46.6 RE494.2 UE5.46
KSI18: QE47.3 RE500.2 UE5.81
KSI19: QE47.6 RE499.2 UE5.82
KSI20: QE48.3 RE505.2 UE5.85
KSI21: QE48.6 RE506.2 UE5.86
KSO0: RE513.1 UE5.39
KSO1: RE516.1 UE5.40
KSO2: RE520.1 UE5.41
KSO3: JEC.1 RE524.1 UE5.42
KSO4: RE528.1 UE5.43
KSO5: JKB2.3 JKB2.4 UE5.44
LAN_ACTIVITY#: CL27.1 JLAN.10 UL1.38
LAN_LED2#: CL29.1 JLAN.13 RL15.1
LAN_LED2#_R: RL15.2 UL1.23
LAN_LINK#: CL28.1 JLAN.11 RL13.1
LAN_LINK#_R: QL3.2 RL4.2 UL1.39
LAN_MDIN0: TL1.11 UL1.12
LAN_MDIN1: TL1.7 UL1.15
LAN_MDIN2: TL1.5 UL1.18
LAN_MDIN3: TL1.1 UL1.21
LAN_MDIP0: TL1.12 UL1.11
LAN_MDIP1: TL1.8 UL1.14
LAN_MDIP2: TL1.6 UL1.17
LAN_MDIP3: TL1.2 UL1.20
LCD_TEST: JEDP.31 UE5.72
LDO2-CAP: CA28.1 CA29.1 RA12.2 UA1.22
LG_3V: PQ101.4 PU100.11
LG_5V: PQ103.4 PU100.15
LG_+1VALWP: PQ301.4 PU300.6
LID_SW#: CE43.1 DE1.1 JIO.20 RE70.2 UE5.115
LINE1_JD: JACK2.5 RA36.2
LINE1_L: CA49.1 UA1.35
LINE1_R: CA47.1 UA1.34
LINE1_VREFO_L: RA41.1 UA1.40
LINE1_VREFO_R: RA40.1 UA1.39
LINE-IN-L: LA9.2 RA35.2 RA38.1
LINE-IN-R: LA10.2 RA37.2 RA39.1
LOGO_LED_B_DRV#: JLOGO.8 UE3.9
LOGO_LED_G_DRV#: JLOGO.7 UE3.8
LOGO_LED_R_DRV#: JLOGO.6 UE3.6
LPC_AD0: UE5.10 UH1.AT22
LPC_AD1: UE5.8 UH1.AV22
LPC_AD2: UE5.7 UH1.AT19
LPC_AD3: UE5.5 UH1.BD16
LPC_FRAME#: UE5.4 UH1.BE16
LX_3V: PC105.1 PL101.2 PQ100.1 PQ100.2 PQ100.3 PQ101.5 PR110.1 PU100.8
LX_5V: PC106.2 PL102.1 PQ102.1 PQ102.2 PQ102.3 PQ103.5 PR111.1 PU100.18
LX_+1.8VGS: PL801.1 PR809.1 PU802.2 PU802.3
LX_+VGA_PCIE: PC808.2 PL800.1 PR803.1 PU800.6 PU800.19 PU800.20
LX_CHG: PC702.1 PL700.1 PQ704.1 PQ704.2 PQ704.3 PQ706.5 PR713.1 PU700.27
LX_VCCIO: PC593.2 PL509.1 PR5009.1 PU509.6 PU509.19 PU509.20
M_CLK_DDR0: CPU1.AG1 JDIMM1.137
M_CLK_DDR1: CPU1.AK2 JDIMM1.138
M_CLK_DDR2: CPU1.AM9 JDIMM2.137
M_CLK_DDR3: CPU1.AM7 JDIMM2.138
M_CLK_DDR#0: CPU1.AG2 JDIMM1.139
M_CLK_DDR#1: CPU1.AK1 JDIMM1.140
M_CLK_DDR#2: CPU1.AN9 JDIMM2.139
M_CLK_DDR#3: CPU1.AM8 JDIMM2.140
M_ODT0: CPU1.AD3 JDIMM1.155
M_ODT1: CPU1.AE4 JDIMM1.161
M_ODT2: CPU1.AF7 JDIMM2.155
M_ODT3: CPU1.AE8 JDIMM2.161
MDP_AUX#_SDA: RG400.1 RV618.2 UG1.AT33 UV3.6
MDP_AUX_SCL: RG401.1 RV619.2 UG1.AU33 UV3.3
MDP_HPD: CX1.1 JDP.2 RX2.2
MDP_LANE_N0_C: CV27.2 JDP.5
MDP_LANE_N1_C: CV30.2 JDP.11
MDP_LANE_N2_C: CV33.2 JDP.17
MDP_LANE_N3_C: CV31.2 JDP.12
MDP_LANE_P0_C: CV26.2 JDP.3
MDP_LANE_P1_C: CV28.2 JDP.9
MDP_LANE_P2_C: CV32.2 JDP.15
MDP_LANE_P3_C: CV29.2 JDP.10
ME_EN: RH16.1 UE5.99
ME_SUS_PWR_ACK: RH506.1 UE5.71 UH1.BD19
MEM_VDD_CTL: PR8213.1 PR8215.2 PR8216.1
MIC1-VREFO_L: RA26.1 RA28.1 UA1.38
MIC_CLK: CA34.1 JEDP.23 LA6.1 RV13.1
MIC_DATA: CA35.1 JEDP.22 RA19.1
MUX_EDP_A0N: CV2.2 UV21.45
MUX_EDP_A0P: CV1.2 UV21.46
MUX_EDP_A1N: CV4.2 UV21.42
MUX_EDP_A1P: CV3.2 UV21.43
MUX_EDP_A2N: CV6.2 UV21.39
MUX_EDP_A2P: CV8.2 UV21.40
MUX_EDP_A3N: CV11.2 UV21.36
MUX_EDP_A3P: CV7.2 UV21.37
MUX_EDP_AUXN: CV13.2 RV19.2 UV21.31
MUX_EDP_AUXP: CV12.2 RV20.1 UV21.32
N17_ID0: RH27.1 RH28.1 UH1.AL43
N17_ID1: RH25.1 RH26.1 UH1.AJ43
NC_B4: RT45.1 RT86.2 UT1.B4
NC_B5: RT46.1 UT1.B5
NC_G2: RT47.1 UT1.G2
NRB_BIT: RH524.2 UH1.BD28
NUM: JKB.2 RE636.1
NUM_LED: RE637.1 UE5.36
NVVDD1_EN: UE10.15
NVVDD2_EN: UE10.19
ON/OFF#: CE27.1 JPWR.5 RE63.1 SW1.2 UE5.114
OUT_A: CA67.1 CA87.1 LA50.1 UA4.55
OUT_B: CA68.1 CA88.1 LA51.1 UA4.52
OUT_C: CA69.1 CA89.1 LA52.1 UA4.47
OUT_D: CA70.1 CA90.1 LA53.1 UA4.44
P1: PC701.1 PQ700.3 PQ701.1 PQ701.2 PQ701.3 PQ702.1 PQ702.2 PQ702.3 PQ707.1 PQ707.2 PQ707.3 PQ708.1 PQ708.2 PQ708.3 PR701.2 PR706.1
P2: PQ702.5 PQ708.5 PR702.1
PA_USB2_RBIAS: RT43.1 UT1.H19
PANELL_LED_B_DRV#: JLOGO.11 UE8.14
PANELL_LED_G_DRV#: JLOGO.10 UE8.11
PANELL_LED_R_DRV#: JLOGO.9 UE8.10
PANELR_LED_B_DRV#: JLOGO.14 UE8.17
PANELR_LED_G_DRV#: JLOGO.13 UE8.16
PANELR_LED_R_DRV#: JLOGO.12 UE8.15
PB_USB2_RBIAS: RT44.1 UT1.F19
PBTN_OUT#: CH174.1 RH2.2 UE5.106 UH1.AT13
PC0: RV624.1 RV625.1 UV21.38
PC1: RV626.1 RV627.1 UV21.55
PC_BEEP: DA1.1 RA9.1 RA15.1
PCH_AZ_BITCLK: RP2.5 UH1.BA9
PCH_AZ_CODEC_BITCLK: RA2.1 RP2.4 UA1.13
PCH_AZ_CODEC_RST#: RA17.1 RP2.3
PCH_AZ_CODEC_RST#_R: RA17.2 UA1.15
PCH_AZ_CODEC_SDIN0: RA18.1 UH1.BE7
PCH_AZ_CODEC_SDOUT: RA10.1 RP2.1 UA1.17
PCH_AZ_CODEC_SYNC: RP2.2 UA1.14
PCH_AZ_RST#: RP2.6 UH1.BD8
PCH_AZ_SDOUT: RH16.2 RP2.8 UH1.BB7
PCH_AZ_SYNC: RP2.7 UH1.BD9
PCH_BATLOW#: RH515.1 RT14.2 UH1.BD13
PCH_CPU_BCLK_N: CPU1.A32 UH1.H2
PCH_CPU_BCLK_P: CPU1.B31 UH1.G2
PCH_CPU_PCIBCLK_N: CPU1.C36 UH1.J1
PCH_CPU_PCIBCLK_P: CPU1.D35 UH1.J2
PCH_DPWROK: DE4.2 RH90.2 UE5.127 UH1.AV11
PCH_JTAG_TCK: CPU1.BR28 JPCMC.32 RC35.1 UH1.AR3
PCH_PECI: RH73.1 UH1.AL3
PCH_PLTRST#: UH1.BB27 UH3.1 UH3.2 UM3.2
PCH_PWR_EN: C268.1 PR300.1 RE74.1 U18.4
PCH_PWROK: CE44.1 DE3.2 RE75.1 UE5.32 UH1.AW11
PCH_RTCRST#: CH53.1 CLRP1.1 QE5.1 RH84.2 UH1.BC10
PCH_RTCX1: CH45.1 RH70.1 UH1.BC9 YH1.1
PCH_RTCX2: CH46.1 RH70.2 UH1.BD10 YH1.2
PCH_SATADET#: RH512.1 RS8.1 UH1.AD44
PCH_SMBCLK: JDIMM1.253 JDIMM2.253 JTP.15 RH463.2 UH1.AW44 US1.4
PCH_SMBDATA: JDIMM1.254 JDIMM2.254 JTP.16 RH462.2 UH1.BB43 US1.6
PCH_SPI_CLK: RH104.1 UH4.6
PCH_SPI_CLK_R: RH104.2 UH1.BC31
PCH_SPI_CS#: RH74.2 UH1.BD31 UH4.1
PCH_SPI_HOLD#: RPH5.4 UH4.7
PCH_SPI_HOLD#_R: RH78.2 RH455.2 RPH5.5 UH1.BD30
PCH_SPI_SI: RPH5.2 UH4.5
PCH_SPI_SI_R: RH1.2 RH489.1 RPH5.7 UH1.BB29
PCH_SPI_SO: RPH5.3 UH4.2
PCH_SPI_SO_R: RPH5.6 UH1.BE30
PCH_SPI_WP#: RPH5.1 UH4.3
PCH_SPI_WP#_R: RC354.2 RH75.2 RPH5.8 UH1.BC29
PCH_SRTCRST#: CH52.1 RH83.2 UH1.BB10
PCH_SYS_PWROK_XDP: RH489.2 RH493.2
PCH_TRIGGER: RH167.1 UH1.AL2
PCH_XDP_CLK_N: T49.1(TP-1) UH1.L1
PCH_XDP_CLK_P: T50.1(TP-1) UH1.L2
PCIE_GEN3#_GEN2: UE1.18 UE6.11
PCIE_PRX_DTX_N5: CL2.2 UH1.K19
PCIE_PRX_DTX_N5_C: CL2.1 UL1.29
PCIE_PRX_DTX_N6: JWLAN.35 UH1.G22
PCIE_PRX_DTX_N9: JSSD3.43 UH1.G31
PCIE_PRX_DTX_N10: JSSD3.29 UH1.G29
PCIE_PRX_DTX_N11: JSSD3.17 UH1.L31
PCIE_PRX_DTX_N12: JSSD3.5 UH1.G33
PCIE_PRX_DTX_N13: JSSD1.29 UH1.G35
PCIE_PRX_DTX_N14: JSSD1.43 UH1.D39
PCIE_PRX_DTX_N17: JSSD2.43 UH1.H42
PCIE_PRX_DTX_N18: JSSD2.29 UH1.K37
PCIE_PRX_DTX_N19: JSSD2.17 UH1.L37
PCIE_PRX_DTX_N20: JSSD2.5 UH1.N39
PCIE_PRX_DTX_P5: CL1.2 UH1.L19
PCIE_PRX_DTX_P5_C: CL1.1 UL1.30
PCIE_PRX_DTX_P6: JWLAN.33 UH1.E22
PCIE_PRX_DTX_P9: JSSD3.41 UH1.H31
PCIE_PRX_DTX_P10: JSSD3.31 UH1.E29
PCIE_PRX_DTX_P11: JSSD3.19 UH1.K31
PCIE_PRX_DTX_P12: JSSD3.7 UH1.H33
PCIE_PRX_DTX_P13: JSSD1.31 UH1.E35
PCIE_PRX_DTX_P14: JSSD1.41 UH1.E37
PCIE_PRX_DTX_P17: JSSD2.41 UH1.H40
PCIE_PRX_DTX_P18: JSSD2.31 UH1.G37
PCIE_PRX_DTX_P19: JSSD2.19 UH1.L39
PCIE_PRX_DTX_P20: JSSD2.7 UH1.N38
PCIE_PTX_DRX_N5: CL4.2 UH1.D22
PCIE_PTX_DRX_N5_C: CL4.1 UL1.36
PCIE_PTX_DRX_N6: CN24.2 UH1.B22
PCIE_PTX_DRX_N6_C: CN24.1 JWLAN.29
PCIE_PTX_DRX_N9: CH210.1 JSSD3.47
PCIE_PTX_DRX_N9_C: CH210.2 UH1.C31
PCIE_PTX_DRX_N10: CH212.1 JSSD3.35
PCIE_PTX_DRX_N10_C: CH212.2 UH1.C32
PCIE_PTX_DRX_N11: CH203.2 JSSD3.23
PCIE_PTX_DRX_N11_C: CH203.1 UH1.C33
PCIE_PTX_DRX_N12: CH209.2 JSSD3.11
PCIE_PTX_DRX_N12_C: CH209.1 UH1.B35
PCIE_PTX_DRX_N13: CH206.2 JSSD1.35
PCIE_PTX_DRX_N13_C: CH206.1 UH1.C36
PCIE_PTX_DRX_N14: CH204.2 JSSD1.47
PCIE_PTX_DRX_N14_C: CH204.1 UH1.B38
PCIE_PTX_DRX_N17: CH214.1 JSSD2.47
PCIE_PTX_DRX_N17_C: CH214.2 UH1.E45
PCIE_PTX_DRX_N18: CH216.1 JSSD2.35
PCIE_PTX_DRX_N18_C: CH216.2 UH1.G45
PCIE_PTX_DRX_N19: CH221.2 JSSD2.23
PCIE_PTX_DRX_N19_C: CH221.1 UH1.H43
PCIE_PTX_DRX_N20: CH219.2 JSSD2.11
PCIE_PTX_DRX_N20_C: CH219.1 UH1.K44
PCIE_PTX_DRX_P5: CL3.2 UH1.C22
PCIE_PTX_DRX_P5_C: CL3.1 UL1.35
PCIE_PTX_DRX_P6: CN23.2 UH1.A23
PCIE_PTX_DRX_P6_C: CN23.1 JWLAN.27
PCIE_PTX_DRX_P9: CH211.1 JSSD3.49
PCIE_PTX_DRX_P9_C: CH211.2 UH1.B31
PCIE_PTX_DRX_P10: CH213.1 JSSD3.37
PCIE_PTX_DRX_P10_C: CH213.2 UH1.B32
PCIE_PTX_DRX_P11: CH202.2 JSSD3.25
PCIE_PTX_DRX_P11_C: CH202.1 UH1.B33
PCIE_PTX_DRX_P12: CH208.2 JSSD3.13
PCIE_PTX_DRX_P12_C: CH208.1 UH1.A35
PCIE_PTX_DRX_P13: CH207.2 JSSD1.37
PCIE_PTX_DRX_P13_C: CH207.1 UH1.B36
PCIE_PTX_DRX_P14: CH205.2 JSSD1.49
PCIE_PTX_DRX_P14_C: CH205.1 UH1.C38
PCIE_PTX_DRX_P17: CH215.1 JSSD2.49
PCIE_PTX_DRX_P17_C: CH215.2 UH1.F45
PCIE_PTX_DRX_P18: CH217.1 JSSD2.37
PCIE_PTX_DRX_P18_C: CH217.2 UH1.G44
PCIE_PTX_DRX_P19: CH220.2 JSSD2.25
PCIE_PTX_DRX_P19_C: CH220.1 UH1.H44
PCIE_PTX_DRX_P20: CH218.2 JSSD2.13
PCIE_PTX_DRX_P20_C: CH218.1 UH1.J45
PCIE_RBIAS: RT3.1 UT1.N16
PCIE_WAKE#: RH4.1 RL1.2 UE5.64 UL1.3
PCIECOMP: RH193.1 UH1.C17
PCIECOMP#: RH193.2 UH1.B18
PCIRST#: CE34.1 JSSD1.50 JSSD2.50 JSSD3.50 JWLAN.44 RC355.2 RH199.1 RT1.1 UE5.13 UG2.2 UH3.4 UL1.2
PD_EE_CLK: RT101.2 UT4.A3
PD_EE_CS_N: RT100.2 UT4.B3
PD_EE_DI: RT98.2 UT4.B4
PD_EE_DO: RT99.2 UT4.A4
PD_IRQ#: RT107.2 UE5.89 UT4.B6
PD_RESET: RT109.1 UE10.8
PD_UART: RT62.1 UT4.E2 UT4.F2
PECI_KB9012: RE76.1 UE5.118
PEG_CRX_C_GTX_N8: CM69.2 UM8.4
PEG_CRX_C_GTX_N9: CM66.2 UM8.8
PEG_CRX_C_GTX_N10: CM62.2 UM8.6
PEG_CRX_C_GTX_N11: CM65.2 UM8.2
PEG_CRX_C_GTX_P8: CM67.2 UM8.3
PEG_CRX_C_GTX_P9: CM63.2 UM8.7
PEG_CRX_C_GTX_P10: CM68.2 UM8.5
PEG_CRX_C_GTX_P11: CM64.2 UM8.1
PEG_CRX_GTX_N0: CG2.2 CPU1.E10
PEG_CRX_GTX_N0_C: CG2.1 UG1.AR39
PEG_CRX_GTX_N1: CG4.2 CPU1.E11
PEG_CRX_GTX_N1_C: CG4.1 UG1.AN37
PEG_CRX_GTX_N2: CG6.2 CPU1.E12
PEG_CRX_GTX_N2_C: CG6.1 UG1.AN38
PEG_CRX_GTX_N3: CG8.2 CPU1.E13
PEG_CRX_GTX_N3_C: CG8.1 UG1.AM38
PEG_CRX_GTX_N4: CG10.2 CPU1.E14
PEG_CRX_GTX_N4_C: CG10.1 UG1.AK39
PEG_CRX_GTX_N5: CG12.2 CPU1.E15
PEG_CRX_GTX_N5_C: CG12.1 UG1.AJ37
PEG_CRX_GTX_N6: CG14.2 CPU1.E16
PEG_CRX_GTX_N6_C: CG14.1 UG1.AJ38
PEG_CRX_GTX_N7: CG16.2 CPU1.E17
PEG_CRX_GTX_N7_C: CG16.1 UG1.AG38
PEG_CRX_GTX_N8: CM69.1 CPU1.F18
PEG_CRX_GTX_N9: CM66.1 CPU1.D19
PEG_CRX_GTX_N10: CM62.1 CPU1.F20
PEG_CRX_GTX_N11: CM65.1 CPU1.D21
PEG_CRX_GTX_P0: CG1.2 CPU1.F10
PEG_CRX_GTX_P0_C: CG1.1 UG1.AR38
PEG_CRX_GTX_P1: CG3.2 CPU1.D11
PEG_CRX_GTX_P1_C: CG3.1 UG1.AR37
PEG_CRX_GTX_P2: CG5.2 CPU1.F12
PEG_CRX_GTX_P2_C: CG5.1 UG1.AN39
PEG_CRX_GTX_P3: CG7.2 CPU1.D13
PEG_CRX_GTX_P3_C: CG7.1 UG1.AM39
PEG_CRX_GTX_P4: CG9.2 CPU1.F14
PEG_CRX_GTX_P4_C: CG9.1 UG1.AK38
PEG_CRX_GTX_P5: CG11.2 CPU1.D15
PEG_CRX_GTX_P5_C: CG11.1 UG1.AK37
PEG_CRX_GTX_P6: CG13.2 CPU1.F16
PEG_CRX_GTX_P6_C: CG13.1 UG1.AJ39
PEG_CRX_GTX_P7: CG15.2 CPU1.D17
PEG_CRX_GTX_P7_C: CG15.1 UG1.AG39
PEG_CRX_GTX_P8: CM67.1 CPU1.E18
PEG_CRX_GTX_P9: CM63.1 CPU1.E19
PEG_CRX_GTX_P10: CM68.1 CPU1.E20
PEG_CRX_GTX_P11: CM64.1 CPU1.E21
PEG_CRX_TTX_N12: CPU1.F22 CT16.1
PEG_CRX_TTX_N12_C: CT16.2 UT1.V22
PEG_CRX_TTX_N13: CPU1.D23 CT2.1
PEG_CRX_TTX_N13_C: CT2.2 UT1.P22
PEG_CRX_TTX_N14: CPU1.F24 CT108.1
PEG_CRX_TTX_N14_C: CT108.2 UT1.K22
PEG_CRX_TTX_N15: CPU1.D25 CT110.1
PEG_CRX_TTX_N15_C: CT110.2 UT1.F22
PEG_CRX_TTX_P12: CPU1.E22 CT14.1
PEG_CRX_TTX_P12_C: CT14.2 UT1.V23
PEG_CRX_TTX_P13: CPU1.E23 CT12.1
PEG_CRX_TTX_P13_C: CT12.2 UT1.P23
PEG_CRX_TTX_P14: CPU1.E24 CT109.1
PEG_CRX_TTX_P14_C: CT109.2 UT1.K23
PEG_CRX_TTX_P15: CPU1.E25 CT111.1
PEG_CRX_TTX_P15_C: CT111.2 UT1.F23
PEG_CTX_C_GRX_N0: CC1.2 UG1.AN43
PEG_CTX_C_GRX_N1: CC2.2 UG1.AM41
PEG_CTX_C_GRX_N2: CC3.2 UG1.AM42
PEG_CTX_C_GRX_N3: CC4.2 UG1.AK42
PEG_CTX_C_GRX_N4: CC5.2 UG1.AJ43
PEG_CTX_C_GRX_N5: CC6.2 UG1.AG41
PEG_CTX_C_GRX_N6: CC7.2 UG1.AG42
PEG_CTX_C_GRX_N7: CC8.2 UG1.AF42
PEG_CTX_C_GRX_N8: CC9.2 JCDRA.4
PEG_CTX_C_GRX_N9: CC10.2 JCDRA.7
PEG_CTX_C_GRX_N10: CC11.2 JCDRA.10
PEG_CTX_C_GRX_N11: CC12.2 JCDRA.13
PEG_CTX_C_GRX_P0: CC13.2 UG1.AN42
PEG_CTX_C_GRX_P1: CC14.2 UG1.AN41
PEG_CTX_C_GRX_P2: CC15.2 UG1.AM43
PEG_CTX_C_GRX_P3: CC16.2 UG1.AK43
PEG_CTX_C_GRX_P4: CC17.2 UG1.AJ42
PEG_CTX_C_GRX_P5: CC18.2 UG1.AJ41
PEG_CTX_C_GRX_P6: CC19.2 UG1.AG43
PEG_CTX_C_GRX_P7: CC20.2 UG1.AF43
PEG_CTX_C_GRX_P8: CC21.2 JCDRA.3
PEG_CTX_C_GRX_P9: CC22.2 JCDRA.6
PEG_CTX_C_GRX_P10: CC23.2 JCDRA.9
PEG_CTX_C_GRX_P11: CC24.2 JCDRA.12
PEG_CTX_GRX_N0: CC1.1 CPU1.B10
PEG_CTX_GRX_N1: CC2.1 CPU1.B11
PEG_CTX_GRX_N2: CC3.1 CPU1.B12
PEG_CTX_GRX_N3: CC4.1 CPU1.B13
PEG_CTX_GRX_N4: CC5.1 CPU1.B14
PEG_CTX_GRX_N5: CC6.1 CPU1.B15
PEG_CTX_GRX_N6: CC7.1 CPU1.B16
PEG_CTX_GRX_N7: CC8.1 CPU1.B17
PEG_CTX_GRX_N8: CC9.1 CPU1.C18
PEG_CTX_GRX_N9: CC10.1 CPU1.A19
PEG_CTX_GRX_N10: CC11.1 CPU1.C20
PEG_CTX_GRX_N11: CC12.1 CPU1.A21
PEG_CTX_GRX_P0: CC13.1 CPU1.C10
PEG_CTX_GRX_P1: CC14.1 CPU1.A11
PEG_CTX_GRX_P2: CC15.1 CPU1.C12
PEG_CTX_GRX_P3: CC16.1 CPU1.A13
PEG_CTX_GRX_P4: CC17.1 CPU1.C14
PEG_CTX_GRX_P5: CC18.1 CPU1.A15
PEG_CTX_GRX_P6: CC19.1 CPU1.C16
PEG_CTX_GRX_P7: CC20.1 CPU1.A17
PEG_CTX_GRX_P8: CC21.1 CPU1.B18
PEG_CTX_GRX_P9: CC22.1 CPU1.B19
PEG_CTX_GRX_P10: CC23.1 CPU1.B20
PEG_CTX_GRX_P11: CC24.1 CPU1.B21
PEG_CTX_TRX_N12: CPU1.C22 CT15.1
PEG_CTX_TRX_N12_C: CT15.2 UT1.Y22
PEG_CTX_TRX_N13: CPU1.A23 CT13.1
PEG_CTX_TRX_N13_C: CT13.2 UT1.T22
PEG_CTX_TRX_N14: CPU1.C24 CT18.1
PEG_CTX_TRX_N14_C: CT18.2 UT1.M22
PEG_CTX_TRX_N15: CPU1.A25 CT21.1
PEG_CTX_TRX_N15_C: CT21.2 UT1.H22
PEG_CTX_TRX_P12: CPU1.B22 CT3.1
PEG_CTX_TRX_P12_C: CT3.2 UT1.Y23
PEG_CTX_TRX_P13: CPU1.B23 CT1.1
PEG_CTX_TRX_P13_C: CT1.2 UT1.T23
PEG_CTX_TRX_P14: CPU1.B24 CT4.1
PEG_CTX_TRX_P14_C: CT4.2 UT1.M23
PEG_CTX_TRX_P15: CPU1.B25 CT5.1
PEG_CTX_TRX_P15_C: CT5.2 UT1.H23
PEG_RCOMP: CPU1.G2 RC2.2
PEX_VDD_EN: UE10.17
PI0: RV622.1 RV623.1 UV21.56
PLT_RST_VGA#: RG1.1 RG152.1 UG1.AV42 UG2.4
PLTRST_CPU#: CH195.1 CPU1.BP35 UH1.AK2
PM_SLP_S3#: CE41.1 Q8.2 QE1.5 UE5.6 UH1.AW15
PM_SLP_S3_H: Q7.2 Q7.5 Q8.5 Q8.6 R307.2
PM_SLP_S4#: PR1301.2 Q9.2 UE5.73 UH1.BD15
PM_SLP_S4_H: Q9.5 Q9.6 R325.2
PM_SLP_S5#: CE45.1 QE4.5 UE5.14 UH1.BA13
PM_SLP_SUS#: UE5.38 UH1.BB13
POK: DE2.1 DE3.1 DE4.1 PR14.1 PR17.2 PU100.7
POWER_LED: QE4.6 QE8.2 RE28.2
PQ703_S: PC725.2 PL700.2 PQ703.1 PQ703.2 PQ703.3 PR712.1 PR734.1
PROC_DETECT#: RH519.1 UH1.Y44
PS_ID: PR3.1 PR4.2 UE5.16
PSID: PJPDC1.1 PL2.2
PSID-1: PQ2.2 PR6.1 PR9.2
PSID-2: PQ2.1 PQ7.2 PR8.2
PSID-3: PQ7.3 PR4.1
PWM1: PR6009.1 PU6102.4 PU8201.31
PWM1_GT: PR590.2 PU500.12
PWM1_VCORE: PR552.2 PU500.25
PWM2: PR6016.1 PU6201.4 PU8201.29
PWM2_GT: PR591.2 PU500.13
PWM2_VCORE: PR563.2 PU500.26
PWM3: PR6084.1 PU6202.4 PU8201.30
PWM3_VCORE: PR573.2 PU500.27
PWM4: PR6023.1 PU6301.4 PU8201.28
PWM_SA: PR5001.1 PU500.35
PWM_VDDCI: PR6061.1 PU6400.4 PU8201.27
PWR_B#: JPWR.4 QE13.3 RE154.2 RE160.1
PWR_B_7313#: QE13.4 UE3.17
PWR_B_EC: QE13.2 UE6.22
PWR_G#: JPWR.3 QE21.3 RE155.1 RE156.2
PWR_G_7313#: QE21.4 UE3.16
PWR_G_EC: QE21.2 UE6.10
PWR_LED#: QE4.2 UE5.92
PWR_R#: JPWR.2 QE22.3 RE157.1 RE158.2
PWR_R_7313#: QE22.4 UE3.15
PWR_R_EC: QE22.2 UE6.6
PWR_SRC_ON: CV15.2 QV1.3 RV9.2 RV12.1
PWR_VGA_CORE_BOOT1: PR8205.2 PU8200.1
PWR_VGA_CORE_BOOT1_1: PC8206.2 PR8205.1
PWR_VGA_CORE_BOOT2: PR8207.2 PU8200.15
PWR_VGA_CORE_BOOT2_1: PC8213.2 PR8207.1
PWR_VGA_CORE_LGATE1: PQ8200.6 PR8206.2 PU8200.19
PWR_VGA_CORE_LGATE2: PQ8201.6 PU8200.17
PWR_VGA_CORE_PHASE1: PC8206.1 PL8200.1 PQ8200.7 PR8204.1 PU8200.20
PWR_VGA_CORE_PHASE2: PC8213.1 PL8201.1 PQ8201.7 PR8210.1 PU8200.16
PWR_VGA_CORE_SS: PC8216.1 PU8200.11
PWR_VGA_CORE_TON: PR8202.1 PU8200.9
PWR_VGA_CORE_TON_1: PC8205.1 PR8201.1 PR8202.2
PWR_VGA_CORE_UGATE1: PQ8200.1 PU8200.2
PWR_VGA_CORE_UGATE2: PQ8201.1 PU8200.14
PWRSHARE_EN_EC#: UE5.119 UU1.5
PX_EN: TV1.1(TP-1) UG1.V40
R16M_ID: RH29.1 RH30.1 UH1.AK45
REGN_CHG: PC710.1 PR714.1 PU700.24
REMOTE1+: C2500.1 C2502.1 Q2407.1 Q2407.2 U2407.2
REMOTE1-: C2500.2 C2502.2 Q2407.3 R184.1
REMOTE2+: C2504.1 C2505.1 Q2408.1 Q2408.2 U2407.4
REMOTE2-: C2504.2 C2505.2 Q2408.3 R184.2 U2407.3
REMOTE3+: C2510.1 C2511.1 Q2411.1 Q2411.2 U2407.5
REMOTE3-: C2510.2 C2511.2 Q2411.3 R185.2
RESET#: CV67.1 RV200.1 U1.35
RESET_N: RT102.1 UT4.F11
RF_+1VALWP: PR306.1 PU300.5
RING2: LA8.2 RA28.2 UA1.36
RING2_R: CA46.1 CA92.1 DA5.2 JACK1.4 LA8.1
RJ45_CT: CL30.2 RL9.2 RL10.2 RL11.2 RL12.2
RJ45_CT0: RL12.1 TL1.15
RJ45_CT1: RL11.1 TL1.16
RJ45_CT2: RL10.1 TL1.21
RJ45_CT3: RL9.1 TL1.22
RJ45_MDI0+: JLAN.1 TL1.13
RJ45_MDI0-: JLAN.2 TL1.14
RJ45_MDI1+: JLAN.3 TL1.17
RJ45_MDI1-: JLAN.6 TL1.18
RJ45_MDI2+: JLAN.4 TL1.19
RJ45_MDI2-: JLAN.5 TL1.20
RJ45_MDI3+: JLAN.7 TL1.23
RJ45_MDI3-: JLAN.8 TL1.24
RPD_G1: RT64.1 UT4.K9
RPD_G2: RT65.1 UT4.K10
RST#: CE55.2 RE91.2 UE6.3
RT8812_PVCC: PC8200.1 PR8200.1 PU8200.18
RTD3_CIO_PWR_EN: RT16.2 UH1.AR44
RTD3_CIO_PWR_EN_R: RT16.1 RT36.1 UT1.F1
RTD3_USB_PWR_EN: RT12.2 UH1.AR41
RTD3_USB_PWR_EN_R: RT12.1 RT37.1 UT1.D4
SATA_DET#: JHDD.19 RS8.2
SATA_GP0: JSSD3.69 R364.1 UH1.AG36
SATA_GP1: JSSD1.69 R363.1 UH1.AG35
SATA_GP3: JHDD.16 RS2.1 RS3.1 UH1.AD35
SATA_GP4: JSSD2.69 R365.1 UH1.AD31
SATA_PRX_DTX_N3: JHDD.1 UH1.D43
SATA_PRX_DTX_P3: JHDD.2 UH1.E42
SATA_PTX_DRX_N3: JHDD.4 UH1.A41
SATA_PTX_DRX_P3: JHDD.5 UH1.A40
SCL: RG12.2 UG1.AF34
SDA: RG13.2 UG1.AF33
SERIRQ: RH111.1 UE5.3 UH1.BA17
SLEEVE: LA7.2 RA26.2 UA1.37
SLEEVE_R: CA45.1 CA91.1 DA5.3 JACK1.3 LA7.1
SLP_S3: QE1.3 RE15.2 UE1.26
SLP_S5: QE4.3 RE16.2 UE1.21
SM_PG_CTRL: PR211.2 RH525.2 UC1.4
SML0CLK: RH501.2 RV632.1 UH1.AY44 UM4.11
SML0DATA: RH502.2 RV633.1 UH1.BB39 UM4.10
SML1CLK: QH5.6 RH460.2 UH1.AW42
SML1DATA: QH5.3 RH461.2 UH1.AW45
SNB_+VGA_PCIE: PC802.1 PR803.2
SNB_VCCIO: PC591.1 PR5009.2
SNUB_CHG: PC715.1 PR713.2
SPEAKER_SEL: JSPK.5 UE10.2
SPI_MOCLK: CE57.1 RE11.2 UE1.2
SPI_MOCS#: RE12.2 UE1.31 UE2.1
SPI_MOSI: RE9.2 UE1.32
SPI_MOSO: RE10.2 UE1.1
SPK_L+_CONN: CA255.1 DA7.2 JSPK.4 LA51.2 RA61.1
SPK_L-_CONN: DA7.3 JSPK.3 RA57.2 RA59.1
SPK_R+_CONN: CA257.1 DA8.2 JSPK.2 LA53.2 RA65.1
SPK_R-_CONN: DA8.3 JSPK.1 RA60.2 RA64.1
STRAP3_PCH: UH1.L43
STRAP5_PCH: UH1.L44
SUSACK#: UE5.97 UH1.BB19
SUSCLK: JSSD1.68 JSSD2.68 JSSD3.68 JWLAN.42 UH1.AN15
SUSP#: PR209.1 PR807.2 PR5007.2 Q8.3 R174.1 R182.1 RT15.2 U16.4 U20.4 UE5.116 UZ21.3
SUSP#_R: RT15.1 RT30.2 UT1.D2
SVC: PR6002.1 PR6006.2 PR6011.2 PU8201.4
SVD: PR6001.1 PR6004.2 PR6007.2 PU8201.2
SVI2_SVC: PR6011.1 UG1.AM23
SVI2_SVD: PR6007.1 UG1.AP23
SVI2_SVT: PR6010.1 UG1.AN23
SW_1.2V: PC204.2 PL201.2 PQ200.1 PQ200.2 PQ200.3 PQ201.5 PR202.1 PU201.16
SW_+1VALWP: PC305.2 PL300.1 PQ300.1 PQ300.2 PQ300.3 PQ301.5 PR305.1 PU300.8
SW_USB20_N1: LU3.1 UU1.11
SW_USB20_P1: LU3.4 UU1.10
SYNC_OUT: TC24.1(TP-1) UA4.38
SYS_PWROK: CE46.1 PR6008.1 UE5.74 UH1.AY1
SYS_RESET#: CH175.1 RH5.2 RH571.1 UH1.AW1
SYSON: CE42.1 PR208.2 Q9.3 U19.4 UE5.95
TB_STAT#_CHG: PQ705.2 PR718.1 PU700.16
TBT_A_AUX_N: CT44.2 UT1.W15
TBT_A_AUX_N_C: CT44.1 RT70.2 UT4.J2
TBT_A_AUX_P: CT43.2 UT1.Y15
TBT_A_AUX_P_C: CT43.1 RT73.1 UT4.J1
TBT_A_USB20_L_NB: DT10.4 DT10.7 JUSBC1.B7 LT3.3
TBT_A_USB20_L_NT: DT10.2 DT10.8 JUSBC1.A7 LT2.2
TBT_A_USB20_L_PB: DT10.5 DT10.6 JUSBC1.B6 LT3.2
TBT_A_USB20_L_PT: DT10.1 DT10.9 JUSBC1.A6 LT2.3
TBT_A_USB20_N: UT1.D20 UT4.K5
TBT_A_USB20_NB: LT3.4 UT4.L7
TBT_A_USB20_NT: LT2.1 UT4.L6
TBT_A_USB20_P: UT1.E20 UT4.L5
TBT_A_USB20_PB: LT3.1 UT4.K7
TBT_A_USB20_PT: LT2.4 UT4.K6
TBT_CIO_PLUG_EVENT#: RT29.2 UH1.AN43 UT1.W2
TBT_EE_CLK: RT101.1 UT1.AB4 UT2.6
TBT_EE_CS_N: RT50.2 RT100.1 UT1.AC3 UT2.1
TBT_EE_DI: RT98.1 UT1.AB3 UT2.5
TBT_EE_DO: RT49.1 RT99.1 UT1.AC4 UT2.2
TBT_EE_WP_N: RT48.2 UT1.V1 UT2.3
TBT_FORCE_PWR: RT13.2 UH1.P43
TBT_FORCE_PWR_R: RT13.1 RT35.1 RT94.2 UT1.H4
TBT_HDMI_DDC_CLK: T9.1(TP-1) UT1.Y2
TBT_HDMI_DDC_DATA: T7.1(TP-1) UT1.Y1
TBT_HOLD_N: RT51.2 UT2.7
TBT_I2C_SCL: RT27.2 UT1.U2 UT4.D2
TBT_I2C_SDA: RT26.2 UT1.U1 UT4.D1
TBT_PCIE_WAKE#: RT10.2 UE5.70
TBT_PCIE_WAKE_N: RT10.1 RT28.2 UT1.W1
TBT_RBIAS: RT25.1 UT1.H6
TBT_RESET_N: RT23.1 RT80.1 RT102.2 UT1.F4
TBT_RESET_N_EC: RT23.2 UE5.15
TBT_RSENSE: RT25.2 UT1.J6
TBT_RST#_R: RT1.2 UT1.L4
TBT_SRC_CFG1: RT11.1 UT1.AA1
TBT_SRC_HPD: RT4.1 UT1.G1
TBT_SVR_IND: LT1.1 UT1.C1 UT1.C2 UT1.D1
TBT_TCK: RT7.2 UT1.T4
TBT_TDI: RT9.2 UT1.Y4
TBT_TDO: RT6.2 UT1.W4
TBT_TEST_EN: RT17.1 UT1.E1
TBT_TEST_PWG: RT18.1 UT1.AB5
TBT_TMS: RT8.2 UT1.V4
TBT_TMU_CLK_OUT: RT34.1 T2.1(TP-1) UT1.V2
TBT_XTAL_25_IN: CT37.1 UT1.D22 YT1.1
TBT_XTAL_25_OUT: CT38.1 UT1.D23 YT1.3
TBTA_CC1: CT112.1 DT11.1 JUSBC1.A5 UT4.L9
TBTA_CC2: CT113.1 DT12.1 JUSBC1.B5 UT4.L10
TBTA_DEBUG1: RT71.1 UT4.L2
TBTA_DEBUG2: RT72.1 UT4.K2
TBTA_DIG_AUD_N: RT69.1 UT4.K3
TBTA_DIG_AUD_P: RT68.1 UT4.L3
TBTA_HPD: RT41.1 UT1.M4 UT4.C10
TBTA_I2C_INT: RT32.2 UT1.J4 UT4.C1
TBTA_I2C_SCL1_R: RT57.2 RT60.2 UT4.B5
TBTA_I2C_SDA1_R: RT58.2 RT59.2 UT4.A5
TBTA_LDO_BMC: CT98.1 UT4.E1
TBTA_LSRX: RT42.1 UT1.A4 UT4.K4
TBTA_LSTX: RT21.2 RT40.1 UT1.A5 UT4.L4
TBTA_MRESET: RT63.1 UT4.E11
TBTA_ROSC: RT75.1 UT4.G2
TBTA_SBU1: DT13.1 JUSBC1.A8 UT4.K8
TBTA_SBU2: DT14.1 JUSBC1.B8 UT4.L8
TBTB_I2C_INT: RT33.2 UT1.E2
TEST_PG: RG17.1 UG1.AA31
TEST_PG_BACO: RG20.1 UG1.Y32
TESTEN: RG7.1 RG396.1 TV6.1(TP-1) UG1.AE30
THERMDA: UT1.AB23 UT1.AC23
TMDS_C_TX0N: LV4.4 RV643.1 U1.16
TMDS_C_TX0P: LV4.1 RV646.1 U1.17
TMDS_C_TX1N: LV5.4 RV642.1 U1.19
TMDS_C_TX1P: LV5.1 RV639.1 U1.20
TMDS_C_TX2N: LV6.4 RV645.1 U1.22
TMDS_C_TX2P: LV6.1 RV638.1 U1.23
TMDS_C_TXCN: LV3.4 RV641.1 U1.13
TMDS_C_TXCP: LV3.1 RV640.1 U1.14
TMDS_CTRLCLK: JHDMI.15 U1.7
TMDS_CTRLDAT: JHDMI.16 U1.8
TMDS_R_TX0N: JHDMI.9 LV4.3 RV501.1 RV643.2
TMDS_R_TX0P: JHDMI.7 LV4.2 RV501.2 RV646.2
TMDS_R_TX1N: JHDMI.6 LV5.3 RV502.1 RV642.2
TMDS_R_TX1P: JHDMI.4 LV5.2 RV502.2 RV639.2
TMDS_R_TX2N: JHDMI.3 LV6.3 RV503.1 RV645.2
TMDS_R_TX2P: JHDMI.1 LV6.2 RV503.2 RV638.2
