# Allegro board LAD752PR10-0816.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+5VALW_LED: length 20.6
  TOP w0.508: v1(206.07,151.68) 206.07,154.21 205.75,154.53 205.75,157.7 v2(207.05,159) 207.63,159.58 207.63,164.04 208.14,164.55 209.81,164.55 210.32,165.06 JPWR.1
  BOTTOM w0.508: v1(206.07,151.68) 206.07,150.18 QE8.1
+5VALWP: length 22.5
  TOP w0.508: v1(53.46,43.28) 53.35,43.16 53.35,43.05 52.84,42.54 50.75,42.54 50.65,42.64 45.98,42.64
  BOTTOM w0.203: PU100.14 v1(53.46,43.28)
  BOTTOM w0.254: 37.41,46.39 37.85,46.83 46.81,46.83 49.4,49.42 PR102.2
  vias: v1(39.12,42.01) v1(39.44,42.51) v1(39.38,41.43) v1(39.76,42.01) v1(39.7,40.93) v1(40.01,41.43) v1(40.14,42.51) v1(40.33,40.93) v1(40.46,42.01) v1(40.65,41.43) v1(40.78,42.51) v1(40.97,40.93) v1(41.09,42.01) v1(41.28,41.43) v1(41.41,42.51) v1(41.66,40.93) v1(41.73,42.01) v1(42.05,42.51) v1(41.98,41.43) v1(42.36,42.01) v1(42.62,41.43) v1(42.74,42.51) v2(38.24,40.67)
+5VS: length 550.7
  TOP w0.356: RS1.1 187.13,68.05 v1(187.27,67.91)
  TOP w0.381: PR5026.1 v1(180.54,140.75) ; 156.52,145.24 156.52,143.92 157.21,143.23 PR599.2
  TOP w0.508: v1(176.05,147.94) 174.41,146.31 173.71,146.31 173.3,145.89 173.3,143.61 173.63,143.27 PR5019.2 174.27,143.27 174.87,142.67 PR5030.1 ; v1(176.05,147.94) 180.89,147.94 v1(182.38,146.45) ; v1(176.05,147.94) 176.05,148.29 175.33,149.01 169.65,149.01 168.56,147.92 v1(167.7,147.92) ; v1(159.37,147.97) 160.21,147.97 161.19,148.94 167.09,148.94 167.7,148.33 v1(167.7,147.92) ; v1(159.37,147.97) 159.37,148.77 156.91,151.23 v1(151.69,151.23) ; v1(159.37,147.97) 158.19,146.78 157.73,146.78 156.52,145.57 156.52,145.24 ; v1(151.69,151.23) 151.15,151.77 146.03,151.77 145.43,151.17 143.4,151.17 v1(143.36,151.21) 143.36,151.2 141.47,149.32 140.98,149.32 140.66,149 140.66,146.92 141.05,146.53 PR5021.2 141.71,146.53 142.22,146.03 PR5031.1 ; v1(151.69,151.23) 151.46,151.23 150.05,149.83 149.61,149.83 148.98,149.19 148.98,146.91 149.33,146.56 PR5023.2 149.9,146.56 150.55,145.91 PR5032.1 ; PR5028.1 158.22,142.56 157.54,143.23 PR599.2 ; PR5029.1 165.92,142.56 PR5011.2 165.83,142.69 164.98,143.55 164.98,145.52 166.46,147 166.78,147 v1(167.7,147.92) ; PR505.1 126.55,135.29 126.04,135.8 126.04,136.24 v1(125.48,136.81) ; v1(223.43,168.36) 222.62,168.36 220.82,166.57 220.82,164.48 221.76,163.54 226.07,163.54 226.32,163.78 231.92,163.78 232.29,163.42 232.48,163.42 v1(232.55,163.35) ; v1(299.59,53.82) 299.21,53.44 PR6000.1
  TOP w1.016: 184.1,147.29 184.73,147.92 188.29,147.92 188.96,147.25 194.57,147.25 ; 289.57,72.71 288.51,71.66 283.16,71.66 280.87,69.37 280.87,65.6 279.11,63.84 ; 207.75,153.21 207.75,151.13 207.27,150.65 205.04,150.65 204.65,151.05 ; 193.62,12.03 192.86,11.27 187.59,11.27 183.14,15.72 175.77,15.72 172.47,12.42 172.47,6.2 170.95,4.68 163.26,4.68 162.82,5.11 161.17,5.11
  IN1 w0.508: v1(180.54,140.75) 181.56,141.76 181.56,145.32 182.38,146.14 v1(182.38,146.45)
  IN1 w2.286: 109.67,59.66 109.67,58.03 108.38,56.74 108.38,54.41 109.09,53.7 109.09,49.23 103.81,43.95 103.81,30.83 104.19,30.45
  IN2 w0.508: v1(143.36,151.21) 140.29,148.14 139.12,148.14 137.13,146.15 132.38,146.15 129.47,149.06 125.12,149.06 124.43,148.36 124.43,145.02 125.48,143.97 v1(125.48,136.81)
  IN2 w1.016: 185.84,69.02 184.73,70.14 184.73,72.6 185.05,72.92 185.05,83.03 184.03,84.04 181.17,84.04 178.01,87.21 178.01,92.5 181.75,96.23 181.75,98.33 180.16,99.92 180.16,117.82 181.56,119.22 181.56,123.29 182.89,124.62 183.97,124.62 188.6,129.25 188.6,142.65 184.86,146.4 184.29,146.4 ; v1(283.03,47.72) v1(284.49,47.72) 287.97,47.72 288.55,48.3 291.55,48.3 297.07,53.82 v1(299.59,53.82) 302.31,53.82 305.74,57.25 306.52,57.25
  IN3 w0.508: 187.68,68.33 187.68,72.97 188.38,73.66 188.38,84.58 192.09,88.3 198.32,88.3 v1(198.82,88.79) ; v1(280.01,62.5) 280.01,59.95 283.41,56.55 283.41,54.13 284.23,53.31 284.23,47.97 v1(284.49,47.72)
  IN3 w1.016: 222.6,168.01 218.14,168.01 217.7,168.46 212.07,168.46 211.18,167.57 211.18,167.06 210.03,165.9 210.03,159.51
  IN3 w1.524: 283.03,6.7 283.03,8.29 282.36,8.96 282.36,16.31 283.79,17.75 283.79,19.84
  IN3 w2.286: 106.11,25.49 110.16,21.43 126.37,21.43
  IN4 w1.016: 282.14,47.28 280.81,47.28 277.57,50.51 269.76,50.51 268.99,51.28 ; 189.05,64.48 189.05,63.88 182.57,57.4 182.57,51.81 183.26,51.13 183.26,43.84 180.78,41.36 180.54,41.36
  BOTTOM w0.203: v1(267.98,51.2) 268.22,51.2 268.6,51.58 PU6400.31 ; PU6301.7 222.7,58.51 222.52,58.69 v1(222.52,58.81) ; 266.84,53.55 266.97,53.68 PU6400.3 ; v1(231.21,57.82) 231.21,57.55 231.39,57.37 PU6202.7 ; PU6202.3 229.75,54.71 v1(229.62,54.58) ; PU6201.7 239.96,57.51 239.78,57.69 v1(239.78,57.82) ; PU6301.3 221.06,55.7 v1(220.93,55.57) ; PU6201.3 238.33,54.71 v1(238.2,54.58) ; v1(246.76,54.57) 246.89,54.7 PU6102.3 ; PU6400.7 268.6,56.48 268.42,56.66 v1(268.42,56.79) ; v1(248.35,57.81) 248.35,57.68 248.53,57.51 PU6102.7
  BOTTOM w0.356: CV23.1 232.55,163.73 v1(232.55,163.35)
  BOTTOM w0.381: v1(232.55,163.35) 232.55,162.97 232.16,162.59 231.82,162.59 231.7,162.72 UV3.16 ; UV22.16 197.85,88.82 CV484.1
  BOTTOM w0.508: PR6400.1 266,53.77 PC6401.1 ; PC6401.1 266.22,53.55 266.84,53.55 ; PC6401.1 266.01,51.85 266.52,51.34 267.84,51.34 v1(267.98,51.2) ; v1(159.37,147.97) 159.18,147.78 PR553.2 ; v1(280.01,62.5) 280.01,62.01 280.42,61.59 PR6085.1 ; JKB3.5 62.93,6.14 62.43,6.64 JKB3.6 62.43,9.31 62.18,9.56 ; v1(182.38,146.45) 182.69,146.14 PR5025.2 ; v1(198.82,88.79) CV484.1 ; PR5024.2 v1(151.69,151.23) ; PR5020.2 v1(176.05,147.94) ; PR5022.2 v1(143.36,151.21) ; PR5004.2 v1(167.7,147.92)
  vias: v1(30.65,38.16) v1(31.29,38.16) v1(32.52,49.75) v1(33.16,49.75) v1(44.27,49.37) v1(44.27,48.74) v1(59.27,9.31) v1(59.39,10.39) v1(59.65,9.82) v1(59.96,9.31) v1(60.03,10.39) v1(60.35,9.89) v1(60.66,10.39) v1(60.6,9.31) v1(60.98,9.89) v1(61.23,9.31) v1(61.3,10.39) v1(61.62,9.89) v1(91.17,8.3) v1(91.55,8.87) v1(91.55,7.73) v1(91.8,8.3) v1(92.18,8.87) v1(92.18,7.73) v1(92.44,8.3) v1(92.82,8.87) v1(92.82,7.73) v1(93.07,8.3) v1(93.45,8.87) v1(93.45,7.73) v1(105.23,26.89) v1(105.61,28.04) v1(105.61,27.4) v1(106.24,28.04) v1(106.24,27.4) v1(109.86,62.47) v1(109.86,61.83) v1(109.86,61.2) v1(110.5,61.83) v1(110.5,61.2) v1(129.02,20.82) v1(129.65,20.82) v1(130.29,20.82) v1(130.92,20.82) v1(131.56,20.82) v1(131.52,7.53) v1(132.22,7.53) v1(132.91,7.53) v1(133.61,7.53) v1(152.6,10.32) v1(152.6,9.68) v1(153.23,10.32) v1(153.23,9.68) v1(153.87,9.68) v1(162.32,6.51) v1(162.82,8.91) v1(179.27,41.69) v1(179.59,41.18) v1(183.27,146.46) v1(187.02,67.37) v1(210.8,159.26) v1(210.8,158.68) v1(222.12,53.66) v1(224.06,168.36) v1(230.7,53.05) v1(239.28,52.67) v1(247.28,52.99) v1(279.56,63.01) v1(282.01,5.47) v1(282.6,5.47) v1(283.22,5.49) v1(283.73,22.77) v1(283.73,22.13) v1(283.73,21.5) v1(306.33,57.94) v1(307.03,57.94) v4(207.91,157.07)
+5VS_TP_LED: length 113.6
  TOP w0.508: v1(188.4,12.53) 188.4,13.86 189.56,15.02 C2508.1 191.95,15.02 192.36,14.61 Q2409.4 ; v1(117.73,31.89) 117.56,32.06 R146.1 ; R154.1 v1(113.48,31.68) ; R144.1 v1(116.2,30.16) ; v1(108.91,31.81) 109.16,32.06 R147.1
  IN3 w0.508: v1(188.4,12.53) 189.66,11.27 195.29,11.27 v1(196.73,9.83) ; v1(116.2,30.16) 116.2,30.37 v1(117.73,31.89) ; v1(108.91,31.81) 113.35,31.81 v1(113.48,31.68)
  BOTTOM w0.508: v1(113.48,31.68) 113.48,30.92 114.25,30.16 v1(116.2,30.16) 116.65,29.71 127.62,29.71 128.91,28.42 179.19,28.42 184.78,22.83 185.83,22.83 186.96,21.7 186.96,13.96 v1(188.4,12.53)
  vias: v4(114.69,29.65)
+AVDDH: length 15.1
  TOP w0.508: CL6.1 CL5.1 237.3,156.66 v1(237.68,157.04)
  IN1 w0.508: v1(236.74,148.56) 237.39,149.22 237.39,150.89 236.86,151.42 236.86,156.29 237.62,157.04 v1(237.68,157.04)
  BOTTOM w0.203: CL7.1 237.49,149.5 UL1.22 ; v1(237.68,157.04) 237.68,156.69 237.49,156.5 UL1.9
  BOTTOM w0.508: CL7.1 237.25,149.5 236.74,148.99 v1(236.74,148.56)
+AVDDL: length 12.6
  TOP w0.508: v1(239.46,154.42) 239.18,154.15 CL24.1 ; CL19.1 CL18.1 236.41,157.11 v1(236.38,157.13) ; CL25.1 239.98,151.5 v1(239.45,152.02) ; v1(232.72,151.45) 232.85,151.33 CL21.1 CL23.1 ; CL22.1 232.7,152.85 v1(232.72,152.82) 232.8,152.75 CL20.1
  BOTTOM w0.102: v1(232.72,151.45) v2(232.11,151.45)
  BOTTOM w0.203: v1(236.38,157.13) 236.29,157.04 UL1.6 ; v1(232.72,151.45) 232.89,151.62 UL1.31 ; v1(239.45,152.02) UL1.19 ; v1(232.72,152.82) UL1.34 ; v1(239.46,154.42) UL1.13
+DVDDL: length 4.2
  TOP w0.508: CL43.1 233.36,155.15 233.35,155.14 233.35,154.22 CL44.1 233.17,154.02 v1(232.67,154.02)
  BOTTOM w0.102: v1(232.67,154.02) 232.54,154.02 v2(231.73,154.84)
  BOTTOM w0.203: v1(232.67,154.02) UL1.37
+PVDD: length 10.4
  TOP w0.203: UA4.37 30.04,9.21 29.6,9.66 ; v1(34.86,5.05) 34.65,5.25 UA4.51 ; v1(33.04,5.02) 33.45,5.43 UA4.48 ; CA54.1 37.99,4.97
  TOP w0.381: 29.6,9.69 29.6,9.66
  TOP w0.508: CA54.1 38.3,5.11 v1(38.3,5.62) ; v1(27.06,10.38) 27.1,10.34 CA62.1 CA63.1 28.94,10.34 29.6,9.69
  BOTTOM w0.508: CA52.1 38.3,6.76 38.57,7.03 v1(39.57,7.03) ; v1(27.06,10.38) 28.14,10.38 CA61.1
  vias: v1(28.58,4.03) v1(29.22,4.03) v1(31,5.56) v2(28.27,7.08)
+VCC_CORE: length 70.9
  TOP w0.254: v1(168.66,134.46) 168.2,134.46 PR569.2 167.99,134.29 PR571.1 PR570.1 ; v1(160.28,134.21) 160.23,134.16 PR559.2 PR560.1 158.67,133.25 PR561.1 ; PR581.1 PR580.1 176.05,134.16 PR579.2 176.61,134.16 v1(176.79,134.34)
  TOP w0.381: PC1213.1 157.85,101.6 v1(157.98,101.72)
  BOTTOM w0.203: CPU1.T37 v1(162.9,119.89) CPU1.T38 ; CPU1.AD31 v1(156.6,115.98) CPU1.AD32 ; CPU1.L14 166.57,102.05 v1(166.25,101.73) ; CPU1.AD14 156.7,102.05 v1(157.03,101.72) 156.7,101.4 CPU1.AD13 ; CPU1.R36 v1(163.69,119.23) CPU1.R37 ; CPU1.AC33 v1(157.39,116.63) CPU1.AC32 ; v1(157.39,115.34) CPU1.AB30 CPU1.AB29 157.76,114.31 ; v1(157.39,115.34) CPU1.AC31 ; v1(157.39,115.34) CPU1.AC30 CPU1.AC29 ; CPU1.AA33 v1(158.96,116.63) CPU1.AA32 ; v1(158.18,115.98) CPU1.AA31 ; v1(158.18,115.98) CPU1.AB32 ; v1(158.18,115.98) CPU1.AB31 ; CPU1.AD38 v1(156.6,119.89) CPU1.AD37 ; CPU1.K13 167.27,101.46 v1(167.22,101.51) ; CPU1.AE37 v1(155.81,119.23) CPU1.AE36 ; v1(162.11,115.34) CPU1.T30 ; v1(162.11,115.34) CPU1.U31 ; v1(162.11,115.34) CPU1.U30 CPU1.U29 ; v1(167.22,101.51) 167.33,101.62 CPU1.K14 ; v1(167.22,101.51) 167.1,101.4 CPU1.L13 ; CPU1.AD36 v1(156.6,118.58) ; v1(156.6,118.58) CPU1.AC36 ; v1(156.6,118.58) CPU1.AD35 ; CPU1.N14 164.7,102.05 v1(164.36,101.71) 164.67,101.4 CPU1.N13 ; v1(159.83,102.38) 160.16,102.05 CPU1.W14 CPU1.W13 ; v1(161.66,102.38) 161.32,102.05 CPU1.V14 CPU1.V13 ; CPU1.U33 v1(162.11,116.63) CPU1.U32 ; CPU1.V31 v1(161.32,115.98) CPU1.V32 ; CPU1.V33 v1(161.32,117.28) CPU1.V34 ; CPU1.Y30 CPU1.Y29 159.36,114.3 ; v1(157.98,101.72) 158.3,101.4 CPU1.AA13 ; v1(157.98,101.72) 157.65,102.05 CPU1.AC14 ; v1(157.98,101.72) 157.65,101.4 CPU1.AC13 ; CPU1.AA36 v1(158.96,119.23) CPU1.AA37 ; CPU1.AA34 v1(158.96,117.93) CPU1.AA35 ; v1(159.75,115.98) CPU1.Y32 ; v1(159.75,115.98) CPU1.W32 ; v1(159.75,115.98) CPU1.Y31 ; CPU1.P30 CPU1.P29 164.06,114.29 ; CPU1.U36 v1(162.11,119.23) ; v1(160.54,117.93) CPU1.W35 ; CPU1.AF35 v1(155.03,118.58) CPU1.AF36 ; v1(163.47,101.72) 163.79,102.05 CPU1.P14 ; v1(163.47,101.72) 163.79,101.4 CPU1.P13 ; v1(163.47,101.72) 163.14,101.4 CPU1.R13 ; CPU1.N36 v1(164.47,118.58) CPU1.N35 ; CPU1.V35 v1(161.32,118.58) CPU1.V36 ; CPU1.AB38 v1(158.18,119.89) CPU1.AB37 ; CPU1.AE14 155.83,102.05 v1(156.17,101.71) 155.86,101.4 CPU1.AE13 ; CPU1.AC34 v1(157.39,117.93) CPU1.AC35 ; CPU1.AD33 v1(156.6,117.28) CPU1.AD34 ; CPU1.T36 v1(162.9,118.58) CPU1.T35 ; CPU1.AE32 v1(155.03,115.98) ; CPU1.AB35 v1(158.18,118.58) CPU1.AB36 ; CPU1.W36 v1(160.54,119.23) CPU1.W37 ; v1(155.81,117.93) CPU1.AE35 ; CPU1.AF37 154.7,119.56 v1(155.03,119.89) 154.7,120.21 CPU1.AF38 ; CPU1.U35 v1(162.11,117.93) CPU1.U34 ; CPU1.Y36 v1(159.75,118.58) CPU1.Y35
  BOTTOM w0.254: PL501.1 161.48,135.41 v1(160.28,134.21) ; v1(168.66,134.46) 168.48,134.46 167.53,135.41 PL502.1 ; v1(176.79,134.34) 177.05,134.08 PL503.1 ; CPU1.T30 CPU1.T29
  BOTTOM w0.508: PC1004.1 175.52,128.43 v1(175.71,128.62) ; PC1003.1 v1(177.17,128.62) ; PC1006.1 v1(178.82,128.62)
  vias: v1(154.77,113.76) v1(155.02,108.49) v1(155.02,103.66) v1(155.21,121.12) v1(155.21,107.34) v1(155.21,106.14) v1(155.4,113.76) v1(155.4,110.39) v1(155.52,121.68) v1(155.65,108.49) v1(155.65,103.66) v1(155.85,121.12) v1(155.81,120.54) v1(156.15,121.68) v1(156.42,110.39) v1(156.47,122.33) v1(156.48,121.12) v1(156.79,122.89) v1(156.79,121.68) v1(157.12,123.41) v1(157.12,122.33) v1(157.12,121.12) v1(157.18,113.76) v1(157.42,122.89) v1(157.42,121.68) v1(157.43,108.49) v1(157.43,103.66) v1(157.56,107.34) v1(157.56,106.14) v1(157.75,123.41) v1(157.75,122.33) v1(157.75,121.12) v1(157.81,113.76) v1(158.06,122.89) v1(158.06,121.68) v1(158.07,108.49) v1(158.07,103.66) v1(158.39,123.41) v1(158.39,122.33) v1(158.39,121.12) v1(158.69,122.89) v1(158.69,121.68) v1(158.96,120.54) v1(159.02,123.41) v1(159.02,122.33) v1(159.02,121.12) v1(159.15,110.39) v1(159.33,129.51) v1(159.33,128.87) v1(159.33,122.89) v1(159.33,121.68) v1(159.66,123.41) v1(159.66,122.33) v1(159.66,121.12) v1(159.59,113.76) v1(159.76,117.27) v1(159.73,115.34) v1(159.85,108.49) v1(159.85,103.66) v1(159.97,129.51) v1(159.95,128.88) v1(159.96,122.89) v1(159.96,121.68) v1(159.91,107.34) v1(159.91,106.14) v1(160.16,110.39) v1(160.23,113.76) v1(160.29,123.41) v1(160.29,122.33) v1(160.29,121.12) v1(160.54,120.54) v1(160.48,108.49) v1(160.48,103.66) v1(160.6,129.51) v1(160.59,128.88) v1(160.6,122.89) v1(160.6,121.68) v1(160.93,123.41) v1(160.93,122.33) v1(160.93,121.12) v1(161.24,129.51) v1(161.22,128.88) v1(161.23,122.89) v1(161.23,121.68) v1(161.32,120.54) v1(161.32,119.89) v1(161.56,123.41) v1(161.56,122.33) v1(161.56,121.12) v1(161.86,128.88) v1(161.87,122.89) v1(161.87,121.68) v1(161.87,129.51) v1(162,113.76) v1(162.25,123.41) v1(162.18,122.31) v1(162.2,121.12) v1(162.26,108.49) v1(162.26,107.34) v1(162.26,106.14) v1(162.23,103.66) v1(162.51,129.51) v1(162.49,128.88) v1(162.5,121.68) v1(162.55,102.4) v1(162.63,122.9) v1(162.64,113.76) v1(162.64,110.39) v1(162.82,122.31) v1(162.83,121.12) v1(162.87,103.66) v1(162.9,120.54) v1(162.9,115.98) v1(162.89,108.49) v1(163.2,121.7) v1(163.46,122.33) v1(163.45,102.39) v1(163.52,121.13) v1(163.66,118.6) v1(163.69,117.93) v1(163.68,117.26) v1(163.69,116.63) v1(163.7,115.96) v1(163.84,121.7) v1(164.46,116.64) v1(164.49,119.24) v1(164.5,115.98) v1(164.61,103.66) v1(165.11,129.27) v1(165.17,128.62) v1(165.24,103.66) v1(165.74,129.27) v1(165.79,128.62) v1(165.81,104.49) v1(165.94,105.88) v1(166.38,129.27) v1(166.43,128.62) v1(166.68,128.05) v1(167.01,129.27) v1(167.06,128.62) v1(167.32,128.05) v1(167.71,129.25) v1(167.7,128.62) v1(167.95,128.05) v1(168.35,129.25) v1(168.33,128.62) v1(168.59,128.05) v1(168.97,128.62) v1(168.98,129.25) v1(171.65,128.81) v1(171.96,129.4) v1(171.96,128.23) v1(172.27,128.81) v1(172.6,129.4) v1(172.6,128.26) v1(172.91,128.81) v1(173.23,129.4) v1(173.23,128.26) v1(173.54,128.81) v1(173.87,129.4) v1(173.87,128.26) v1(174.18,128.81) v1(176.09,129.32) v1(176.33,128.68) v1(176.73,129.32) v1(177.36,129.32) v1(178,129.32) v1(178,128.68) v4(170.71,130.46)
+VCCGT: length 17
  TOP w0.254: PR598.1 151.38,137.49 PR597.2 151.98,137.49 v1(152.15,137.32) ; v1(143.96,137.58) 143.89,137.5 PR588.2 143.27,137.5 PR589.1
  BOTTOM w0.203: CPU1.AP14 148.66,102.33 149.01,102.33 CPU1.AN14 ; v1(145.18,102.37) 144.85,102.05 CPU1.AW14 ; v1(140.61,101.72) 140.28,102.05 CPU1.BD14 140.02,102.05 v1(139.69,102.37) 139.37,102.05 CPU1.BF14 ; v1(148.83,101.72) 148.51,101.4 CPU1.AP13 ; CPU1.BB14 141.83,102.05 v1(141.52,102.36) ; CPU1.AM14 150.07,102.05 v1(149.75,101.72) 149.42,101.4 CPU1.AN13
  BOTTOM w0.254: v1(133.82,118.74) 133.98,118.9 CPU1.BN36 ; v1(143.96,137.58) 143.71,137.32 PL505.1 ; 152.15,134.65 v1(152.15,137.32)
  BOTTOM w0.508: v1(151.38,121.86) 151.4,121.88 RH203.1
  vias: v1(133.42,123.45) v1(133.42,121.49) v1(133.71,122.84) v1(133.9,122.13) v1(134,123.45) v1(134,121.49) v1(134.29,122.84) v1(134.48,122.13) v1(134.59,123.45) v1(134.59,121.49) v1(134.88,122.84) v1(135.07,122.13) v1(135.17,123.45) v1(135.17,121.49) v1(135.46,122.84) v1(135.65,122.13) v1(135.75,123.45) v1(135.75,121.49) v1(136.05,122.84) v1(136.24,122.13) v1(136.39,121.57) v1(136.67,123.51) v1(136.96,122.9) v1(136.92,120.56) v1(137.03,121.57) v1(137.15,122.19) v1(137.25,123.51) v1(137.36,121) v1(137.54,122.9) v1(137.66,121.57) v1(137.61,106.34) v1(137.73,122.19) v1(137.7,119.89) v1(137.7,118.58) v1(137.7,117.93) v1(137.7,115.98) v1(137.84,123.51) v1(138.13,122.9) v1(138.21,113.34) v1(138.32,122.19) v1(138.3,121.57) v1(138.42,123.51) v1(138.49,117.93) v1(138.49,116.63) v1(138.49,115.34) v1(138.71,122.9) v1(138.76,109.82) v1(138.9,122.19) v1(138.93,121.57) v1(139,123.51) v1(139.14,107.73) v1(139.14,104) v1(139.3,122.9) v1(139.28,119.89) v1(139.28,118.58) v1(139.28,115.98) v1(139.49,122.19) v1(139.57,121.57) v1(139.65,123.48) v1(139.84,104) v1(139.91,122.95) v1(140.06,120.54) v1(140.06,119.23) v1(140.06,117.93) v1(140.06,116.63) v1(140.09,122.27) v1(140.07,121.12) v1(140.16,106.01) v1(140.16,104.74) v1(140.29,113.33) v1(140.39,121.63) v1(140.49,122.95) v1(140.72,122.27) v1(140.71,121.12) v1(140.85,118.58) v1(140.85,117.28) v1(140.85,115.98) v1(140.85,115.34) v1(141.03,121.63) v1(140.99,113.33) v1(141.05,109.82) v1(141.34,121.12) v1(141.49,107.73) v1(141.66,121.63) v1(141.64,120.54) v1(141.64,119.23) v1(141.62,104) v1(141.98,121.12) v1(142.26,104) v1(142.3,121.63) v1(142.43,119.89) v1(142.43,118.58) v1(142.43,117.28) v1(142.43,115.98) v1(142.45,106.07) v1(142.45,104.8) v1(142.4,102.38) v1(142.42,101.77) v1(142.61,121.12) v1(142.76,113.33) v1(142.93,121.63) v1(143.08,122.24) v1(143.25,121.12) v1(143.21,117.93) v1(143.21,116.63) v1(143.21,115.34) v1(143.46,113.33) v1(143.4,109.82) v1(143.57,121.63) v1(143.67,122.24) v1(143.78,107.73) v1(143.88,121.12) v1(144,119.89) v1(144,118.58) v1(144,115.98) v1(144.03,104) v1(144.25,122.24) v1(144.2,121.63) v1(144.52,121.12) v1(144.67,106.07) v1(144.67,104.8) v1(144.83,122.24) v1(144.84,121.63) v1(144.79,120.54) v1(144.79,119.23) v1(144.79,117.93) v1(144.79,116.63) v1(144.86,104) v1(145.15,121.12) v1(145.24,113.33) v1(145.18,101.72) v1(145.42,122.24) v1(145.47,121.63) v1(145.58,118.58) v1(145.58,117.28) v1(145.58,115.98) v1(145.59,115.35) v1(145.79,121.12) v1(145.81,109.82) v1(145.88,113.33) v1(146,122.24) v1(146.11,121.62) v1(146.19,107.73) v1(146.27,134.54) v1(146.27,133.9) v1(146.36,120.54) v1(146.36,119.23) v1(146.42,121.12) v1(146.59,122.88) v1(146.59,122.24) v1(146.64,104) v1(146.77,121.6) v1(146.91,134.54) v1(146.91,133.9) v1(147.06,121.11) v1(147.02,106.07) v1(147.02,104.8) v1(147.15,119.89) v1(147.15,118.58) v1(147.15,117.28) v1(147.15,115.98) v1(147.2,132.05) v1(147.2,131.41) v1(147.2,130.78) v1(147.2,130.14) v1(147.17,123.51) v1(147.17,122.88) v1(147.17,122.24) v1(147.27,104.04) v1(147.41,121.6) v1(147.54,134.54) v1(147.54,133.9) v1(147.76,123.51) v1(147.76,122.88) v1(147.76,122.24) v1(147.72,121.1) v1(147.72,113.34) v1(147.84,132.05) v1(147.84,131.41) v1(147.84,130.78) v1(147.84,130.14) v1(147.94,117.93) v1(147.94,116.63) v1(147.94,115.34) v1(148.05,121.6) v1(148.18,134.54) v1(148.18,133.9) v1(148.34,123.51) v1(148.34,122.88) v1(148.34,122.24) v1(148.37,121.1) v1(148.29,109.82) v1(148.42,113.38) v1(148.47,132.05) v1(148.47,131.41) v1(148.47,130.78) v1(148.47,130.14) v1(148.54,107.73) v1(148.73,119.89) v1(148.73,118.58) v1(148.73,115.98) v1(148.98,123.48) v1(148.98,122.84) v1(148.98,122.21) v1(149.08,104.04) v1(149.37,106.07) v1(149.37,104.8) v1(149.51,120.54) v1(149.51,119.23) v1(149.51,117.93) v1(149.51,116.63) v1(149.5,116) v1(149.69,104.04) v1(149.79,102.38) v1(150.16,113.38) v1(150.19,111.73) v1(150.3,120.54) v1(150.3,118.58) v1(150.3,115.98) v1(150.77,113.38) v1(150.83,111.73) v1(151.09,119.89) v1(151.09,119.23) v1(151.09,117.93) v1(151.09,116.63) v1(151.27,110.39) v1(151.27,109.06) v1(151.27,107.79) v1(151.46,104.04) v1(151.59,106.01) v1(151.59,104.74) v1(151.88,118.58) v1(151.88,117.28) v1(151.88,115.98) v1(152.66,117.93) v1(152.66,116.63) v1(152.66,115.34) v1(152.61,113.38) v1(153.35,132.05) v1(153.35,131.41) v1(153.35,130.78) v1(153.35,130.14) v1(153.98,132.05) v1(153.98,131.41) v1(153.98,130.78) v1(153.98,130.14) v4(142.03,127.3)
+VCCIO: length 52.3
  IN3 w0.508: v1(169.49,88.3) 167.59,86.39 162.57,86.39 158.5,90.46 158.5,96.55 157.3,97.76 157.3,98.52 155.35,100.47 155.05,100.47 154.43,101.1 v1(154.32,101.1) ; v1(177.37,120.68) 176.03,120.68 173.87,118.52 173.05,118.52 171.9,117.38 171.01,117.38 169.03,115.39 169.02,115.4 168.54,115.4 168.09,114.95 168.09,112.36
  BOTTOM w0.203: v1(154.32,101.1) 154.19,101.07 CPU1.AG12
  BOTTOM w0.254: v1(168.76,106.99) 168.4,107.35 CPU1.H20 ; v1(168.76,104.56) 168.76,104.67 CPU1.G17 ; CPU1.G19 169.08,106.54 v1(169.42,106.2)
  BOTTOM w0.305: CPU1.J21 CPU1.H21 CPU1.G21 ; CPU1.H20 CPU1.J20 ; CPU1.H19 CPU1.J19 ; CPU1.H17 CPU1.J17
  BOTTOM w0.508: v1(169.49,88.3) 170.95,89.76 RC2.1 ; v1(177.37,120.68) 177.37,124.54 RC30.2
  vias: v1(121.03,101.1) v1(121.03,100.46) v1(121.03,99.88) v1(121.66,101.1) v1(121.66,100.46) v1(121.66,99.88) v1(122.3,101.1) v1(122.3,100.46) v1(122.3,99.88) v1(122.93,101.1) v1(122.93,100.46) v1(167.28,112.46) v1(167.28,107.68) v1(167.28,106.9) v1(167.28,104.62) v4(168.6,108.79)
+VCCIOP: length 24.2
  IN4 w0.254: v1(123.96,103.35) 123.45,103.85 123.45,114.01 124.53,115.09 124.53,116.55 123.77,117.32 123.77,120.3 122.04,122.03 122.04,124.14 v1(122.01,124.17)
  BOTTOM w0.254: v1(122.01,124.17) PC818.1 122.04,123.37 PR5014.1
  vias: v2(122.75,107.73)
+VCCSA: length 4.4
  BOTTOM w0.254: PL508.2 184.3,132.31 PR5027.2
  BOTTOM w0.508: RH201.2 174.51,123.47 v1(174.07,123.03)
  vias: v1(165.6,111.51) v1(165.6,110.94) v1(166.06,119.92) v1(166.06,119.22) v1(166.05,118.58) v1(166.06,117.95) v1(166.05,117.28) v1(166.06,116.62) v1(166.07,122.63) v1(166.13,122.01) v1(166.13,121.38) v1(166.12,120.81) v1(166.67,122.62) v1(166.82,119.92) v1(166.84,119.23) v1(166.87,117.94) v1(166.84,116.63) v1(166.84,115.98) v1(166.89,118.59) v1(167.62,116.63) v1(180.97,129.72) v1(180.97,129.09) v1(180.97,128.39) v1(180.97,127.76) v1(180.97,127.17) v1(181.61,129.72) v1(181.61,129.09) v1(181.61,128.39) v1(181.61,127.76) v1(181.61,127.17) v1(182.24,129.72) v1(182.24,129.09) v1(182.25,128.42) v1(182.25,127.78) v1(182.83,129.72) v1(182.83,129.09) v1(182.84,128.42) v1(182.84,127.78) v1(183.41,129.72) v1(183.41,129.09) v1(183.42,128.42) v1(183.42,127.78) v4(180.41,129.09)
+VCCST: length 125.9
  TOP w0.381: v1(166.05,115.98) 166.2,115.83 CH109.1 ; RH164.1 174.26,98.64 v1(173.63,98.01) ; CH108.1 168.46,114.51 v1(168.78,114.83)
  TOP w0.508: v1(126.08,118.81) 126.4,118.81 127.58,117.63 127.58,115.41 128.11,114.88 v1(128.33,114.88) ; v1(167.35,113.27) 167.4,113.21 CH107.1 167.98,112.76 167.9,112.68 CH110.1 ; PC502.1 PR501.1 PR502.1 PR503.1 v1(127.39,132.87) ; RH163.1 167.94,114.76 CH108.1
  IN2 w0.508: v1(130.63,121.95) 130.63,121.4 132.66,119.37 132.66,117.34 133,116.99 133,115.58 133.99,114.59 135.84,114.59 136.28,114.14 136.28,111.16 136.72,110.71 136.72,106.31 133.99,103.58 133.99,100.68 134.57,100.11 134.57,99.07 133.32,97.82 133.32,92.83 131.01,90.52 131.01,86.52 134.25,83.28 170.19,83.28 172.86,85.95 172.86,89.25
  IN4 w0.508: v1(127.39,132.87) 127.39,124.97 128.98,123.38 128.98,122.68 129.71,121.95 v1(130.63,121.95)
  BOTTOM w0.203: v1(168.78,114.83) 168.78,114.84 CPU1.H30 ; CPU1.H28 CPU1.J28 v1(167.35,113.27)
  BOTTOM w0.508: v1(128.33,114.88) RH156.1 ; RH151.1 v1(126.08,118.81) 126.08,120.52 126.47,120.91 RH152.1 126.73,121.17 127.52,121.95 v1(130.63,121.95)
  vias: v1(173.18,92.74) v1(173.56,92.29) v1(173.94,91.85) v1(174.45,91.47) v1(174.9,91.02) v4(175.87,82.52)
+VCCSTG: length 168.6
  TOP w0.381: CH105.1 172.6,113.4 CH106.1
  TOP w0.508: 184.3,84.5 185.62,83.18 185.62,76.8 184.29,75.47 182.64,75.47 182.06,74.9 182.06,74.26 180.98,73.18 177.3,73.18 176.41,72.3 176.41,68.17 177.49,67.09 v1(177.49,64.93)
  TOP w2.54: 180.41,114.01 180.41,106.06 182.76,103.71 182.76,97.38 187.45,92.7 187.45,87.65 184.3,84.5 181.66,84.5 181.55,84.39
  IN1 w0.508: v1(168.38,115.97) 168.38,115.58 168.02,115.22 168.02,114.62 168.6,114.03 v1(168.8,114.03)
  IN2 w0.508: v1(177.49,64.93) 176,66.42 138.97,66.42 126.11,79.28 126.11,93.58 125.14,94.55 125.14,101.16 127.22,103.24 127.22,105.85 128.65,107.27 128.65,111.7 127.54,112.81 v1(126.25,112.81)
  IN4 w0.508: v1(126.25,112.81) 126.88,113.44 126.88,115.6 126.37,116.11 v1(126.12,116.11)
  BOTTOM w0.203: CPU1.G30 168.38,115.93 v1(168.38,115.97)
  BOTTOM w0.254: CPU1.H29 168.43,114.4 v1(168.8,114.03)
  BOTTOM w0.508: RH165.1 126.59,115.83 126.31,116.11 v1(126.12,116.11)
  vias: v4(172.49,115.42)
+VDD_MEM15_REFDA: length 4.5
  TOP w0.089: v1(233.22,106.85) 233.32,106.85 v2(233.69,107.22)
  TOP w0.508: RG64.2 231.45,106.73 231.9,106.28 RG69.1 CG134.1 232.77,106.4 v1(233.22,106.85)
  BOTTOM w0.4: v1(233.22,106.85) 233.37,106.85 UG1.P25
+VDD_MEM15_REFDB: length 5.1
  TOP w0.089: v2(238.83,108.81) 238.83,107.91 238.62,107.69 CG132.1
  TOP w0.381: RG67.1 240.07,106.1 RG62.2 239.73,106.34 v1(239.22,106.85) 238.82,107.25 CG132.1
  BOTTOM w0.3: UG1.P20 239.07,106.85 v1(239.22,106.85)
+VDD_MEM15_REFDC: length 4.3
  TOP w0.089: RG86.1 246.14,100.4 v2(246.38,100.63)
  TOP w0.381: RG86.1 245.48,100.59 v1(245.07,101) 245.41,101.34 RG83.2 245.4,101.59 CG136.1
  BOTTOM w0.3: UG1.Y14 245.07,100.85 v1(245.07,101)
+VDD_MEM15_REFDD: length 7.9
  TOP w0.089: v2(246.35,94.38) 245.69,94.38 v1(245.07,95)
  TOP w0.381: RG87.1 244.58,92 RG84.2 245.58,92.13 245.58,92.81 245.28,93.11 244.72,93.11 243.98,93.84
  TOP w0.4: v1(245.07,95) 245.07,94.94 CG137.1 243.98,93.84
  BOTTOM w0.4: v1(245.07,95) 245.07,95.15 UG1.AE14
+VDD_TOUCH:
  vias: v1(167.39,181.86) v1(167.46,181.26) v1(168.16,181.26) v1(168.6,172.12) v1(168.6,171.53) v1(169.12,171.82) v4(167.98,182.05)
+VDDCI: length 61.4
  TOP w0.254: v1(235.66,90.58) 235.61,90.58 235.35,90.84 PR6067.1
  TOP w0.381: v1(235.62,106.85) 235.23,107.24 CG57.1
  IN4 w0.254: v1(241.32,92.1) UG1.AJ18 236.67,91.6 v1(235.66,90.58)
  IN4 w0.508: v1(243.36,96.06) 243.4,96.1 243.77,96.1 v1(245.07,97.4)
  BOTTOM w0.381: v1(230.29,102.19) 230.29,102.17 230.26,102.2 230.22,102.2 UG1.V29
  BOTTOM w0.4: v1(245.07,97.4) 245.07,97.55 UG1.AC14 ; v1(235.62,106.85) 235.77,106.85 UG1.P23 ; v1(245.07,99.8) 245.07,99.65 UG1.AA14 ; UG1.P21 237.87,106.85 v1(238.02,106.85)
  BOTTOM w0.5: UG1.AH17 v1(241.32,92.1) UG1.AJ18 ; UG1.AH17 v1(242.32,93.1) UG1.AG16 v1(243.32,93.1) UG1.AH15 ; UG1.AH17 v1(242.32,92.1) UG1.AJ16 ; UG1.U28 v1(231.32,104.1) UG1.T27 v1(231.32,105.1) UG1.R28 ; UG1.U28 v1(230.32,104.1) UG1.T29 ; UG1.U28 UG1.V29 ; 243.34,102.08 UG1.W15 v1(243.32,101.1) UG1.Y15 ; 243.34,102.08 v1(243.35,102.08) ; 243.34,102.08 243.34,102.12 UG1.V15 ; UG1.P23 UG1.P21 ; UG1.T15 243.39,104.17 v1(243.35,104.17) ; 234.31,105.11 v1(234.31,105.13) ; 234.31,105.11 234.33,105.11 UG1.R24 ; 234.31,105.11 UG1.R25 v1(233.32,105.1) UG1.R26 ; UG1.R16 v1(242.32,105.1) ; UG1.AD15 243.36,96.14 v1(243.36,96.06) UG1.AE15 v1(243.32,95.1) UG1.AF15 ; UG1.R20 v1(239.32,105.1) UG1.R19 240.23,105.19 v1(240.36,105.19) 240.41,105.19 UG1.R18 ; UG1.AA14 UG1.AC14
  BOTTOM w0.508: RG514.1 263.36,47.24 263.86,47.75 263.86,62.31 264.51,62.96
  vias: v1(236.8,84.8) v1(236.8,84.11) v1(238.03,87.24) v1(238.02,83.95) v1(238.01,82.14) v1(238.01,81.25) v1(238.01,80.36) v1(238.01,79.41) v1(239.22,82.15) v1(239.22,81.25) v1(239.22,80.35) v1(239.22,79.45) v1(240.42,86.39) v1(240.42,83.95) v1(240.42,83.05) v1(240.42,81.25) v1(240.42,80.35) v1(240.42,79.45) v1(241.62,84.75) v1(241.62,82.15) v1(241.62,80.35) v1(264.54,63.97) v1(264.85,63.48) v1(265.12,67.98) v1(265.17,63.97) v1(265.49,63.48) v1(265.81,63.97) v1(266.12,63.48) v1(266.44,63.97) v1(266.76,63.48) v1(267.08,63.97) v1(267.39,63.48) v1(267.6,67.98) v1(267.71,63.97) v1(268.03,63.48) v1(268.13,64.51) v1(268.35,63.97) v1(268.66,63.48) v1(268.72,64.51) v1(268.98,63.97) v1(269.3,64.51) v1(269.3,63.48) v1(269.62,63.97) v1(269.88,64.51) v1(269.93,63.48) v1(270.01,67.98) v1(270.25,63.97) v1(270.47,64.51) v1(270.57,63.48) v1(270.89,63.97) v1(271.2,63.48) v1(271.52,63.97) v1(272.42,67.98) v2(247.6,77.38)
+VDDCT_L: length 2.9
  BOTTOM w0.508: v1(241.12,162.72) 241.12,162.64 241.63,162.13 TL1.10 ; TL1.9 241.75,160.86 v1(241.06,160.17)
  vias: v1(243.53,153.7) v1(243.98,154.08) v2(242.01,157.32)
GND: length 7528.7
  TOP w0.102: v1(183.74,170.53) UT1.A18 UT1.B18 ; v4(203.21,168.12) 203.21,168.37 v1(203.53,168.69) ; v1(11.69,61.35) 11.85,61.35 12.14,61.06 v4(12.33,61.06) ; v1(181.59,170.53) 181.59,170.37 181.9,170.06 UT1.A14 UT1.B14 ; v4(193.49,172.8) 193.49,172.79 v1(192.88,172.79) ; v1(182.62,170.54) 182.62,170.32 182.82,170.11 UT1.A16 UT1.B16 ; v1(184.79,170.59) 184.77,170.59 184.66,170.48 UT1.A20 UT1.B20 ; v1(243.79,145.67) v4(244.58,145.67)
  TOP w0.107: v1(165.62,181.36) 165.62,181.51 v2(164.8,182.33) ; v1(166.23,181.35) v2(166.23,182.3)
  TOP w0.127: v1(158.62,181.21) 158.62,181.49 158.96,181.83 v2(158.96,182.15)
  TOP w0.178: UT1.B12 UT1.A12 v1(180.98,170.38) ; v1(175.39,164.34) 175.39,164.21 175.74,163.86 UT1.P1 UT1.P2 ; UT1.AB2 UT1.AB1 175.79,160.18 175.61,160 175.61,159.54 v1(175.36,159.29) ; UT1.T1 UT1.T2 ; UT1.M2 UT1.M1 ; UT1.J22 UT1.J23 186.68,166.16 v1(186.76,166.25) ; UT1.W22 UT1.W23 ; UT1.AB20 UT1.AC20 184.66,159.32 185.07,158.91 v1(185.07,158.66) ; v1(179.77,159) 179.77,159.1 179.95,159.27 179.95,159.35 180.05,159.46 180.05,159.5 180.06,159.51 UT1.AC10 UT1.AB10 ; UT1.C23 UT1.C22 ; UT1.AB18 UT1.AC18 183.74,159.15 v1(183.84,159.05) ; UT1.AB12 UT1.AC12 180.98,159.41 180.79,159.23 180.79,159.06 180.78,159.05 v1(180.78,159.03) ; v1(186.57,165.23) 186.56,165.24 UT1.L23 UT1.L22 ; UT1.AC2 UT1.AC1 175.92,159.22 v1(175.38,158.68) ; UT1.B6 UT1.A6 ; v1(186.81,168.39) 186.81,168.38 186.43,168 UT1.E23 UT1.E22 ; UT1.B22 UT1.A22 185.58,169.98 185.88,170.28 v1(186.06,170.28) ; UT1.G22 UT1.G23 186.94,167.08 v1(187.07,167.22) ; v1(182.89,159.04) 182.82,159.1 UT1.AC16 UT1.AB16 ; UT1.AB14 UT1.AC14 181.9,159.11 v1(181.82,159.03) ; UT1.AB8 UT1.AC8 ; UT1.K2 UT1.K1 ; UT1.H2 UT1.H1 ; v1(178.96,170.4) 179.14,170.22 UT1.A8 UT1.B8 ; v1(186.48,160.47) 186.31,160.64 UT1.AA23 UT1.AA22 ; UT1.AC6 UT1.AB6 ; v1(186.54,163.31) 186.45,163.4 186.04,163.4 UT1.R23 UT1.R22 ; UT1.AB22 UT1.AC22 185.58,159.63 v1(185.97,159.24) ; UT1.N23 UT1.N22 ; v1(179.97,170.4) 180.06,170.31 UT1.A10 UT1.B10 ; UT1.U23 UT1.U22
  TOP w0.203: UT1.AB10 180.06,160.5 UT1.Y9 ; UT1.E4 176.75,168.37 176.75,168.82 176.94,169.01 177.4,169.01 UT1.D5 ; UE5.11 301.54,22.78 301.75,22.57 301.75,21.46 v1(301.74,21.44) ; UT1.AB6 178.22,160.23 178.49,160.5 178.82,160.5 UT1.AB8 179.14,160.34 UT1.Y9 ; UA4.4 38.27,8.41 38.65,8.8 v1(39.06,8.8) ; UT1.Y9 179.57,160.99 179.57,161.43 UT1.W9 179.56,161.65 179.56,162.06 UT1.V9 ; UE3.7 217.31,158.33 v1(217.07,158.08) ; v1(305.93,16.67) 305.94,16.66 305.94,16.49 306.21,16.21 UE5.113 ; v1(29.53,8.45) 30.47,8.45 UA4.39 ; v1(305,9.41) 304.74,9.14 UE5.94 ; PU8200.10 279.55,158.42 279.76,158.63 v1(279.76,158.88) ; v1(290.06,21.3) 290.17,21.41 UE5.35 ; v1(175.4,165.2) 175.4,165.32 175.77,165.7 UT1.K1 ; UE5.24 296.34,22.54 v1(296.55,22.32) ; v1(278.9,155.48) 278.66,155.48 278.44,155.7 PU8200.5
  TOP w0.229: DT6.2 v1(197.28,174.12) ; DT7.2 v1(194.72,174.12)
  TOP w0.254: v1(220.37,105.8) 220.05,105.48 RG155.2 ; v1(171.08,163.48) 171.15,163.56 RT36.2 ; v1(194.26,176.63) 194.28,176.6 194.34,176.6 194.7,176.24 DT13.2 ; v1(242.82,106.85) 243.27,106.4 RG61.1 ; v1(246.67,97.4) 246.08,96.81 CG65.2 ; v1(324.56,19.85) 324.56,20.03 324.88,20.36 JIO.22 ; CG28.2 222.97,93.26 v1(222.97,93.8) ; v1(220.1,103.41) 220.1,102.9 220.35,102.65 RG147.2 ; CE62.2 305.19,50.08 UE10.23 ; v1(232.32,102.1) 232.63,101.79 CG117.2 ; CG67.2 238.62,92.58 238.8,92.4 238.8,92.01 238.81,92 CG115.2 ; v1(155.62,179.37) JEDP.9 ; CG19.2 v1(232.01,89.52) ; DT11.2 191.65,173.72 191.95,173.42 192.25,173.42 v1(192.88,172.79) ; CG123.2 235.12,94.9 v1(235.32,95.1) ; JUSBC2.B1 5.79,57.68 5.78,57.67 ; v1(244.83,107.08) 244.85,107.11 244.85,107.47 CG44.2 ; JUSBC2.A1 v1(8.37,62.92) ; v1(220.06,155.09) 219.81,154.84 UE3.23 ; CG98.2 241.61,100.39 v1(241.32,100.1) ; CG100.2 225.44,105.8 v1(225.37,105.8) ; v1(223.77,99.8) 223.55,99.58 CG23.2 ; RT37.2 v1(170.49,165.49) RT17.2 ; v1(117.12,153.87) 117.47,153.87 JPCMC.19 ; JUSBC2.B12 6.27,63.17 6.45,63.35 6.45,64.2 JUSBC2.5 ; v1(246.67,103.4) 246.07,102.8 CG60.2 ; v1(223.77,97.4) 223.62,97.25 CG22.2 ; v1(223.77,93.8) 223.62,93.95 CG21.2 ; UE6.12 334.17,43.95 334.65,43.47 v1(334.78,43.47) ; v1(249.87,104.6) 249.27,104 CG62.2 ; UE4.7 184.55,18.69 v1(184.35,18.89) ; v1(223.77,95) 223.62,95.15 CG25.2 ; v1(324.62,23.36) 324.63,23.36 JIO.28 ; v1(191.54,21.11) 191.53,21.11 191.44,21.19 UE4.23 ; v1(154.12,179.37) JEDP.6 ; v1(196.9,176.82) DT12.2 ; v1(226.97,103.4) 226.97,103.17 CG58.2 ; UE4.18 189.74,18.69 189.49,18.45 v1(189.35,18.45) ; JEDP.29 v1(165.62,181.36) ; RU2.1 19.87,44.83 UU1.14 ; v1(324.62,14.85) 324.62,14.61 324.88,14.36 JIO.10 ; RG403.2 230.68,85.41 v1(230.77,85.5) ; RG148.2 220.6,101.23 v1(220.37,101) ; v1(166.23,181.35) 166.12,181.25 JEDP.30 ; DU13.3 11.36,58.76 v1(11.38,58.77) ; CG52.2 248.81,92.25 248.46,92.6 v1(248.27,92.6) ; CG118.2 232.63,102.79 v1(232.32,103.1) ; v1(133.98,106.73) 133.84,106.59 RH186.2 ; v1(157.12,179.37) JEDP.12 ; CG63.2 247.67,105.2 v1(248.27,105.8) ; v1(214.56,24.97) 214.56,24.65 214.12,24.22 UH3.3 ; DU12.3 9.16,63.39 v1(9.03,63.26) ; v1(190,177.01) 188.63,177.01 188.16,176.54 DT14.2 ; RT34.2 172.38,162.11 v1(172.35,162.08) ; v1(236.32,93.1) 236.65,92.77 CG104.2 236.86,92.37 236.86,91.92 237.02,91.76 CG68.2 ; RG154.2 218.72,104.75 v1(218.57,104.6) ; v1(311.22,52.29) 311.01,52.08 UE10.12 ; JIO.13 324.89,15.85 324.62,16.13 v1(324.62,16.35) ; v1(234.42,90.25) 233.91,89.74 CG50.2 ; UE3.18 217.31,154.84 v1(217.07,155.09) ; RG26.2 232.62,89.05 CG20.2 232.3,89.03 v1(232.02,88.75) ; v1(158.62,181.21) JEDP.15 ; v1(324.62,21.67) 324.8,21.85 JIO.25 ; v1(152.62,179.37) JEDP.3
  TOP w0.279: JUSBC2.A12 8.36,57.42 v1(8.53,57.26) ; 5.78,57.67 5.66,57.55 v1(5.66,57.16)
  TOP w0.3: v1(243.07,136.4) 243.56,135.91 RG102.2
  TOP w0.305: US1.10 v1(183.9,72.85) ; RG69.2 230.99,105.77 v1(230.32,105.1) ; RE527.2 230.55,30.35 230.27,30.62 QE53.4 ; CG199.2 235.92,132.4 v1(235.87,132.4) ; US1.15 180.98,70.58 180.92,70.52 179.84,70.52 179.38,70.97 CS7.2 ; CG190.2 234.92,134.15 v1(235.07,134) ; RE523.2 230.55,20.63 230.27,20.91 QE52.4 ; CA66.1 27.87,8.22 28.32,8.68 29.15,8.68 29.38,8.45 v1(29.53,8.45) ; v1(239.87,132.4) 239.69,132.58 CG192.2 ; U16.5 v1(315.84,50.52) ; US1.5 184.4,68.72 184.54,68.58 v1(184.98,68.58) ; U20.5 182.52,81.49 181.94,82.07 C10.2 ; US1.16 181.28,70.08 180.77,69.56 179.99,69.56 CS2.2 ; RE519.2 230.55,27.11 230.27,27.39 QE51.4 ; v1(194.26,176.63) 194.26,177.26 194.1,177.42 CT96.2 ; CG211.2 247.15,133.68 v1(247.47,134) ; RE512.2 230.55,23.87 230.27,24.15 QE49.4 ; US1.13 182.4,72.52 v1(182.74,72.87) 182.9,72.71 US1.12 ; U19.5 178.9,81.58 179.08,81.76 C6.2
  TOP w0.356: CT56.2 186.59,158.51 v1(186.39,158.71) ; RT18.2 176.84,156.67 v1(176.79,156.62) ; RT11.2 RT38.2 v1(171.52,158.63) ; PQ710.1 120.58,78.55 120.79,78.77 PR730.1 ; v1(233.02,26.3) 233.02,25.76 RE509.2 ; RV8.2 169.39,160.05 169.77,159.67 169.77,158.69 v1(169.98,158.48) ; RV1.2 167.52,159.02 v1(167.94,158.61) ; RG144.2 226.03,87.81 v1(226.02,87.8) ; RG401.2 214.86,101.8 v1(213.85,102.8) ; RT35.2 RT41.2 170.04,163.47 v1(170.49,163.47) ; RE497.2 v1(233.05,32.75) ; RE504.2 v1(233.05,29.51)
  TOP w0.381: CA58.2 36.9,16.54 37.28,16.92 v1(37.28,16.99) ; CG102.2 244.42,105.66 v1(244.42,105.78) ; RH24.2 209.33,25.05 v1(209.36,25.08) ; PC1028.2 141.88,108.3 v1(141.49,108.3) ; v1(155.21,106.71) 154.77,106.71 PC1023.2 ; CH70.2 210.51,26.7 v1(210.27,26.46) ; CG101.2 230.22,107.45 v1(230.82,106.85) ; v1(162.26,107.92) 162.7,107.92 PC1026.2 ; RG8.2 216.75,113.39 RG60.1 217.04,113.63 v1(217.67,113) ; v1(162.55,100.46) 162.54,100.47 PC1097.2 ; CG87.2 227.57,98 v1(226.97,98.6) 226.97,99.15 CG29.2 227.9,99.49 CG95.2 ; CG121.2 236.61,103.39 v1(236.32,103.1) ; CG55.2 229.49,106.72 v1(229.62,106.85) ; v1(189.05,158.66) 188.7,159 CT70.2 ; v1(232.32,101.1) 231.43,101.1 CG82.2 ; CG151.2 218.58,141.3 v1(219.47,140.4) ; v1(148.54,108.3) 148.92,108.3 PC1032.2 ; CG105.2 243,93.78 v1(243.32,94.1) 243.07,94.35 CG64.2 ; 223.66,20.61 223.5,20.76 RE515.2 223.3,20.76 v1(222.77,20.23) ; CG27.2 223.49,91.68 v1(223.77,91.4) ; CG106.2 227.24,94.73 v1(226.97,95) ; v1(204.35,165.32) 203.88,165.79 CT113.2 ; v1(233.47,140.4) 233.09,140.78 CG195.2 ; v1(278.12,125.41) 278.5,125.8 CG242.2 ; v1(241.62,88.75) 241.01,88.75 CG122.2 ; v1(222.67,139.6) 222.68,139.59 CG152.2 ; v1(36.3,26.85) 36.54,26.85 37.54,27.85 CA11.2 ; CG99.2 227.78,107.81 v1(228.42,108.45) ; CH201.2 216.42,23.4 v1(216.38,23.44) ; CG92.2 243.57,105.35 v1(243.32,105.1) ; CG231.2 276.61,125.51 v1(276.52,125.41) ; QE48.1 236.29,24.15 236.5,23.93 RE508.2 236.74,23.64 v1(236.44,23.34) ; v1(232.32,94.1) 232.06,93.84 CG74.2 ; CG188.2 238.47,142.48 v1(238.58,142.59) ; CG91.2 243.06,92.36 v1(243.32,92.1) 243.44,91.98 CG96.2 ; v1(237.05,29.75) 237.05,30.03 RE496.2 236.43,30.35 236.16,30.62 QE46.1 ; v1(239.87,139.6) 239.07,138.8 RG103.2 ; CG172.2 229.25,134.18 v1(229.07,134) ; v1(226.97,92.6) 226.75,92.38 CG26.2 ; PC6534.2 242.44,102.22 v1(243.32,103.1) 243.92,102.5 CG136.2 ; RT47.2 RT4.2 173.51,165.09 v1(173.61,165.18) ; CG79.2 228.8,103.16 v1(228.57,103.4) ; v1(230.83,19.97) RE523.2 ; CG51.2 228.13,90.96 v1(228.57,91.4) 228.19,91.78 CG78.2 ; RE504.2 233.5,28.96 233.78,28.69 QE47.4 ; PC1025.2 159.46,107.92 v1(159.91,107.92) ; v1(224.15,135.83) CG176.2 ; CG166.2 223.74,133.78 v1(224.16,134.21) ; v1(256.15,92) 255.43,92.71 CG135.2 ; CG46.2 CG56.2 228.65,104.68 v1(228.57,104.6) ; RG67.2 241.68,106.79 v1(241.62,106.85) ; PC1029.2 139.53,108.3 v1(139.14,108.3) ; v1(123.71,78.53) 124.09,78.53 124.28,78.72 UC1.3 ; CG69.2 245.24,88.77 v1(245.22,88.75) ; v1(159.91,106.71) 159.46,106.71 PC1024.2 ; v1(208.67,135.6) 208.67,135.52 209.48,134.72 CG163.2 ; CG94.2 228.57,100.64 v1(228.57,101) ; v1(236.67,143.6) 235.95,142.88 CG203.2 ; v1(207.87,133.2) 208.5,133.2 CG174.2 ; v1(253.32,142.69) CG210.2 ; RA74.2 37.09,1.99 v1(37.09,2.25) ; CG24.2 223.55,89.98 v1(223.77,90.2) ; v1(226.97,96.2) 227.29,96.52 CG107.2 ; CG33.2 234.42,87.95 v1(234.42,87.95) 234.47,87.9 234.83,87.9 235.02,87.71 CG111.2 ; v1(203.62,165.24) 203.57,165.2 CT112.2 ; PQ710.4 120.91,77.25 120.58,77.59 120.58,78.55 ; CG90.2 247.6,106.87 v1(247.47,107) ; CG93.2 234.83,101.59 v1(235.32,101.1) ; CG212.2 247.32,142.65 v1(247.47,142.8) ; v1(225.87,132.4) 225.74,132.53 CG167.2 ; v1(238.32,105.13) 238.32,105.1 238.62,105.4 CG132.2 ; RG43.2 244.72,104.6 v1(245.07,104.6) ; v1(247.47,108.2) 247.47,108.69 CG54.2 ; v1(161.65,101.7) 161.71,101.76 PC1162.2 ; CH4.2 215.18,32.12 v1(215.39,31.92) ; v1(236.32,105.1) 236.24,105.1 CG97.2 ; RG79.1 244.83,106.68 v1(244.83,107.08) ; CG278.2 v1(279.17,93.97) ; v1(231.32,96.1) 231.23,96.01 230.2,96.01 PC6526.2 ; CG70.2 243.1,99.32 v1(243.32,99.1) ; CG285.2 278.78,89.27 v1(278.92,89.41) ; CG61.2 226.97,106.55 v1(226.97,107) ; v1(155.21,107.92) 154.77,107.92 PC1022.2 ; v1(226.02,87.8) 226.56,87.26 CG30.2 ; CT101.2 199.16,164.18 v1(199.23,164.1) ; v1(249.87,92.6) 249.87,92.26 RG85.1 ; CG76.2 245.05,96.22 v1(245.07,96.2) 245.55,95.72 CG53.2 ; v1(224.15,137.18) 223.91,136.95 RG91.2 ; CG109.2 236.97,108.07 237.35,108.45 v1(238.02,108.45) ; CG75.2 235.07,93.85 235.28,94.06 v1(235.28,94.11) ; v1(162.26,106.71) 162.7,106.71 PC1027.2 ; v1(131.72,111.98) 132.03,111.66 RH184.2 ; CG88.2 248.27,90.88 v1(248.27,91.4) ; v1(159.78,101.72) 159.75,101.7 PC1099.2 ; v1(279.79,91.09) 279.73,91.09 279.08,91.74 CG284.2 ; v1(249.07,141.2) 249.25,141.02 CG208.2 ; CH106.2 171.99,112.49 v1(172.01,112.51) 172.04,112.48 CH105.2 ; CG86.2 227.58,93.19 v1(226.97,93.8) ; v1(199.13,163.53) 198.68,163.53 198.45,163.29 RT83.1 ; RT62.2 198.26,160.03 197.87,159.64 v1(197.67,159.64) ; CG89.2 254.32,110.45 v1(254.17,110.6) ; CG287.2 v1(281.52,93.38) ; v1(155.65,48.55) 155.66,48.54 RD30.2 ; v1(157.56,106.71) 158,106.71 PC1021.2 ; CG297.2 278.75,75.24 v1(278.92,75.41) ; v1(212.99,110.33) 213.94,111.28 RG396.2 ; v1(245.07,91.4) 244.65,90.98 RG87.2 ; PC6527.2 235.3,100.08 v1(235.32,100.1) ; QE46.4 233.78,31.92 233.5,32.2 RE497.2 ; v1(219.47,144.4) 218.94,144.4 CG171.2 ; v1(230.83,23.27) RE512.2 ; v1(195.24,19.37) 195.24,19.37 195.44,19.57 Q2410.3 ; v1(229.69,87.25) 229.69,87.22 229.86,87.05 CG18.2 ; v1(252.5,144.22) CG217.2 ; CG194.2 243.4,134 v1(243.07,134) ; CG220.2 253.82,132.45 v1(253.87,132.4) ; CH193.2 176.44,98.6 v1(176.44,99.15) ; PC1020.2 158,107.92 v1(157.56,107.92) ; PC1134.2 165.2,101.12 CH127.2 165.25,100.48 v1(165.3,100.43) ; v1(235.32,102.1) 234.82,102.6 CG84.2 ; RV10.2 v1(162.24,181.49) ; v1(237.02,26.45) 237.02,26.79 236.74,27.07 RE501.2 236.43,27.11 236.16,27.39 QE47.1 ; v1(35.82,16.99) 35.82,16.56 36.01,16.37 CA59.2 ; CG254.2 278.87,105.65 v1(278.9,105.68) 279.41,106.19 CG250.2 ; QE48.4 233.78,25.45 233.5,25.72 RE509.2 ; CH110.2 168.81,113.13 CH107.2 ; PQ202.3 101.59,53.34 v1(101.96,52.97) ; v1(146.08,101.11) 146.02,101.17 CH118.2 ; CG59.2 228.57,105.74 v1(228.57,105.8) ; v1(246.67,99.8) 246.67,99.11 246.29,98.73 CG80.2 ; CG134.2 233.68,106.11 v1(234.42,106.85) 234.61,106.66 CG57.2 ; CG110.2 235.77,104.55 v1(235.32,104.1) ; v1(232.32,95.1) 232.06,94.84 CG83.2 ; CH124.2 144.37,101.21 v1(144.27,101.11) ; PC1213.2 157.27,100.66 v1(157.06,100.46) ; CT102.2 195.27,168.05 v1(195.21,167.99) ; RA79.2 RA78.2 v1(31.56,16.86) ; CG157.2 v1(209.97,139.68) ; v1(235.87,141.2) 235.95,141.12 CG202.2 ; v1(217.32,41.61) 217.52,41.81 CH53.2 ; v1(241.62,90.8) 241.35,90.53 CG108.2 ; v1(143.78,108.3) 144.22,108.3 PC1031.2 ; v1(146.19,108.3) 146.57,108.3 PC1030.2 ; RG68.1 252.37,111.59 v1(252.37,111.8) ; RU25.2 306.96,58.57 v1(306.16,58.57) ; v1(230.83,29.75) RE527.2 ; CG137.2 244.23,92.93 244.55,92.62 245.06,92.62 v1(245.07,92.6) ; CA256.2 v1(34.49,1.45) ; CU29.2 30.83,46.03 30.83,45.38 30.56,45.11 UU5.3 ; v1(273.19,114.97) RG117.2 ; v1(230.83,26.51) RE519.2 ; CG145.2 230.46,138.03
  TOP w0.406: v1(17.66,38.49) DU2.3 ; UX1.3 224.57,160.84 v1(224.88,160.53)
  TOP w0.432: v1(118.16,30.32) Q28.1 ; v1(227.58,26.29) 228.02,25.85 QE49.1 ; v1(323.94,45.65) QE4.1 ; Q29.4 115.26,32.6 v1(115.71,32.16) ; Q28.4 119.46,31.91 v1(119.9,31.46) ; v1(323.39,38.91) 323.42,38.91 323.42,38.91 323.84,38.91 323.97,39.04 323.97,39.13 QE1.4 ; Q7.4 v1(319.89,43.76) ; v1(203.24,172.69) 203.24,172.69 QE13.1 ; QE21.1 200.76,172.73 v1(200.8,172.69) ; v1(322.08,42.86) 322.27,42.86 322.5,43.09 QE4.4 ; Q9.1 327.81,41.05 327.87,40.99 327.87,40.1 v1(327.87,40.1) ; QE50.4 224.57,20.61 223.66,20.61 ; v1(107.3,31.81) Q34.1 ; v1(327.05,44.61) 326.86,44.61 QE3.1 ; QE50.1 v1(225.94,23.27) ; Q34.4 108.6,32.62 108.15,32.17 v1(108.15,31.81) ; Q8.1 v1(322.54,40.37) ; Q7.1 v1(321.19,44.34) ; Q9.4 326.42,39.49 327.04,40.11 v1(327.29,40.11) ; v1(227.58,29.53) 228.02,29.09 QE51.1 ; QE53.1 228.62,31.92 228.75,32.05 v1(229.02,32.05) ; Q8.4 v1(321.24,39.83) ; Q29.1 113.96,31.25 114.17,31.45 v1(114.17,31.64) ; v1(227.58,22.92) 227.72,22.79 227.72,22.38 227.9,22.21 QE52.1 ; v1(324.62,43.34) 324.87,43.09 QE3.4 ; v1(205.94,172.74) 205.94,172.75 205.71,172.98 QE22.1 ; v1(324.74,41.75) 324.81,41.75 325.25,41.32 QE1.1
  TOP w0.457: UE1.3 315.4,8.18 315.66,7.92 CE57.2 ; v1(280.52,97.41) 280.52,97.47 280.12,97.87 CG275.2 ; CH187.2 217.77,38.68 v1(217.83,38.63)
  TOP w0.5: PC6525.2 v1(232.43,98.09) ; v1(235.32,96.96) 235.32,96.98 234.92,97.38 PC6518.2
  TOP w0.508: CG303.2 283.03,82.04 v1(283.03,81.21) 282.69,80.87 RG132.2 ; v1(35.19,16.99) 35.12,16.92 CA60.2 RA77.2 ; v1(190,177.01) 190,177.64 CT95.1 ; C622.2 v1(333.38,49.94) ; v1(157.06,100.46) 156.95,100.57 CH125.2 ; R180.2 192.08,18.27 C2509.2 191.56,17.75 v1(191.46,17.75) 191.46,17.3 191.08,16.93 C2508.2 ; v1(178.25,56.55) 177.68,55.98 RD29.2 ; JIO.33 v1(327.15,6.75) ; CU47.2 v1(17.74,47.34) ; PC511.2 130.37,136.63 131.26,137.53 v1(131.26,138.27) ; CG177.2 225.79,135.68 v1(225.87,135.6) ; v1(194.08,163.77) 194.18,163.67 CT88.2 ; CG238.2 280.34,127.26 RG121.2 278.94,127.26 v1(278.79,127.41) ; CD82.2 171.97,43.47 v1(172.16,43.28) ; RU2.1 18.19,45.29 v4(18.18,45.28) 18.14,45.28 v1(17.73,45.69) ; RA76.2 30.16,2.25 CA257.2 29.4,2.43 v1(29.28,2.32) ; v1(197.52,63.89) 197.04,64.36 C268.2 ; CE82.2 142.68,162.9 v1(142.31,162.53) ; v1(130.16,58.69) 130.13,58.72 CD78.2 ; PC587.2 183.14,137.38 PC583.2 ; CG261.2 278.85,103.35 v1(278.92,103.41) ; RG118.2 276.01,107.13 v1(275.9,107.23) ; v1(193.67,165.22) 194.14,165.69 YT1.4 ; JLOGO.18 237.92,168.43 v1(237.24,168.43) ; JFAN2.4 287.12,76.12 v1(287.33,75.9) ; v1(288.87,75.37) 288.51,75.01 CF5.2 ; CG154.2 230.48,144.47 v1(230.96,144.94) ; RA6.2 30.74,33.43 v1(31,33.18) ; PD2.1 83.4,12.02 83.7,11.72 v4(85.54,11.72) 86.05,11.21 v1(86.05,9.87) ; CD86.2 150.95,39.86 v1(150.49,40.32) ; v1(68.88,5.84) PC12.2 ; v1(243.85,159.86) 243.15,160.56 CL35.2 CL32.1 ; v1(76.79,9.67) 76.14,9.02 PQ8.3 ; CH120.2 173.2,99.09 v1(173.55,99.44) ; CN25.2 314.11,37.23 v1(313.97,37.09) ; C2512.2 314.4,50.26 v1(314.27,50.39) ; v1(310.65,14.26) 310.48,14.26 CE40.1 ; v1(264.87,52.74) 264.68,52.93 264.68,56.67 263.53,57.82 PC6400.1 ; v1(169.42,112.45) 169.28,112.31 CH110.2 ; v1(233.22,82.15) 232.66,82.15 CG43.2 CG42.2 ; C638.2 278.52,6.57 278.14,6.95 v1(277.88,6.95) 278.46,7.53 C637.2 ; v1(280.68,113.51) CG244.2 CG236.2 ; v1(233.32,104.1) 233.34,104.12 CG81.2 ; RA82.2 27.43,12.41 v1(27.06,12.41) ; v1(161.64,163.29) 162.06,163.29 162.7,163.93 DV2.1 ; v1(280.55,106.39) 280.49,106.46 CG247.2 ; CT94.1 194.9,181.02 195.46,181.58 196.98,181.58 v1(196.99,181.58) ; v1(250.72,132.43) 250.82,132.53 CG221.2 ; v1(243.91,154.78) 243.59,154.78 243.47,154.65 CL37.2 CL36.1 ; v1(229.29,64.55) 229.29,64.1 PC6530.2 ; DV4.1 166.63,164.19 167.29,163.53 v1(167.29,163.53) ; PC8211.2 v1(279.47,154.64) ; v1(127.64,155.72) 127.53,155.84 RC35.2 ; U18.2 200.27,63.09 v1(200.23,63.13) ; CG286.2 277.28,94.25 v1(277.32,94.21) 277.39,94.15 RG133.2 ; CD74.2 168.49,51.39 v1(169.46,50.42) ; v1(214.32,170.47) 213.82,169.96 JPWR.7 ; CE80.2 143.34,165.89 v1(143.63,165.89) ; CD76.2 134.85,52.26 v1(134.11,53) ; RE29.2 RE30.2 v1(182.95,20.42) ; v1(224.88,157.41) 224.28,156.81 RE31.2 ; v1(255.02,80.4) 254.3,79.68 PC6505.2 ; CH126.2 167.84,97.69 v1(167.91,97.76) ; 140.66,46.39 141.55,46.39 142.26,45.68 142.26,43.57 v1(142.15,43.46) ; CH173.2 CH80.2 210.95,29.06 210.33,29.67 v1(210.33,29.74) ; CD83.2 121.12,48.56 v1(121.04,48.48) ; v1(301.44,28.67) 301.44,27.91 CE36.2 301.24,27.71 CE34.2 CE45.2 ; PC6506.2 252.57,78.49 251.62,79.45 v1(251.22,79.45) 250.45,78.68 PC6507.2 ; CG229.2 RG129.2 275.12,100.02 v1(274.9,100.24) ; JFAN1.6 100.27,70.32 v1(100.47,70.52) ; PC217.2 103.37,51.1 v1(103.82,50.65) ; PR711.2 60.14,17.51 v1(60.7,16.95) ; CH200.2 213,21.47 v1(213.28,21.18) ; v1(310.7,17.83) 310.6,17.73 CE43.2 ; JPWR.8 213.82,166.93 v1(214.28,167.39) ; v1(307.6,9.05) 307.6,9.05 CE51.2 ; PQ8202.3 281.77,150.55 PC8222.2 v1(282.53,150.5) ; YT1.2 191.87,168.05 v1(190.83,168.05) ; CD5.2 150.01,58.12 150.65,57.48 v1(150.91,57.48) ; CN9.2 314.33,43.28 v1(314.02,43.59) ; v1(316.79,5.54) CE3.2 ; v1(152.85,57.74) 152.99,57.74 153.5,58.24 153.5,59.11 CD70.2 ; v1(229.07,136.4) 229.09,136.42 CG160.2 ; v1(211.87,135.6) 211.86,135.59 RG90.2 ; v1(4.33,29.43) 4.89,30 JUSB1.13 ; CL39.2 CL38.1 v1(243.91,153.07) ; v1(33.93,20.16) 34.25,20.48 RA16.2 ; RH90.1 211.1,36.34 v1(211.09,36.33) 211.08,36.34 CH174.2 ; RM31.2 v1(309.55,39.97) ; CU29.2 v1(30.62,47.09) ; v1(324.43,11.65) 324.05,12.03 CE18.2 CE17.2 323.66,12.93 CE16.2 ; v1(241.43,145.66) CG204.2 ; CV375.2 v1(169.22,182.73) ; v1(236.32,101.1) 236.34,101.12 PC6510.2 ; RA22.2 34.43,35.68 v1(34.93,35.19) ; v1(301.8,42.82) CM12.2 ; RV24.2 191.13,108.71 v1(191.13,107.22) ; v1(127.71,157.64) 127.47,157.88 RC348.2 RH497.1 ; v1(155.34,36.88) 155.35,36.89 RH212.2 RH210.2 ; v1(147.01,43.91) 147.77,44.67 CD85.2 ; v1(156.66,37.71) 156.23,38.14 RD40.2 ; JLOGO.17 220.62,169.69 v1(220.29,170.02) ; JEDP.43 148.52,178.14 v1(149.36,178.98) ; v1(128.34,154.66) 128.09,154.4 CM31.2 ; v1(158.8,37.71) 158.8,37.79 CD80.2 ; RA80.2 26.49,15.08 v1(26.3,14.89) ; v1(213.3,31.11) 212.98,30.8 CH186.2 ; PC308.2 248.67,26 v1(248.17,26) ; v1(247.11,16.34) 247.15,16.39 PR303.1 ; v1(137.41,50.51) 137.43,50.53 CD69.2 ; v1(190.38,171.04) 189.92,170.58 CT37.2 ; CG161.2 206.07,145.13 205.47,144.53 v1(205.47,144.4) ; CA63.2 CA62.2 v1(26.98,9.42) ; v1(331.99,37.81) 331.49,38.31 CE55.1 ; CH103.2 167.62,106.19 v1(167.21,105.78) ; CD10.2 v1(181.17,62.92) ; CD73.2 141.52,52.61 141.54,52.63 143.22,52.63 v1(144.04,53.45) ; v1(77.37,9.39) PR28.1 ; v1(61.67,31.21) 62.12,30.76 PR700.1 ; v1(205.79,9.3) 206.79,10.3 JWDB.6 ; v1(310.63,19.27) 310.4,19.51 CE38.2 ; v1(275.88,70.88) RG143.2 CG271.2 ; v1(203.4,23.85) 202.95,23.4 CH3.2 ; PC6524.2 248.61,63.97 v1(248.61,64.48) ; CG187.2 233.29,138.98 v1(233.47,138.8) ; v1(317.74,5.54) CE4.1 ; v1(231.86,141.66) RG93.2 ; v1(277.32,91.01) 277.24,91.1 CG282.2 ; JWDB.4 v1(203.09,11.46) ; v1(282.12,97.41) 281.9,97.64 CG279.2 ; CG133.2 255.91,108.8 v1(256.17,108.8) ; v1(126.3,74.97) CH197.2 ; C618.2 C617.2 332.57,47.2 v1(331.97,47.8) ; v1(162.92,45.82) 163.21,46.11 CD20.2 ; v1(221.75,29.9) 221.29,30.36 RH135.1 ; RE650.2 292.83,44.67 v1(292.96,44.8) ; v1(239.91,142.02) 239.91,141.94 239.4,141.43 CG193.2 ; v1(206.74,34.85) 206.69,34.9 206.33,34.9 CH188.2 ; RG131.2 276.4,87.81 v1(276.52,87.81) 276.49,87.78 276.49,86.44 CG283.2 ; v1(253.87,135.6) 253.37,135.6 RG106.2 ; CH102.2 169.37,103.77 v1(169.41,103.81) ; CS7.2 v1(178.51,71.09) ; CH189.2 210.94,38.69 v1(211.25,38.38) ; CD72.2 152.17,52.63 152.88,53.35 152.88,53.41 v1(153.01,53.53) ; CD22.2 114.79,38.5 v1(115.58,37.72) ; v1(150.41,43.75) 149.73,44.43 CD24.2 ; v1(31.71,35.08) 32.2,35.58 CA8.2 ; v1(300.72,42.26) CM13.2 ; CH183.2 202.76,25.99 v1(202.86,25.89) ; CG159.2 211.51,133.56 v1(211.87,133.2) ; CG249.2 v1(282.88,112.24) ; PC6519.2 231.09,64.1 v1(231.09,64.55) ; CA85.2 35.83,24.07 v1(36.22,23.68) ; v1(204.38,33.44) 204.06,33.76 CH82.2 ; C266.2 202.82,60.03 C2522.2 201.6,59.54 v1(201.91,59.23) 202.14,59 C267.2 ; JIO.31 v1(324.59,8.96) ; CD7.2 139.47,58.72 v1(137.53,58.72) ; CE29.2 297,26.82 v1(296.51,27.31) ; v1(236.16,167.42) 236.92,166.66 JLOGO.16 ; v1(279.03,113.51) 278.66,113.87 CG239.2 CG240.2 ; CA40.2 36.96,33.51 v1(36.65,33.81) ; CD8.2 139.47,52.82 139.22,53.06 139.22,53.91 139.7,54.38 v1(139.85,54.38) ; CD25.2 154.33,46.34 v1(154.78,45.9) ; RE66.1 287.52,8.43 v1(287.41,8.54) ; v1(293.11,27.1) CE44.2 RE75.2 ; v1(233.47,142.8) 233.29,142.62 RG105.2 ; 230.46,138.03 RG101.2 v1(231.92,138.03) ; 139.26,46.39 139.26,45.64 139.11,45.49 v1(139.11,44.56) ; JTOBII.8 159.86,167.57 159.3,168.13 v1(158.84,168.13) ; RH199.2 216.8,20.8 v1(216.97,20.62) ; CD28.2 v1(182.4,49.39) ; RA9.2 36.6,26.55 v1(36.3,26.85) ; PR306.2 251.85,16.66 v1(251.53,16.34) ; RH209.2 CD18.2 RH211.2 153.91,53.57 v1(153.48,53.99) ; C624.2 274.19,18.69 v4(273.79,18.29) v1(273.29,17.79) ; CA7.2 31.82,36.94 v1(31.29,36.94) ; v1(323.29,17.77) 323.67,17.39 CE13.2 323.67,15.58 CE14.2 ; C2518.2 128.24,98.62 v1(127.96,98.9) ; CG147.2 211.82,131.65 v1(211.87,131.6) ; v1(32.64,37.4) 32.03,38 CA9.2 31.96,38.84 CA10.2 ; CD91.2 138.31,49.49 138.01,49.18 v1(137.42,49.18) ; CH190.2 206.33,18.68 206.8,19.14 v1(206.8,19.69) ; v1(209.32,170.25) JPWR.10 ; v1(178.57,83.22) 178.57,83.22 179.08,82.71 C6.2 ; v1(52.19,24.69) PC718.1 52.96,23.81 PC720.1 ; CD71.2 150.01,52.31 v1(148.8,52.31) ; v1(315.66,6.7) CE57.2 ; v1(127.01,12.49) 126.87,12.63 CS16.2 ; v1(181.1,68.92) 181.11,68.92 181.11,68.93 180.76,68.93 180.45,68.93 CS2.2 ; v1(126.37,8.6) CS6.2 ; DA8.1 49.14,7.54 49.54,7.14 v1(49.54,6.38) ; v1(181.17,62.07) 180.81,61.71 CD9.2 ; v1(181.17,60.63) CD3.2 CD4.2 ; v1(235.07,5.04) C639.2 C640.2 ; v1(187.54,25.58) RE37.2 RE27.2 ; JEDP.42 v1(172.02,178.82) ; v1(235.07,141.2) 235.03,141.16 CG200.2 ; v1(289.54,6.92) 289.1,7.36 CE28.2 ; CE25.2 188.74,24.98 188.23,25.49 v1(188.22,25.49) ; C269.2 196.96,60.67 C270.2 195.59,61.16 v1(195.27,60.84) ; RA7.2 v1(17.24,1.8) ; C2513.2 v1(313.72,47.97) ; CG197.2 CG201.2 243.19,141.32 v1(243.07,141.2) ; v1(276.9,113.33) 276.9,113.85 CG243.2 ; RH455.1 220.94,20.17 220.19,19.43 v1(220.19,18.61) ; JFAN2.6 285.34,82.18 v1(285.45,82.29) ; v1(119.86,58.67) 119.53,59 CD79.2 ; v1(213.29,24.85) 213.1,25.03 CH176.2 ; CE81.2 153.39,164.13 154.13,164.87 154.13,164.92 154.56,165.36 JTOBII.1 154.56,166.49 v1(154.24,166.81) ; PC8205.2 v1(280.48,160.69) ; CH180.2 198.64,29.45 198.62,29.46 v1(198.62,29.95) ; CD31.2 182.2,46.21 v1(182.36,46.37) ; CU18.2 11.67,61.37 v1(11.69,61.35) ; v1(173.3,182.15) 173.43,182.28 CV14.2 ; v1(236.36,146.73) CG183.2 RG111.2 ; CE79.2 146.45,166.52 146.45,165.06 v1(146.94,164.57) 146.97,164.54 UE12.2 ; v1(183.12,82.12) 182.88,82.37 C10.2 ; CL31.2 260.74,165.39 260.99,165.13 v1(260.99,165.07) ; JLOGO.15 235.92,165.38 v1(236.16,165.13) ; CD1.2 173.12,59.29 172.54,58.71 v1(172.34,58.71) ; RX4.2 222.22,160.97 v1(222.09,161.09) ; v1(232.36,97.14) 232.36,97.06 232.57,96.85 PC6512.2 ; v1(140.4,140.69) 140.92,140.69 PR572.1 ; CG165.2 221.55,145.6 v1(221.62,145.53) ; v1(165.74,161.86) 166.29,161.86 CV374.2 ; CA38.2 37.35,37.94 v1(37.47,37.81) ; v1(215.07,142.8) 215.15,142.73 CG150.2 ; v1(211.22,144.27) CG179.2 ; v1(327.11,43.11) 327.11,42.66 326.77,42.31 CE56.2 ; v1(212.17,37.28) 212.67,36.79 RH88.1 ; DA7.1 v1(47.59,11.54) ; v1(240.93,164.31) 241.49,164.87 CL27.2 ; v1(27.05,13.06) RA81.2 ; CH52.2 217.1,30.83 v1(217.24,30.98) ; v1(273.02,23.56) 273.37,23.21 C620.2 C627.2 ; CG263.2 278.87,107.88 278.71,107.73 v1(278.71,107.72) ; JFAN2.5 294.37,82.18 v1(294.79,81.76) ; v1(230.96,151.81) 230.5,152.27 CL22.2 ; v1(304.73,25.26) 304.73,26.46 304.37,26.82 CE41.2 CE30.2 ; v1(29.6,42.64) 29.03,42.64 28.93,42.74 CU26.2 ; v1(151.58,101.1) 151.36,101.1 151.19,100.92 CH119.2 ; v1(318.69,5.54) CE1.2 ; PC549.1 171.26,147.11 171.67,146.7 v1(171.67,145.96) ; v1(227.47,64.55) 227.47,64.1 PC6529.2 ; v1(124.79,53.61) 124.92,53.47 CD75.2 ; PR730.1 120.79,80.74 121.21,81.15 121.96,81.15 v1(122.12,81.31) ; v1(27,5.87) 27,5.62 CA55.2 ; v1(31.9,46.45) CU28.2 ; v1(230.86,86.89) 231.21,86.53 CG35.2 ; CG173.2 215.22,144.55 v1(215.07,144.4) ; CG156.2 215.18,141.2 v1(215.07,141.2) ; v1(322.63,5.54) CE6.2 ; v1(238.17,64.42) 238.17,63.97 PC6521.2 ; v1(175.73,37.7) 175.62,37.59 175.62,36.26 176.04,35.83 RD38.2 RD39.2 ; v1(292.96,41.8) 292.91,41.86 QE5.3 ; v1(302.88,42.26) CM10.2 ; CG255.2 278.91,109.82 v1(278.92,109.81) ; v1(313.64,21.24) 313.64,20.92 CE58.2 ; v1(100.64,22.09) 100.82,22.09 CE64.2 ; v1(317.23,42.38) CM15.2 ; v1(279.47,151.99) 279.22,151.73 PR8216.2 ; v1(224.53,141.93) CG170.2 ; PC502.2 v1(123.37,133.79) ; v1(274.12,91.01) 274.12,91.39 274.65,91.92 CG272.2 ; v1(278.92,111.41) 278.92,111.42 278.32,112.02 CG257.2 ; RG134.2 279.45,70.24 v1(279.22,70.01) 280.22,70.01 280.42,70.21 CG292.2 ; CA254.2 38.46,4.13 39.02,4.69 39.02,4.92 CA54.2 39.26,4.97 v1(39.95,4.29) 39.95,5.61 39.44,6.12 CA53.2 ; v1(25.6,14.83) 25.54,14.89 RA4.2 ; v1(286.08,11.08) 286.08,10.2 LE2.1 ; C635.2 v1(334.34,49.94) ; v1(273.25,20.35) 273.31,20.42 C625.2 C628.2 ; v1(199.14,169.13) 199.14,168.75 199.4,168.49 RT108.2 ; JPWR.6 212.82,170.06 v1(212.31,170.57) ; v1(163.37,58.8) 164.09,59.52 CD2.2 ; CE15.2 324.44,14.67 v1(324.62,14.85) ; PC6523.2 246.78,63.97 v1(246.78,64.48) ; CD6.2 144.09,59.17 145.14,58.12 v1(145.62,58.12) ; RG46.2 v1(234.93,77.07) ; JTOBII.5 157.76,164.32 v1(157.79,164.28) ; PC724.2 117.73,80.35 v4(118.79,81.41) 119.39,82.01 122.06,82.01 v1(122.12,81.95) ; PC513.2 120.66,140.05 v1(119.77,140.94) ; v1(225.19,154.69) 224.51,154.69 CE24.2 ; PC6001.1 v1(293.76,47.91) ; JTOBII.7 153.69,167.48 154.52,167.48 v1(154.76,167.25) ; v1(248.11,16.34) 248.1,16.35 PC300.2 ; PC8218.2 v1(279.73,162.27) ; v1(215.07,134) 215.22,134.15 CG155.2 ; CD77.2 157.94,50.78 158.12,50.6 v1(158.12,50.55) ; v1(217.5,17.53) 217.3,17.33 216.88,17.33 216.37,16.82 CH192.2 ; CE63.1 v1(307.79,45.76) ; v1(233.24,84.48) 233.24,84.67 CG32.2 ; v1(125.48,8.6) CS5.2 ; v1(18.87,40.93) 18.96,40.93 19.46,41.43 CU7.2 19.41,41.65 RU3.1 ; C2514.2 v1(320.34,55.21) ; v1(104.24,56.13) PC218.2 103.99,55.35 PQ202.6 ; v1(236.34,64.42) 236.34,63.97 PC6520.2 ; v1(55.94,15.46) 56.37,15.89 PC721.2 56.6,15.91 PC716.1 ; v1(16.79,29.92) RA1.2 ; v1(153.41,101.06) 153.23,101.23 CH122.2 ; CD19.2 130.19,46.44 v1(130.82,45.82) ; CL34.1 CL33.2 v1(243.74,162.59) ; CG252.2 282,100.16 282.36,100.52 282.36,101.58 v1(282.12,101.81) ; RG88.2 215.1,136.38 v1(215.07,136.4) ; CD81.2 v1(168.42,40.4) ; v1(71.83,7.34) PQ4.3 ; v1(38.87,34.56) 38.73,34.42 CA39.2 ; RE645.1 311.84,24.21 312.24,24.61 v1(312.24,25.43) ; CG169.2 225.88,142.01 v1(225.87,142) ; v1(239.87,144.4) 239.49,144.4 239.4,144.3 239.39,144.3 CG189.2 ; v1(231.97,144.11) 232.39,144.53 CG198.2 ; v1(319.64,5.54) CE59.2 ; CG245.2 v1(281.76,127.92) ; PR26.1 PC13.1 293.21,6.78 v1(293.38,6.95) ; v1(209,18.73) 209.05,18.73 209.42,18.36 CH191.2 ; v1(236.32,95.1) 236.33,95.09 PC6513.2 ; v1(243.79,145.67) CG191.2 ; CA57.2 v1(27.63,5.94) ; CM14.2 315.6,42.34 v1(315.64,42.38) ; v1(175.33,76.61) 175.82,77.1 C4.2 ; JFAN1.5 v1(109.72,64.58) ; PC8215.2 v1(282.63,158.91) ; CD29.2 155.35,40.07 v1(155.54,40.26) ; v1(200.35,71.66) 200.67,71.34 PR1308.2 PC1311.2 ; v1(280.52,101.81) 280.67,101.66 CG262.2 RG120.2 ; QE2.3 310.4,6.64 v1(310.65,6.89) ; C2516.2 v1(317.34,54.4) ; RE44.2 RE42.2 221.54,162.39 222.05,161.88 v1(222.05,161.8) ; v1(197.34,166.06) 197.81,166.53 198.26,166.53 ; RG135.2 276.52,97.68 v1(276.52,97.41) ; JIO.34 v1(328.47,28.58) ; v1(243.38,98.1) 243.24,97.97 PC6514.2 ; CH109.2 164.51,115.35 v1(164.5,115.33) ; RE649.1 v1(309.19,45.76) ; PC119.2 53.96,31.01 PC118.2 53.94,30.34 v1(53.73,30.13) ; PC208.2 PC216.2 v1(86.56,36.06) ; PR8211.2 282.34,155.96 v1(282.77,156.39) 282.32,156.85 PC8217.2 ; CD92.2 v1(138.44,37.75) ; v1(310.02,24.99) RE83.2 310.02,23.56 309.51,23.05 CE32.1 ; PR582.1 187.2,131.54 186.7,131.03 v1(186.13,131.03) ; PR116.2 63.45,45.75 v1(63.45,45.45) ; PC8216.2 v1(279.79,161.4) ; CA23.2 33.98,23.79 v1(34.5,23.27) ; v1(144.06,40.33) 143.59,39.86 CD26.2 ; v1(103.79,62.1) 103.12,62.77 JFAN1.4 ; CE46.2 v1(296.8,5.73) ; v1(78.5,7.59) PD3.1 ; JWDB.5 202.15,11.87 v1(202.99,12.71) ; v1(206.57,38.39) 206.64,38.32 RH580.2 ; C2521.2 v1(178.39,76.46) ; C633.2 v1(238.32,5.02) ; JEDP.41 v1(150.72,179.37) ; v1(320.85,5.54) CE60.2 ; v1(205.18,29.76) 205.11,29.83 CH185.2 ; v1(239.53,155.73) 239.3,155.5 CL6.2 ; CE27.2 v1(310.63,15.82) ; PC6528.2 244.94,64.03 v1(244.94,64.48) ; CF4.2 v1(107.77,58.33) ; v1(135.25,41.89) 135.15,41.79 CD21.2 ; PC8219.2 v1(264.04,171.22) ; PC11.2 65.13,14.52 v1(64.69,14.08) ; C623.2 C621.2 330.45,30.38 v1(330.02,29.94) ; v1(304.11,50.4) CE62.2 ; QU1.3 v1(305.96,56) ; C29.2 192.34,12.9 191.6,12.16 v1(190.38,12.16) ; C2520.2 184.16,77.04 C7.2 183.4,76.57 v1(183.56,76.41) ; v1(210.03,143.77) CG178.2 ; CE31.1 v1(286.84,24.48) ; DA5.1 v1(22.45,17.11) ; v1(249.94,16.34) PR308.2 ; v1(261.31,159.8) 261.01,159.49 QL3.3 ; C2515.2 v1(320.34,56.48) ; CD27.2 v1(182.4,48.18) ; v1(318.07,21.25) CE9.2 ; v1(174.26,178.66) 174.22,178.63 JEDP.44 ; v1(20.61,55.02) 20.61,54.9 21.12,54.39 CU44.2 ; JPWR.9 v1(208.48,166.96) ; CL29.2 CL28.2 v1(257.88,165.75) ; PR8206.1 272.93,158.21 v1(273.6,158.88) ; CH104.2 167.52,111.38 v1(167.16,111.74) ; CG230.2 v1(282.56,113.51) ; CM11.2 312.77,42.86 313.19,43.27 v1(313.19,43.58) ; C636.2 v1(334.79,31.35) ; v1(233.63,146.73) RG115.2 ; SW1.1 v1(314.4,5.49) ; CG259.2 280.25,111.69 v1(280.52,111.41) ; JIO.32 v1(324.62,25.25) ; v1(63.05,48.45) PC112.2 ; CE42.2 v1(304.99,4.46) ; PC6522.2 240,64.03 v1(240,64.48) ; v1(188.98,168.62) 189.18,168.82 CT38.2 ; v1(321.74,5.54) CE7.2 ; v1(140,40.63) 140.48,40.14 CD23.2 ; v1(193.24,111.54) 193.68,111.09 RV624.2 ; PR562.1 v1(154.65,136.45) ; CM29.2 v1(128.79,152.43) ; CG253.2 v1(282.13,105.72) ; v1(127.45,7.97) CS1.2
  GND1 w0.203: JCDRA.47 178.62,177.71 ; JCDRA.47 177.67,176.15 ; JCDRA.47 176.72,176.15 ; JCDRA.47 178.62,176.15 ; JCDRA.47 178.62,179.27 ; JCDRA.47 176.72,177.71 ; JCDRA.47 177.67,179.27 ; JCDRA.47 176.72,179.27 ; 295.94,76.25 H20.1 ; H20.1 297.87,78.18 ; H20.1 299.29,74.83 ; H20.1 299.8,76.25 ; H20.1 296.45,74.83 ; H20.1 299.29,77.67 ; H20.1 297.87,74.32 ; H20.1 296.45,77.67 ; 236.07,171.91 JDP.13 ; JDP.13 235.61,172.03 ; JDP.13 235.49,172.49 ; JDP.13 236.07,173.07 ; JDP.13 235.61,172.95 ; JDP.13 236.54,172.03 ; JDP.13 236.54,172.95 ; 231.91,173.23 JDP.1 ; JDP.1 232.84,174.15 ; JDP.1 232.84,173.23 ; JDP.1 232.37,174.27 ; JDP.1 231.79,173.69 ; JDP.1 232.37,173.11 ; JDP.1 231.91,174.15 ; JUSBC1.4 197.04,185.17 ; JUSBC1.4 196.21,182.33 ; JUSBC1.4 196.21,185.17 ; JUSBC1.4 197.87,183.75 ; JUSBC1.4 197.04,182.33 ; JUSBC1.4 196.21,183.75 ; JUSBC1.4 197.87,185.17 ; JUSBC1.4 197.87,182.33 ; JDP.19 238.24,174.15 ; JDP.19 238.24,173.23 ; JDP.19 237.77,174.27 ; JDP.19 238.36,173.69 ; JDP.19 237.31,174.15 ; JDP.19 237.77,173.11 ; JDP.19 237.31,173.23 ; JUSBC2.2 1.8,65.45 ; JUSBC2.2 0.38,64.62 ; JUSBC2.2 0.38,65.45 ; JUSBC2.2 3.22,63.79 ; JUSBC2.2 3.22,64.62 ; JUSBC2.2 1.8,63.79 ; JUSBC2.2 3.22,65.45 ; JUSBC2.2 0.38,63.79 ; H19.1 94.29,55.48 ; H19.1 94.29,58.32 ; H19.1 90.94,56.9 ; H19.1 91.45,58.32 ; H19.1 91.45,55.48 ; H19.1 92.87,54.97 ; H19.1 94.8,56.9 ; H19.1 92.87,58.83 ; 4.69,29.14 JUSB1.13 ; JUSB1.13 4.69,30 ; JUSB1.13 6.2,29.14 ; JUSB1.13 7.71,30 ; JUSB1.13 7.71,29.14 ; 274.24,170.6 H12.1 ; H12.1 277.59,172.02 ; H12.1 276.17,172.53 ; H12.1 276.17,168.67 ; H12.1 278.1,170.6 ; H12.1 274.75,169.18 ; H12.1 277.59,169.18 ; H12.1 274.75,172.02 ; 197.33,154.53 H13.1 ; H13.1 201.81,149.47 ; H13.1 197.33,152 ; H13.1 199.57,154.53 ; H13.1 201.81,152 ; H13.1 197.33,149.47 ; H13.1 199.57,149.47 ; H13.1 201.81,154.53 ; JUSBC2.1 8.08,65.4 ; JUSBC2.1 5.62,65.4 ; JUSBC2.1 8.08,63.84 ; JUSBC2.1 8.08,64.62 ; JUSBC2.1 5.62,63.84 ; JUSBC2.1 6.85,65.4 ; JUSBC2.1 5.62,64.62 ; H9.1 7.99,49.38 ; H9.1 5.15,49.38 ; H9.1 6.57,48.87 ; H9.1 6.57,52.73 ; H9.1 4.64,50.8 ; H9.1 7.99,52.22 ; H9.1 5.15,52.22 ; H9.1 8.5,50.8 ; JUSBC1.5 188.73,179.92 ; JUSBC1.5 189.63,179.92 ; JUSBC1.5 189.63,179.2 ; JUSBC1.5 187.62,179.2 ; JUSBC1.5 187.62,178.48 ; JUSBC1.5 189.63,178.48 ; JUSBC1.5 187.62,179.92 ; 240.57,170.34 JDP.22 ; JDP.22 239.8,170.34 ; JDP.22 240.57,172.96 ; JDP.22 241.35,170.34 ; JDP.22 241.35,172.96 ; JDP.22 241.35,171.65 ; JDP.22 239.8,171.65 ; H18.1 103.49,7.92 ; H18.1 102.07,8.43 ; H18.1 104,6.5 ; H18.1 102.07,4.57 ; H18.1 103.49,5.08 ; H18.1 100.65,7.92 ; H18.1 100.65,5.08 ; H18.1 100.14,6.5 ; 224.84,183.33 JHDMI.23 ; JHDMI.23 226.7,182.05 ; JHDMI.23 225.77,183.33 ; JHDMI.23 226.7,183.33 ; JHDMI.23 225.77,180.77 ; JHDMI.23 226.7,180.77 ; JHDMI.23 224.84,180.77 ; JHDMI.23 224.84,182.05 ; JUSBC2.6 7.07,55.2 ; JUSBC2.6 5.63,55.2 ; JUSBC2.6 7.07,57.21 ; JUSBC2.6 5.63,57.21 ; JUSBC2.6 6.35,57.21 ; JUSBC2.6 5.63,56.3 ; JUSBC2.6 6.35,55.2 ; 158.47,153.9 H1.1 ; H1.1 157.83,155.6 ; H1.1 162.51,155.6 ; H1.1 160.17,157.94 ; H1.1 158.47,157.3 ; H1.1 160.17,153.26 ; H1.1 161.87,157.3 ; H1.1 161.87,153.9 ; 144.22,177.71 JCDRA.50 ; JCDRA.50 145.17,176.15 ; JCDRA.50 144.22,179.27 ; JCDRA.50 146.12,179.27 ; JCDRA.50 144.22,176.15 ; JCDRA.50 146.12,176.15 ; JCDRA.50 146.12,177.71 ; JCDRA.50 145.17,179.27 ; JUSB1.4 17.31,34.4 ; JUSB1.4 16.55,35.16 ; JUSB1.4 15.79,34.4 ; JUSB1.4 15.96,34.99 ; JUSB1.4 17.14,34.99 ; JUSB1.4 17.14,33.81 ; JUSB1.4 16.55,33.64 ; JUSB1.4 15.96,33.81 ; 274.37,45.2 H5.1 ; H5.1 274.37,41.8 ; H5.1 273.73,43.5 ; H5.1 276.07,45.84 ; H5.1 276.07,41.16 ; H5.1 277.77,41.8 ; H5.1 277.77,45.2 ; H5.1 278.41,43.5 ; H8.1 5.07,71.73 ; H8.1 6.49,71.22 ; H8.1 3.65,68.38 ; H8.1 5.07,67.87 ; H8.1 3.14,69.8 ; H8.1 3.65,71.22 ; H8.1 7,69.8 ; H8.1 6.49,68.38 ; 122.67,88.56 H2.1 ; H2.1 122.67,93.24 ; H2.1 124.37,89.2 ; H2.1 125.01,90.9 ; H2.1 120.33,90.9 ; H2.1 120.97,92.6 ; H2.1 120.97,89.2 ; H2.1 124.37,92.6 ; H14.1 202.22,182.03 ; H14.1 204.15,180.1 ; H14.1 203.64,178.68 ; H14.1 202.22,178.17 ; H14.1 200.8,178.68 ; H14.1 203.64,181.52 ; H14.1 200.8,181.52 ; H14.1 200.29,180.1 ; JUSBC2.5 7.07,65.4 ; JUSBC2.5 6.35,63.39 ; JUSBC2.5 6.35,65.4 ; JUSBC2.5 5.63,63.39 ; JUSBC2.5 5.63,65.4 ; JUSBC2.5 7.07,63.39 ; JUSBC2.5 5.63,64.3 ; 19.83,11.5 H11.1 ; H11.1 22.07,9.26 ; H11.1 24.31,11.5 ; H11.1 23.7,13.13 ; H11.1 22.07,13.74 ; H11.1 20.44,13.13 ; H11.1 20.44,9.87 ; H11.1 23.7,9.87 ; H4.1 207.41,48.5 ; H4.1 206.77,46.8 ; H4.1 205.07,50.84 ; H4.1 202.73,48.5 ; H4.1 206.77,50.2 ; H4.1 203.37,50.2 ; H4.1 205.07,46.16 ; H4.1 203.37,46.8 ; H23.1 270.45,6.5 ; H23.1 265.49,4.26 ; H23.1 270.45,8.74 ; H23.1 267.97,4.26 ; H23.1 267.97,8.74 ; H23.1 265.49,6.5 ; H23.1 265.49,8.74 ; H23.1 270.45,4.26 ; 187.57,183.75 JUSBC1.2 ; JUSBC1.2 187.57,185.17 ; JUSBC1.2 188.4,185.17 ; JUSBC1.2 189.23,185.17 ; JUSBC1.2 189.23,182.33 ; JUSBC1.2 189.23,183.75 ; JUSBC1.2 188.4,182.33 ; JUSBC1.2 187.57,182.33 ; H3.1 181.67,92.54 ; H3.1 180.04,88.67 ; H3.1 179.43,90.3 ; H3.1 181.67,88.06 ; H3.1 183.91,90.3 ; H3.1 183.3,91.93 ; H3.1 183.3,88.67 ; H3.1 180.04,91.93 ; H10.1 29.49,52.58 ; H10.1 29.49,55.42 ; H10.1 28.07,52.07 ; H10.1 26.65,52.58 ; H10.1 30,54 ; H10.1 26.14,54 ; H10.1 26.65,55.42 ; H10.1 28.07,55.93 ; 228.8,172.96 JDP.24 ; JDP.24 229.57,172.96 ; JDP.24 228.8,170.34 ; JDP.24 230.35,171.65 ; JDP.24 228.8,171.65 ; JDP.24 229.57,170.34 ; JDP.24 230.35,170.34 ; JPCMC.36 121.57,154.76 ; JPCMC.36 122.25,156.56 ; JPCMC.36 119.77,154.08 ; JPCMC.36 119.77,159.04 ; JPCMC.36 117.97,158.36 ; JPCMC.36 117.97,154.76 ; H7.1 271.41,150.5 ; H7.1 267.37,148.8 ; H7.1 266.73,150.5 ; H7.1 270.77,152.2 ; H7.1 269.07,148.16 ; H7.1 269.07,152.84 ; H7.1 270.77,148.8 ; H7.1 267.37,152.2 ; JUSBC2.4 1.8,56.81 ; JUSBC2.4 0.38,55.15 ; JUSBC2.4 3.22,55.15 ; JUSBC2.4 3.22,56.81 ; JUSBC2.4 0.38,55.98 ; JUSBC2.4 1.8,55.15 ; JUSBC2.4 3.22,55.98 ; JUSBC2.4 0.38,56.81 ; JLAN.16 244.6,179.94 ; JLAN.16 243.69,176.43 ; JLAN.16 243.69,179.94 ; JLAN.16 244.6,176.43 ; JLAN.16 242.77,176.43 ; JLAN.16 242.77,178.19 ; JLAN.16 242.77,179.94 ; JLAN.16 244.6,178.19 ; 228.8,176.65 JDP.23 ; JDP.23 228.8,177.96 ; JDP.23 230.35,175.34 ; JDP.23 229.57,175.34 ; JDP.23 230.35,176.65 ; JDP.23 229.57,177.96 ; JDP.23 228.8,175.34 ; JDP.23 230.35,177.96 ; H15.1 184.64,178.68 ; H15.1 181.8,178.68 ; H15.1 183.22,182.03 ; H15.1 181.29,180.1 ; H15.1 185.15,180.1 ; H15.1 181.8,181.52 ; H15.1 183.22,178.17 ; H15.1 184.64,181.52 ; JCDRA.49 146.12,183.87 ; JCDRA.49 144.22,182.31 ; JCDRA.49 145.17,180.75 ; JCDRA.49 146.12,180.75 ; JCDRA.49 146.12,182.31 ; JCDRA.49 144.22,183.87 ; JCDRA.49 145.17,183.87 ; JCDRA.49 144.22,180.75 ; JDP.21 241.35,175.34 ; JDP.21 240.57,175.34 ; JDP.21 239.8,175.34 ; JDP.21 240.57,177.96 ; JDP.21 239.8,176.65 ; JDP.21 241.35,177.96 ; JDP.21 241.35,176.65 ; JDP.21 239.8,177.96 ; JUSB1.14 7.71,45.8 ; JUSB1.14 6.2,46.66 ; JUSB1.14 7.71,46.66 ; JUSB1.14 4.69,45.8 ; JUSB1.14 4.69,46.66 ; 214.12,173.72 JHDMI.5 ; JHDMI.5 214.58,174.76 ; JHDMI.5 214.12,174.88 ; JHDMI.5 213.66,174.76 ; JHDMI.5 213.66,173.84 ; JHDMI.5 214.58,173.84 ; 197.04,177.47 JUSBC1.3 ; JUSBC1.3 197.82,178.7 ; JUSBC1.3 197.82,177.47 ; JUSBC1.3 197.82,179.93 ; JUSBC1.3 196.27,179.93 ; JUSBC1.3 197.04,179.93 ; JUSBC1.3 196.27,177.47 ; 22.07,2.27 H16.1 ; H16.1 22.07,6.13 ; H16.1 23.49,5.62 ; H16.1 20.65,2.78 ; H16.1 20.14,4.2 ; H16.1 20.65,5.62 ; H16.1 24,4.2 ; H16.1 23.49,2.78 ; JCDRA.48 178.62,180.75 ; JCDRA.48 176.72,182.31 ; JCDRA.48 176.72,180.75 ; JCDRA.48 178.62,183.87 ; JCDRA.48 177.67,180.75 ; JCDRA.48 176.72,183.87 ; JCDRA.48 178.62,182.31 ; JCDRA.48 177.67,183.87 ; 216.66,173.84 JHDMI.11 ; JHDMI.11 216.66,174.76 ; JHDMI.11 217.12,174.88 ; JHDMI.11 217.12,173.72 ; JHDMI.11 217.58,174.76 ; JHDMI.11 217.58,173.84 ; 219.66,173.84 JHDMI.17 ; JHDMI.17 220.12,173.72 ; JHDMI.17 219.66,174.76 ; JHDMI.17 220.58,174.76 ; JHDMI.17 220.12,174.88 ; JHDMI.17 220.58,173.84 ; JUSBC1.6 197.82,178.48 ; JUSBC1.6 197.82,179.2 ; JUSBC1.6 195.81,179.92 ; JUSBC1.6 197.82,179.92 ; JUSBC1.6 196.72,179.92 ; 262.74,176.43 JLAN.14 ; JLAN.14 261.82,176.43 ; JLAN.14 261.82,178.19 ; JLAN.14 263.65,176.43 ; JLAN.14 262.74,179.94 ; JLAN.14 261.82,179.94 ; JLAN.14 263.65,178.19 ; JLAN.14 263.65,179.94 ; 233.61,172.03 JDP.7 ; JDP.7 234.66,172.49 ; JDP.7 234.54,172.03 ; JDP.7 234.07,173.07 ; JDP.7 233.61,172.95 ; JDP.7 234.07,171.91 ; JDP.7 234.54,172.95 ; 222.94,171.32 JHDMI.22 ; JHDMI.22 223.87,171.32 ; JHDMI.22 224.8,172.6 ; JHDMI.22 224.8,173.88 ; JHDMI.22 224.8,171.32 ; JHDMI.22 222.94,173.88 ; JHDMI.22 223.87,173.88 ; JHDMI.22 222.94,172.6 ; H22.1 197.87,57.53 ; H22.1 199.29,54.18 ; H22.1 199.8,55.6 ; H22.1 197.87,53.67 ; H22.1 196.45,57.02 ; H22.1 199.29,57.02 ; H22.1 196.45,54.18 ; H22.1 195.94,55.6 ; JUSB1.7 15.64,38.49 ; JUSB1.7 14.46,37.31 ; JUSB1.7 15.05,38.66 ; JUSB1.7 14.29,37.9 ; JUSB1.7 15.05,37.14 ; JUSB1.7 15.64,37.31 ; JUSB1.7 15.81,37.9 ; JUSB1.7 14.46,38.49 ; H21.1 263.49,5.08 ; H21.1 262.07,4.57 ; H21.1 260.65,5.08 ; H21.1 260.14,6.5 ; H21.1 262.07,8.43 ; H21.1 264,6.5 ; H21.1 263.49,7.92 ; H21.1 260.65,7.92 ; 208.44,171.32 JHDMI.20 ; JHDMI.20 209.37,173.88 ; JHDMI.20 208.44,172.6 ; JHDMI.20 209.37,171.32 ; JHDMI.20 208.44,173.88 ; JHDMI.20 210.3,173.88 ; JHDMI.20 210.3,172.6 ; 215.16,172.29 JHDMI.8 ; JHDMI.8 215.62,173.33 ; JHDMI.8 216.08,172.29 ; JHDMI.8 215.16,173.21 ; JHDMI.8 216.08,173.21 ; JHDMI.8 215.62,172.17 ; 143.15,172.92 H17.1 ; H17.1 145.99,172.92 ; H17.1 142.64,171.5 ; H17.1 144.57,173.43 ; H17.1 145.99,170.08 ; H17.1 143.15,170.08 ; H17.1 144.57,169.57 ; H17.1 146.5,171.5 ; JHDMI.21 208.4,180.8 ; JHDMI.21 208.4,179.52 ; JHDMI.21 208.4,182.08 ; JHDMI.21 206.54,182.08 ; JHDMI.21 207.47,182.08 ; JHDMI.21 206.54,179.52 ; JHDMI.21 206.54,180.8 ; JHDMI.21 207.47,179.52 ; 5.62,56.76 JUSBC2.3 ; JUSBC2.3 8.08,56.76 ; JUSBC2.3 5.62,55.98 ; JUSBC2.3 8.08,55.2 ; JUSBC2.3 6.85,55.2 ; JUSBC2.3 5.62,55.2 ; JUSBC2.3 8.08,55.98 ; 14.96,30.64 JUSB1.11 ; JUSB1.11 16.71,30.64 ; JUSB1.11 16.71,31.5 ; JUSB1.11 13.21,31.5 ; JUSB1.11 16.71,32.36 ; JUSB1.11 14.96,32.36 ; JUSB1.11 13.21,32.36 ; JUSB1.11 13.21,30.64 ; 188.4,177.47 JUSBC1.1 ; JUSBC1.1 187.62,177.47 ; JUSBC1.1 187.62,178.7 ; JUSBC1.1 187.62,179.93 ; JUSBC1.1 189.18,179.93 ; JUSBC1.1 189.18,177.47 ; JUSBC1.1 188.4,179.93 ; 179.67,4.57 H6.1 ; H6.1 177.74,6.5 ; H6.1 179.67,8.43 ; H6.1 178.25,7.92 ; H6.1 178.25,5.08 ; H6.1 181.6,6.5 ; H6.1 181.09,5.08 ; H6.1 181.09,7.92 ; 212.62,172.17 JHDMI.2 ; JHDMI.2 212.16,173.21 ; JHDMI.2 213.08,172.29 ; JHDMI.2 212.04,172.75 ; JHDMI.2 213.08,173.21 ; JHDMI.2 212.62,173.33 ; JHDMI.2 212.16,172.29 ; 14.96,43.44 JUSB1.12 ; JUSB1.12 16.71,44.3 ; JUSB1.12 16.71,43.44 ; JUSB1.12 13.21,43.44 ; JUSB1.12 14.96,45.16 ; JUSB1.12 13.21,45.16 ; JUSB1.12 13.21,44.3 ; JUSB1.12 16.71,45.16
  IN1 w0.508: v1(240.99,175.23) 240.57,175.65 JDP.21
  GND2 w0.203: 14.46,37.31 JUSB1.7 ; JUSB1.7 15.05,37.14 ; JUSB1.7 15.05,38.66 ; JUSB1.7 14.46,38.49 ; JUSB1.7 15.81,37.9 ; JUSB1.7 14.29,37.9 ; JUSB1.7 15.64,38.49 ; JUSB1.7 15.64,37.31 ; 206.54,182.08 JHDMI.21 ; JHDMI.21 208.4,179.52 ; JHDMI.21 206.54,179.52 ; JHDMI.21 207.47,182.08 ; JHDMI.21 208.4,180.8 ; JHDMI.21 208.4,182.08 ; JHDMI.21 207.47,179.52 ; JHDMI.21 206.54,180.8 ; H10.1 28.07,55.93 ; H10.1 29.49,52.58 ; H10.1 26.65,55.42 ; H10.1 30,54 ; H10.1 26.14,54 ; H10.1 28.07,52.07 ; H10.1 26.65,52.58 ; H10.1 29.49,55.42 ; JDP.23 230.35,177.96 ; JDP.23 229.57,175.34 ; JDP.23 228.8,176.65 ; JDP.23 230.35,176.65 ; JDP.23 229.57,177.96 ; JDP.23 228.8,175.34 ; JDP.23 230.35,175.34 ; JDP.23 228.8,177.96 ; JDP.1 232.84,174.15 ; JDP.1 231.91,174.15 ; JDP.1 231.91,173.23 ; JDP.1 231.79,173.69 ; JDP.1 232.37,174.27 ; JDP.1 232.84,173.23 ; JDP.1 232.37,173.11 ; 266.73,150.5 H7.1 ; H7.1 270.77,152.2 ; H7.1 269.07,152.84 ; H7.1 267.37,152.2 ; H7.1 271.41,150.5 ; H7.1 267.37,148.8 ; H7.1 270.77,148.8 ; H7.1 269.07,148.16 ; H12.1 277.59,172.02 ; H12.1 274.24,170.6 ; H12.1 278.1,170.6 ; H12.1 276.17,168.67 ; H12.1 277.59,169.18 ; H12.1 276.17,172.53 ; H12.1 274.75,169.18 ; H12.1 274.75,172.02 ; 3.65,71.22 H8.1 ; H8.1 7,69.8 ; H8.1 6.49,71.22 ; H8.1 3.14,69.8 ; H8.1 6.49,68.38 ; H8.1 5.07,67.87 ; H8.1 3.65,68.38 ; H8.1 5.07,71.73 ; 243.69,176.43 JLAN.16 ; JLAN.16 244.6,179.94 ; JLAN.16 242.77,176.43 ; JLAN.16 242.77,179.94 ; JLAN.16 242.77,178.19 ; JLAN.16 244.6,178.19 ; JLAN.16 243.69,179.94 ; JLAN.16 244.6,176.43 ; 92.87,54.97 H19.1 ; H19.1 94.29,55.48 ; H19.1 94.29,58.32 ; H19.1 90.94,56.9 ; H19.1 91.45,55.48 ; H19.1 91.45,58.32 ; H19.1 94.8,56.9 ; H19.1 92.87,58.83 ; H20.1 299.29,77.67 ; H20.1 297.87,74.32 ; H20.1 296.45,74.83 ; H20.1 299.29,74.83 ; H20.1 297.87,78.18 ; H20.1 295.94,76.25 ; H20.1 296.45,77.67 ; H20.1 299.8,76.25 ; H5.1 277.77,45.2 ; H5.1 274.37,45.2 ; H5.1 276.07,45.84 ; H5.1 278.41,43.5 ; H5.1 277.77,41.8 ; H5.1 273.73,43.5 ; H5.1 276.07,41.16 ; H5.1 274.37,41.8 ; JCDRA.48 178.62,182.31 ; JCDRA.48 177.67,180.75 ; JCDRA.48 176.72,182.31 ; JCDRA.48 176.72,180.75 ; JCDRA.48 177.67,183.87 ; JCDRA.48 178.62,183.87 ; JCDRA.48 178.62,180.75 ; JCDRA.48 176.72,183.87 ; 261.82,176.43 JLAN.14 ; JLAN.14 261.82,179.94 ; JLAN.14 263.65,176.43 ; JLAN.14 261.82,178.19 ; JLAN.14 262.74,179.94 ; JLAN.14 263.65,179.94 ; JLAN.14 262.74,176.43 ; JLAN.14 263.65,178.19 ; JHDMI.20 210.3,173.88 ; JHDMI.20 208.44,173.88 ; JHDMI.20 208.44,171.32 ; JHDMI.20 209.37,173.88 ; JHDMI.20 210.3,172.6 ; JHDMI.20 209.37,171.32 ; JHDMI.20 208.44,172.6 ; JUSBC1.5 189.63,179.92 ; JUSBC1.5 189.63,178.48 ; JUSBC1.5 189.63,179.2 ; JUSBC1.5 187.62,179.92 ; JUSBC1.5 187.62,178.48 ; JUSBC1.5 187.62,179.2 ; JUSBC1.5 188.73,179.92 ; H16.1 23.49,2.78 ; H16.1 24,4.2 ; H16.1 20.65,2.78 ; H16.1 22.07,6.13 ; H16.1 20.65,5.62 ; H16.1 20.14,4.2 ; H16.1 22.07,2.27 ; H16.1 23.49,5.62 ; JHDMI.2 212.62,173.33 ; JHDMI.2 212.16,173.21 ; JHDMI.2 212.62,172.17 ; JHDMI.2 212.16,172.29 ; JHDMI.2 212.04,172.75 ; JHDMI.2 213.08,172.29 ; JHDMI.2 213.08,173.21 ; H23.1 267.97,8.74 ; H23.1 265.49,8.74 ; H23.1 270.45,6.5 ; H23.1 270.45,8.74 ; H23.1 270.45,4.26 ; H23.1 265.49,6.5 ; H23.1 265.49,4.26 ; H23.1 267.97,4.26 ; 188.4,177.47 JUSBC1.1 ; JUSBC1.1 188.4,179.93 ; JUSBC1.1 187.62,178.7 ; JUSBC1.1 187.62,177.47 ; JUSBC1.1 189.18,179.93 ; JUSBC1.1 187.62,179.93 ; JUSBC1.1 189.18,177.47 ; H4.1 205.07,50.84 ; H4.1 207.41,48.5 ; H4.1 203.37,46.8 ; H4.1 206.77,50.2 ; H4.1 206.77,46.8 ; H4.1 203.37,50.2 ; H4.1 202.73,48.5 ; H4.1 205.07,46.16 ; 219.66,173.84 JHDMI.17 ; JHDMI.17 220.12,173.72 ; JHDMI.17 220.58,174.76 ; JHDMI.17 219.66,174.76 ; JHDMI.17 220.58,173.84 ; JHDMI.17 220.12,174.88 ; H11.1 24.31,11.5 ; H11.1 20.44,9.87 ; H11.1 22.07,9.26 ; H11.1 20.44,13.13 ; H11.1 23.7,9.87 ; H11.1 22.07,13.74 ; H11.1 23.7,13.13 ; H11.1 19.83,11.5 ; 233.61,172.95 JDP.7 ; JDP.7 233.61,172.03 ; JDP.7 234.66,172.49 ; JDP.7 234.54,172.03 ; JDP.7 234.07,173.07 ; JDP.7 234.54,172.95 ; JDP.7 234.07,171.91 ; JUSBC1.6 197.82,179.2 ; JUSBC1.6 197.82,178.48 ; JUSBC1.6 195.81,179.92 ; JUSBC1.6 196.72,179.92 ; JUSBC1.6 197.82,179.92 ; 16.55,33.64 JUSB1.4 ; JUSB1.4 17.14,33.81 ; JUSB1.4 16.55,35.16 ; JUSB1.4 15.79,34.4 ; JUSB1.4 17.31,34.4 ; JUSB1.4 15.96,34.99 ; JUSB1.4 17.14,34.99 ; JUSB1.4 15.96,33.81 ; JUSBC1.2 189.23,185.17 ; JUSBC1.2 187.57,183.75 ; JUSBC1.2 187.57,185.17 ; JUSBC1.2 189.23,183.75 ; JUSBC1.2 188.4,182.33 ; JUSBC1.2 188.4,185.17 ; JUSBC1.2 189.23,182.33 ; JUSBC1.2 187.57,182.33 ; 196.21,182.33 JUSBC1.4 ; JUSBC1.4 197.87,182.33 ; JUSBC1.4 196.21,185.17 ; JUSBC1.4 197.04,185.17 ; JUSBC1.4 197.87,185.17 ; JUSBC1.4 197.04,182.33 ; JUSBC1.4 197.87,183.75 ; JUSBC1.4 196.21,183.75 ; JUSBC2.1 8.08,63.84 ; JUSBC2.1 5.62,63.84 ; JUSBC2.1 6.85,65.4 ; JUSBC2.1 5.62,65.4 ; JUSBC2.1 8.08,65.4 ; JUSBC2.1 8.08,64.62 ; JUSBC2.1 5.62,64.62 ; 14.96,30.64 JUSB1.11 ; JUSB1.11 13.21,31.5 ; JUSB1.11 14.96,32.36 ; JUSB1.11 16.71,32.36 ; JUSB1.11 16.71,31.5 ; JUSB1.11 16.71,30.64 ; JUSB1.11 13.21,30.64 ; JUSB1.11 13.21,32.36 ; H3.1 183.91,90.3 ; H3.1 183.3,88.67 ; H3.1 183.3,91.93 ; H3.1 181.67,92.54 ; H3.1 179.43,90.3 ; H3.1 180.04,91.93 ; H3.1 180.04,88.67 ; H3.1 181.67,88.06 ; JUSBC2.4 3.22,55.98 ; JUSBC2.4 3.22,56.81 ; JUSBC2.4 0.38,56.81 ; JUSBC2.4 0.38,55.15 ; JUSBC2.4 1.8,55.15 ; JUSBC2.4 0.38,55.98 ; JUSBC2.4 1.8,56.81 ; JUSBC2.4 3.22,55.15 ; 177.67,176.15 JCDRA.47 ; JCDRA.47 178.62,177.71 ; JCDRA.47 177.67,179.27 ; JCDRA.47 176.72,179.27 ; JCDRA.47 178.62,176.15 ; JCDRA.47 176.72,177.71 ; JCDRA.47 178.62,179.27 ; JUSBC2.2 3.22,64.62 ; JUSBC2.2 3.22,65.45 ; JUSBC2.2 1.8,65.45 ; JUSBC2.2 0.38,65.45 ; JUSBC2.2 0.38,64.62 ; JUSBC2.2 3.22,63.79 ; JUSBC2.2 1.8,63.79 ; JUSBC2.2 0.38,63.79 ; 228.8,171.65 JDP.24 ; JDP.24 230.35,170.34 ; JDP.24 230.35,171.65 ; JDP.24 228.8,172.96 ; JDP.24 228.8,170.34 ; JDP.24 229.57,170.34 ; JDP.24 229.57,172.96 ; 197.33,149.47 H13.1 ; H13.1 199.57,149.47 ; H13.1 201.81,152 ; H13.1 197.33,152 ; H13.1 201.81,149.47 ; 197.04,177.47 JUSBC1.3 ; JUSBC1.3 196.27,179.93 ; JUSBC1.3 197.04,179.93 ; JUSBC1.3 197.82,179.93 ; JUSBC1.3 197.82,178.7 ; JUSBC1.3 197.82,177.47 ; H18.1 103.49,7.92 ; H18.1 100.65,5.08 ; H18.1 103.49,5.08 ; H18.1 102.07,8.43 ; H18.1 100.14,6.5 ; H18.1 100.65,7.92 ; H18.1 104,6.5 ; H18.1 102.07,4.57 ; H1.1 162.51,155.6 ; H1.1 158.47,153.9 ; H1.1 160.17,157.94 ; H1.1 161.87,157.3 ; H1.1 158.47,157.3 ; H1.1 157.83,155.6 ; H1.1 161.87,153.9 ; H1.1 160.17,153.26 ; JUSBC2.3 8.08,55.2 ; JUSBC2.3 6.85,55.2 ; JUSBC2.3 8.08,56.76 ; JUSBC2.3 5.62,55.2 ; JUSBC2.3 5.62,55.98 ; JUSBC2.3 8.08,55.98 ; JUSBC2.3 5.62,56.76 ; 215.16,172.29 JHDMI.8 ; JHDMI.8 215.62,172.17 ; JHDMI.8 215.62,173.33 ; JHDMI.8 216.08,173.21 ; JHDMI.8 216.08,172.29 ; JHDMI.8 215.16,173.21 ; JDP.19 238.24,174.15 ; JDP.19 237.31,173.23 ; JDP.19 237.77,174.27 ; JDP.19 237.77,173.11 ; JDP.19 238.36,173.69 ; JDP.19 238.24,173.23 ; JDP.19 237.31,174.15 ; JUSB1.12 16.71,44.3 ; JUSB1.12 14.96,43.44 ; JUSB1.12 16.71,45.16 ; JUSB1.12 13.21,44.3 ; JUSB1.12 14.96,45.16 ; JUSB1.12 16.71,43.44 ; JUSB1.12 13.21,45.16 ; JUSB1.12 13.21,43.44 ; 178.25,5.08 H6.1 ; H6.1 179.67,4.57 ; H6.1 181.09,5.08 ; H6.1 178.25,7.92 ; H6.1 179.67,8.43 ; H6.1 181.6,6.5 ; H6.1 177.74,6.5 ; H6.1 181.09,7.92 ; H22.1 199.29,54.18 ; H22.1 199.29,57.02 ; H22.1 199.8,55.6 ; H22.1 196.45,57.02 ; H22.1 196.45,54.18 ; H22.1 197.87,57.53 ; H22.1 197.87,53.67 ; H22.1 195.94,55.6 ; H15.1 184.64,181.52 ; H15.1 181.8,181.52 ; H15.1 183.22,182.03 ; H15.1 185.15,180.1 ; H15.1 181.8,178.68 ; H15.1 183.22,178.17 ; H15.1 184.64,178.68 ; H15.1 181.29,180.1 ; JUSB1.13 7.71,30 ; JUSB1.13 4.69,30 ; JUSB1.13 7.71,29.14 ; JUSB1.13 6.2,29.14 ; JUSB1.13 4.69,29.14 ; 200.8,181.52 H14.1 ; H14.1 203.64,178.68 ; H14.1 203.64,181.52 ; H14.1 202.22,182.03 ; H14.1 202.22,178.17 ; H14.1 200.8,178.68 ; H14.1 204.15,180.1 ; H14.1 200.29,180.1 ; 235.49,172.49 JDP.13 ; JDP.13 235.61,172.03 ; JDP.13 236.54,172.95 ; JDP.13 236.07,173.07 ; JDP.13 235.61,172.95 ; JDP.13 236.07,171.91 ; JDP.13 236.54,172.03 ; JUSB1.14 7.71,46.66 ; JUSB1.14 6.2,46.66 ; JUSB1.14 4.69,45.8 ; JUSB1.14 7.71,45.8 ; JUSB1.14 4.69,46.66 ; 5.63,65.4 JUSBC2.5 ; JUSBC2.5 5.63,63.39 ; JUSBC2.5 6.35,63.39 ; JUSBC2.5 5.63,64.3 ; JUSBC2.5 7.07,65.4 ; JUSBC2.5 7.07,63.39 ; JUSBC2.5 6.35,65.4 ; 224.84,182.05 JHDMI.23 ; JHDMI.23 226.7,183.33 ; JHDMI.23 224.84,180.77 ; JHDMI.23 224.84,183.33 ; JHDMI.23 225.77,180.77 ; JHDMI.23 226.7,182.05 ; JHDMI.23 226.7,180.77 ; JHDMI.23 225.77,183.33 ; JHDMI.11 217.58,174.76 ; JHDMI.11 216.66,174.76 ; JHDMI.11 217.12,174.88 ; JHDMI.11 216.66,173.84 ; JHDMI.11 217.58,173.84 ; JHDMI.11 217.12,173.72 ; JUSBC2.6 7.07,55.2 ; JUSBC2.6 7.07,57.21 ; JUSBC2.6 6.35,55.2 ; JUSBC2.6 5.63,57.21 ; JUSBC2.6 5.63,55.2 ; JUSBC2.6 5.63,56.3 ; JUSBC2.6 6.35,57.21 ; 5.15,52.22 H9.1 ; H9.1 5.15,49.38 ; H9.1 6.57,52.73 ; H9.1 8.5,50.8 ; H9.1 7.99,52.22 ; H9.1 6.57,48.87 ; H9.1 4.64,50.8 ; H9.1 7.99,49.38 ; H2.1 124.37,92.6 ; H2.1 122.67,88.56 ; H2.1 124.37,89.2 ; H2.1 122.67,93.24 ; H2.1 125.01,90.9 ; JDP.21 241.35,176.65 ; JDP.21 239.8,177.96 ; JDP.21 241.35,175.34 ; JDP.21 240.57,177.96 ; JDP.21 239.8,175.34 ; JDP.21 241.35,177.96 ; JDP.21 240.57,175.34 ; JDP.21 239.8,176.65 ; JHDMI.22 224.8,172.6 ; JHDMI.22 224.8,173.88 ; JHDMI.22 222.94,172.6 ; JHDMI.22 222.94,171.32 ; JHDMI.22 222.94,173.88 ; JHDMI.22 223.87,171.32 ; JHDMI.22 223.87,173.88 ; JHDMI.22 224.8,171.32 ; 260.65,5.08 H21.1 ; H21.1 263.49,5.08 ; H21.1 260.14,6.5 ; H21.1 264,6.5 ; H21.1 263.49,7.92 ; H21.1 260.65,7.92 ; H21.1 262.07,8.43 ; H21.1 262.07,4.57 ; 239.8,170.34 JDP.22 ; JDP.22 240.57,170.34 ; JDP.22 241.35,171.65 ; JDP.22 241.35,172.96 ; JDP.22 239.8,171.65 ; JDP.22 240.57,172.96 ; JDP.22 241.35,170.34 ; JCDRA.50 146.12,179.27 ; JCDRA.50 145.17,176.15 ; JCDRA.50 146.12,176.15 ; JCDRA.50 144.22,176.15 ; JCDRA.50 144.22,177.71 ; JCDRA.50 145.17,179.27 ; JCDRA.50 144.22,179.27 ; JCDRA.50 146.12,177.71 ; 144.22,180.75 JCDRA.49 ; JCDRA.49 144.22,183.87 ; JCDRA.49 145.17,183.87 ; JCDRA.49 146.12,182.31 ; JCDRA.49 144.22,182.31 ; JCDRA.49 146.12,183.87 ; JCDRA.49 146.12,180.75 ; JCDRA.49 145.17,180.75 ; JHDMI.5 214.12,174.88 ; JHDMI.5 213.66,173.84 ; JHDMI.5 214.12,173.72 ; JHDMI.5 213.66,174.76 ; JHDMI.5 214.58,173.84 ; JHDMI.5 214.58,174.76 ; 143.15,170.08 H17.1 ; H17.1 144.57,169.57 ; H17.1 143.15,172.92 ; H17.1 145.99,172.92 ; H17.1 142.64,171.5 ; H17.1 144.57,173.43
  VCC w0.203: 242.77,178.19 JLAN.16 ; JLAN.16 244.6,178.19 ; JLAN.16 242.77,176.43 ; JLAN.16 244.6,176.43 ; JLAN.16 242.77,179.94 ; JLAN.16 243.69,176.43 ; JLAN.16 244.6,179.94 ; JLAN.16 243.69,179.94 ; 14.29,37.9 JUSB1.7 ; JUSB1.7 15.64,37.31 ; JUSB1.7 14.46,37.31 ; JUSB1.7 15.05,37.14 ; JUSB1.7 15.05,38.66 ; JUSB1.7 15.81,37.9 ; JUSB1.7 15.64,38.49 ; JUSB1.7 14.46,38.49 ; JDP.1 232.37,174.27 ; JDP.1 232.37,173.11 ; JDP.1 232.84,173.23 ; JDP.1 231.79,173.69 ; JDP.1 232.84,174.15 ; JDP.1 231.91,174.15 ; JDP.1 231.91,173.23 ; 239.8,170.34 JDP.22 ; JDP.22 240.57,172.96 ; JDP.22 241.35,170.34 ; JDP.22 239.8,171.65 ; JDP.22 240.57,170.34 ; JDP.22 241.35,172.96 ; JDP.22 241.35,171.65 ; 5.07,67.87 H8.1 ; H8.1 7,69.8 ; H8.1 6.49,68.38 ; H8.1 5.07,71.73 ; H8.1 3.65,71.22 ; H8.1 6.49,71.22 ; H8.1 3.14,69.8 ; H8.1 3.65,68.38 ; JHDMI.8 216.08,172.29 ; JHDMI.8 216.08,173.21 ; JHDMI.8 215.62,172.17 ; JHDMI.8 215.62,173.33 ; JHDMI.8 215.16,172.29 ; JHDMI.8 215.16,173.21 ; 188.4,177.47 JUSBC1.1 ; JUSBC1.1 187.62,178.7 ; JUSBC1.1 187.62,177.47 ; JUSBC1.1 188.4,179.93 ; JUSBC1.1 187.62,179.93 ; JUSBC1.1 189.18,177.47 ; JUSBC1.1 189.18,179.93 ; JUSBC2.2 3.22,63.79 ; JUSBC2.2 1.8,65.45 ; JUSBC2.2 0.38,64.62 ; JUSBC2.2 3.22,65.45 ; JUSBC2.2 1.8,63.79 ; JUSBC2.2 0.38,63.79 ; JUSBC2.2 0.38,65.45 ; JUSBC2.2 3.22,64.62 ; 145.17,180.75 JCDRA.49 ; JCDRA.49 146.12,180.75 ; JCDRA.49 145.17,183.87 ; JCDRA.49 146.12,182.31 ; JCDRA.49 146.12,183.87 ; JCDRA.49 144.22,182.31 ; JCDRA.49 144.22,180.75 ; JCDRA.49 144.22,183.87 ; 13.21,32.36 JUSB1.11 ; JUSB1.11 13.21,30.64 ; JUSB1.11 16.71,31.5 ; JUSB1.11 14.96,30.64 ; JUSB1.11 16.71,32.36 ; JUSB1.11 14.96,32.36 ; JUSB1.11 13.21,31.5 ; JUSB1.11 16.71,30.64 ; 5.63,63.39 JUSBC2.5 ; JUSBC2.5 5.63,64.3 ; JUSBC2.5 5.63,65.4 ; JUSBC2.5 7.07,63.39 ; JUSBC2.5 6.35,65.4 ; JUSBC2.5 6.35,63.39 ; JUSBC2.5 7.07,65.4 ; JDP.7 234.54,172.95 ; JDP.7 233.61,172.95 ; JDP.7 234.54,172.03 ; JDP.7 234.07,173.07 ; JDP.7 234.66,172.49 ; JDP.7 233.61,172.03 ; JDP.7 234.07,171.91 ; 274.75,169.18 H12.1 ; H12.1 277.59,172.02 ; H12.1 278.1,170.6 ; H12.1 274.24,170.6 ; H12.1 276.17,172.53 ; H12.1 276.17,168.67 ; H12.1 277.59,169.18 ; H12.1 274.75,172.02 ; JHDMI.5 214.58,173.84 ; JHDMI.5 214.12,174.88 ; JHDMI.5 214.12,173.72 ; JHDMI.5 213.66,173.84 ; JHDMI.5 214.58,174.76 ; JHDMI.5 213.66,174.76 ; JDP.13 236.07,173.07 ; JDP.13 235.49,172.49 ; JDP.13 236.07,171.91 ; JDP.13 236.54,172.03 ; JDP.13 235.61,172.95 ; JDP.13 235.61,172.03 ; JDP.13 236.54,172.95 ; 222.94,173.88 JHDMI.22 ; JHDMI.22 222.94,171.32 ; JHDMI.22 224.8,172.6 ; JHDMI.22 224.8,171.32 ; JHDMI.22 222.94,172.6 ; JHDMI.22 223.87,171.32 ; JHDMI.22 223.87,173.88 ; JHDMI.22 224.8,173.88 ; 177.67,176.15 JCDRA.47 ; JCDRA.47 178.62,177.71 ; JCDRA.47 178.62,179.27 ; JCDRA.47 178.62,176.15 ; JCDRA.47 176.72,179.27 ; JCDRA.47 177.67,179.27 ; JCDRA.47 176.72,177.71 ; JUSBC1.6 197.82,179.2 ; JUSBC1.6 195.81,179.92 ; JUSBC1.6 197.82,178.48 ; JUSBC1.6 197.82,179.92 ; JUSBC1.6 196.72,179.92 ; 187.62,179.2 JUSBC1.5 ; JUSBC1.5 187.62,179.92 ; JUSBC1.5 189.63,179.2 ; JUSBC1.5 189.63,179.92 ; JUSBC1.5 187.62,178.48 ; JUSBC1.5 188.73,179.92 ; JUSBC1.5 189.63,178.48 ; 220.12,173.72 JHDMI.17 ; JHDMI.17 220.12,174.88 ; JHDMI.17 219.66,174.76 ; JHDMI.17 219.66,173.84 ; JHDMI.17 220.58,173.84 ; JHDMI.17 220.58,174.76 ; JUSB1.4 16.55,35.16 ; JUSB1.4 15.96,34.99 ; JUSB1.4 17.31,34.4 ; JUSB1.4 15.96,33.81 ; JUSB1.4 17.14,34.99 ; JUSB1.4 17.14,33.81 ; JUSB1.4 16.55,33.64 ; JUSB1.4 15.79,34.4 ; 209.37,171.32 JHDMI.20 ; JHDMI.20 208.44,171.32 ; JHDMI.20 210.3,172.6 ; JHDMI.20 210.3,173.88 ; JHDMI.20 208.44,173.88 ; JHDMI.20 209.37,173.88 ; JHDMI.20 208.44,172.6 ; 216.66,174.76 JHDMI.11 ; JHDMI.11 217.58,174.76 ; JHDMI.11 217.58,173.84 ; JHDMI.11 217.12,174.88 ; JHDMI.11 217.12,173.72 ; JHDMI.11 216.66,173.84 ; 5.63,55.2 JUSBC2.6 ; JUSBC2.6 7.07,55.2 ; JUSBC2.6 6.35,55.2 ; JUSBC2.6 5.63,56.3 ; JUSBC2.6 7.07,57.21 ; JUSBC2.6 6.35,57.21 ; JUSBC2.6 5.63,57.21 ; JDP.21 241.35,175.34 ; JDP.21 241.35,176.65 ; JDP.21 239.8,175.34 ; JDP.21 241.35,177.96 ; JDP.21 239.8,176.65 ; JDP.21 240.57,177.96 ; JDP.21 240.57,175.34 ; JDP.21 239.8,177.96 ; JUSB1.14 7.71,46.66 ; JUSB1.14 7.71,45.8 ; JUSB1.14 4.69,46.66 ; JUSB1.14 6.2,46.66 ; JUSB1.14 4.69,45.8 ; H15.1 184.64,178.68 ; H15.1 181.8,178.68 ; H15.1 181.8,181.52 ; H15.1 184.64,181.52 ; H15.1 183.22,182.03 ; H15.1 185.15,180.1 ; H15.1 183.22,178.17 ; H15.1 181.29,180.1 ; JUSBC2.4 1.8,56.81 ; JUSBC2.4 3.22,56.81 ; JUSBC2.4 3.22,55.15 ; JUSBC2.4 1.8,55.15 ; JUSBC2.4 0.38,55.98 ; JUSBC2.4 3.22,55.98 ; JUSBC2.4 0.38,55.15 ; JUSBC2.4 0.38,56.81 ; JUSBC1.4 197.87,185.17 ; JUSBC1.4 197.87,183.75 ; JUSBC1.4 197.04,185.17 ; JUSBC1.4 196.21,182.33 ; JUSBC1.4 196.21,185.17 ; JUSBC1.4 197.04,182.33 ; JUSBC1.4 197.87,182.33 ; JUSBC1.4 196.21,183.75 ; H14.1 204.15,180.1 ; H14.1 200.29,180.1 ; H14.1 202.22,178.17 ; H14.1 202.22,182.03 ; H14.1 203.64,178.68 ; H14.1 203.64,181.52 ; H14.1 200.8,181.52 ; H14.1 200.8,178.68 ; JDP.24 230.35,170.34 ; JDP.24 229.57,172.96 ; JDP.24 229.57,170.34 ; JDP.24 228.8,171.65 ; JDP.24 228.8,170.34 ; JDP.24 230.35,171.65 ; JDP.24 228.8,172.96 ; 5.62,63.84 JUSBC2.1 ; JUSBC2.1 5.62,65.4 ; JUSBC2.1 6.85,65.4 ; JUSBC2.1 8.08,65.4 ; JUSBC2.1 8.08,64.62 ; JUSBC2.1 5.62,64.62 ; JUSBC2.1 8.08,63.84 ; 5.62,55.2 JUSBC2.3 ; JUSBC2.3 8.08,55.98 ; JUSBC2.3 8.08,55.2 ; JUSBC2.3 5.62,55.98 ; JUSBC2.3 5.62,56.76 ; JUSBC2.3 8.08,56.76 ; JUSBC2.3 6.85,55.2 ; 13.21,44.3 JUSB1.12 ; JUSB1.12 14.96,45.16 ; JUSB1.12 14.96,43.44 ; JUSB1.12 13.21,43.44 ; JUSB1.12 16.71,44.3 ; JUSB1.12 13.21,45.16 ; JUSB1.12 16.71,45.16 ; JUSB1.12 16.71,43.44 ; 196.27,177.47 JUSBC1.3 ; JUSBC1.3 197.04,179.93 ; JUSBC1.3 197.82,177.47 ; JUSBC1.3 197.04,177.47 ; JUSBC1.3 196.27,179.93 ; JUSBC1.3 197.82,179.93 ; JUSBC1.3 197.82,178.7 ; JUSBC1.2 189.23,185.17 ; JUSBC1.2 187.57,183.75 ; JUSBC1.2 189.23,182.33 ; JUSBC1.2 188.4,182.33 ; JUSBC1.2 187.57,182.33 ; JUSBC1.2 187.57,185.17 ; JUSBC1.2 189.23,183.75 ; JUSBC1.2 188.4,185.17 ; 228.8,177.96 JDP.23 ; JDP.23 228.8,175.34 ; JDP.23 228.8,176.65 ; JDP.23 229.57,175.34 ; JDP.23 230.35,176.65 ; JDP.23 229.57,177.96 ; JDP.23 230.35,175.34 ; JDP.23 230.35,177.96 ; JHDMI.23 226.7,183.33 ; JHDMI.23 224.84,183.33 ; JHDMI.23 224.84,182.05 ; JHDMI.23 225.77,183.33 ; JHDMI.23 225.77,180.77 ; JHDMI.23 224.84,180.77 ; JHDMI.23 226.7,180.77 ; JHDMI.23 226.7,182.05 ; H2.1 125.01,90.9 ; H2.1 122.67,88.56 ; H2.1 124.37,89.2 ; H2.1 120.97,92.6 ; H2.1 120.33,90.9 ; H2.1 122.67,93.24 ; H2.1 124.37,92.6 ; H2.1 120.97,89.2 ; 206.54,179.52 JHDMI.21 ; JHDMI.21 208.4,179.52 ; JHDMI.21 208.4,180.8 ; JHDMI.21 206.54,180.8 ; JHDMI.21 207.47,179.52 ; JHDMI.21 206.54,182.08 ; JHDMI.21 207.47,182.08 ; JHDMI.21 208.4,182.08 ; 6.57,48.87 H9.1 ; H9.1 8.5,50.8 ; H9.1 5.15,52.22 ; H9.1 7.99,52.22 ; H9.1 5.15,49.38 ; H9.1 4.64,50.8 ; H9.1 7.99,49.38 ; H9.1 6.57,52.73 ; JCDRA.48 178.62,180.75 ; JCDRA.48 176.72,183.87 ; JCDRA.48 177.67,180.75 ; JCDRA.48 177.67,183.87 ; JCDRA.48 178.62,182.31 ; JCDRA.48 176.72,182.31 ; JCDRA.48 178.62,183.87 ; JCDRA.48 176.72,180.75 ; 212.16,173.21 JHDMI.2 ; JHDMI.2 212.62,172.17 ; JHDMI.2 212.62,173.33 ; JHDMI.2 213.08,172.29 ; JHDMI.2 212.16,172.29 ; JHDMI.2 212.04,172.75 ; JHDMI.2 213.08,173.21 ; JLAN.14 262.74,179.94 ; JLAN.14 262.74,176.43 ; JLAN.14 261.82,179.94 ; JLAN.14 261.82,178.19 ; JLAN.14 261.82,176.43 ; JLAN.14 263.65,178.19 ; JLAN.14 263.65,179.94 ; JLAN.14 263.65,176.43 ; JCDRA.50 146.12,176.15 ; JCDRA.50 145.17,179.27 ; JCDRA.50 146.12,179.27 ; JCDRA.50 146.12,177.71 ; JCDRA.50 144.22,176.15 ; JCDRA.50 144.22,177.71 ; JCDRA.50 144.22,179.27 ; JCDRA.50 145.17,176.15 ; JUSB1.13 7.71,29.14 ; JUSB1.13 6.2,29.14 ; JUSB1.13 4.69,30 ; JUSB1.13 7.71,30 ; JUSB1.13 4.69,29.14 ; 237.77,173.11 JDP.19 ; JDP.19 237.31,174.15 ; JDP.19 238.24,173.23 ; JDP.19 237.77,174.27 ; JDP.19 237.31,173.23 ; JDP.19 238.24,174.15 ; JDP.19 238.36,173.69
  GND3 w0.203: 177.74,6.5 H6.1 ; H6.1 181.09,7.92 ; H6.1 181.09,5.08 ; H6.1 179.67,4.57 ; H6.1 179.67,8.43 ; H6.1 178.25,7.92 ; H6.1 178.25,5.08 ; H6.1 181.6,6.5 ; JUSBC1.6 196.72,179.92 ; JUSBC1.6 195.81,179.92 ; JUSBC1.6 197.82,179.92 ; JUSBC1.6 197.82,179.2 ; JUSBC1.6 197.82,178.48 ; JDP.19 238.36,173.69 ; JDP.19 237.77,174.27 ; JDP.19 238.24,173.23 ; JDP.19 237.31,174.15 ; JDP.19 237.31,173.23 ; JDP.19 238.24,174.15 ; JDP.19 237.77,173.11 ; JUSBC2.1 8.08,65.4 ; JUSBC2.1 5.62,64.62 ; JUSBC2.1 6.85,65.4 ; JUSBC2.1 8.08,63.84 ; JUSBC2.1 5.62,65.4 ; JUSBC2.1 5.62,63.84 ; JUSBC2.1 8.08,64.62 ; 228.8,171.65 JDP.24 ; JDP.24 229.57,172.96 ; JDP.24 229.57,170.34 ; JDP.24 228.8,170.34 ; JDP.24 228.8,172.96 ; JDP.24 230.35,170.34 ; JDP.24 230.35,171.65 ; JCDRA.50 146.12,177.71 ; JCDRA.50 145.17,176.15 ; JCDRA.50 146.12,179.27 ; JCDRA.50 146.12,176.15 ; JCDRA.50 145.17,179.27 ; JCDRA.50 144.22,177.71 ; JCDRA.50 144.22,176.15 ; JCDRA.50 144.22,179.27 ; JDP.13 236.54,172.95 ; JDP.13 236.07,173.07 ; JDP.13 235.61,172.95 ; JDP.13 236.07,171.91 ; JDP.13 235.61,172.03 ; JDP.13 235.49,172.49 ; JDP.13 236.54,172.03 ; JHDMI.22 224.8,172.6 ; JHDMI.22 223.87,173.88 ; JHDMI.22 223.87,171.32 ; JHDMI.22 224.8,173.88 ; JHDMI.22 222.94,171.32 ; JHDMI.22 224.8,171.32 ; JHDMI.22 222.94,172.6 ; JHDMI.22 222.94,173.88 ; JUSBC1.1 189.18,179.93 ; JUSBC1.1 188.4,177.47 ; JUSBC1.1 188.4,179.93 ; JUSBC1.1 189.18,177.47 ; JUSBC1.1 187.62,179.93 ; JUSBC1.1 187.62,178.7 ; JUSBC1.1 187.62,177.47 ; H21.1 263.49,5.08 ; H21.1 260.14,6.5 ; H21.1 260.65,5.08 ; H21.1 262.07,8.43 ; H21.1 263.49,7.92 ; H21.1 264,6.5 ; H21.1 260.65,7.92 ; H21.1 262.07,4.57 ; 187.57,185.17 JUSBC1.2 ; JUSBC1.2 188.4,185.17 ; JUSBC1.2 189.23,182.33 ; JUSBC1.2 189.23,185.17 ; JUSBC1.2 188.4,182.33 ; JUSBC1.2 187.57,182.33 ; JUSBC1.2 187.57,183.75 ; JUSBC1.2 189.23,183.75 ; H17.1 146.5,171.5 ; H17.1 143.15,170.08 ; H17.1 143.15,172.92 ; H17.1 144.57,173.43 ; H17.1 145.99,172.92 ; H17.1 142.64,171.5 ; H17.1 145.99,170.08 ; H17.1 144.57,169.57 ; 233.61,172.95 JDP.7 ; JDP.7 234.54,172.95 ; JDP.7 234.07,171.91 ; JDP.7 234.07,173.07 ; JDP.7 234.66,172.49 ; JDP.7 234.54,172.03 ; JDP.7 233.61,172.03 ; JUSB1.4 17.14,33.81 ; JUSB1.4 15.79,34.4 ; JUSB1.4 15.96,34.99 ; JUSB1.4 16.55,33.64 ; JUSB1.4 16.55,35.16 ; JUSB1.4 17.14,34.99 ; JUSB1.4 15.96,33.81 ; JUSB1.4 17.31,34.4 ; JUSBC2.3 8.08,55.98 ; JUSBC2.3 6.85,55.2 ; JUSBC2.3 8.08,55.2 ; JUSBC2.3 5.62,55.98 ; JUSBC2.3 5.62,55.2 ; JUSBC2.3 5.62,56.76 ; JUSBC2.3 8.08,56.76 ; JUSB1.11 14.96,32.36 ; JUSB1.11 13.21,31.5 ; JUSB1.11 16.71,32.36 ; JUSB1.11 13.21,30.64 ; JUSB1.11 13.21,32.36 ; JUSB1.11 16.71,30.64 ; JUSB1.11 16.71,31.5 ; JUSB1.11 14.96,30.64 ; 206.54,179.52 JHDMI.21 ; JHDMI.21 206.54,182.08 ; JHDMI.21 207.47,182.08 ; JHDMI.21 208.4,182.08 ; JHDMI.21 207.47,179.52 ; JHDMI.21 208.4,179.52 ; JHDMI.21 208.4,180.8 ; JHDMI.21 206.54,180.8 ; JCDRA.48 178.62,182.31 ; JCDRA.48 177.67,183.87 ; JCDRA.48 177.67,180.75 ; JCDRA.48 176.72,180.75 ; JCDRA.48 178.62,183.87 ; JCDRA.48 176.72,182.31 ; JCDRA.48 176.72,183.87 ; JCDRA.48 178.62,180.75 ; JDP.23 230.35,176.65 ; JDP.23 228.8,176.65 ; JDP.23 228.8,177.96 ; JDP.23 230.35,175.34 ; JDP.23 228.8,175.34 ; JDP.23 230.35,177.96 ; JDP.23 229.57,175.34 ; JDP.23 229.57,177.96 ; 269.07,148.16 H7.1 ; H7.1 267.37,148.8 ; H7.1 267.37,152.2 ; H7.1 269.07,152.84 ; H7.1 266.73,150.5 ; H7.1 270.77,152.2 ; H7.1 270.77,148.8 ; H7.1 271.41,150.5 ; H5.1 278.41,43.5 ; H5.1 274.37,41.8 ; H5.1 277.77,45.2 ; H5.1 273.73,43.5 ; H5.1 276.07,45.84 ; H5.1 276.07,41.16 ; H5.1 277.77,41.8 ; H5.1 274.37,45.2 ; 196.27,177.47 JUSBC1.3 ; JUSBC1.3 197.82,178.7 ; JUSBC1.3 197.82,179.93 ; JUSBC1.3 196.27,179.93 ; JUSBC1.3 197.04,177.47 ; JUSBC1.3 197.04,179.93 ; JUSBC1.3 197.82,177.47 ; JUSB1.14 6.2,46.66 ; JUSB1.14 4.69,45.8 ; JUSB1.14 7.71,46.66 ; JUSB1.14 7.71,45.8 ; JUSB1.14 4.69,46.66 ; H15.1 184.64,181.52 ; H15.1 183.22,178.17 ; H15.1 183.22,182.03 ; H15.1 181.8,178.68 ; H15.1 181.8,181.52 ; H15.1 184.64,178.68 ; H15.1 185.15,180.1 ; H15.1 181.29,180.1 ; 20.44,9.87 H11.1 ; H11.1 22.07,9.26 ; H11.1 23.7,9.87 ; H11.1 19.83,11.5 ; H11.1 23.7,13.13 ; H11.1 24.31,11.5 ; H11.1 22.07,13.74 ; H11.1 20.44,13.13 ; 213.66,174.76 JHDMI.5 ; JHDMI.5 213.66,173.84 ; JHDMI.5 214.12,173.72 ; JHDMI.5 214.12,174.88 ; JHDMI.5 214.58,174.76 ; JHDMI.5 214.58,173.84 ; 212.62,172.17 JHDMI.2 ; JHDMI.2 212.62,173.33 ; JHDMI.2 212.16,172.29 ; JHDMI.2 213.08,172.29 ; JHDMI.2 212.16,173.21 ; JHDMI.2 213.08,173.21 ; JHDMI.2 212.04,172.75 ; H16.1 24,4.2 ; H16.1 22.07,6.13 ; H16.1 20.14,4.2 ; H16.1 20.65,2.78 ; H16.1 22.07,2.27 ; H16.1 20.65,5.62 ; H16.1 23.49,5.62 ; H16.1 23.49,2.78 ; JUSBC1.5 189.63,179.2 ; JUSBC1.5 187.62,178.48 ; JUSBC1.5 188.73,179.92 ; JUSBC1.5 187.62,179.2 ; JUSBC1.5 187.62,179.92 ; JUSBC1.5 189.63,178.48 ; JUSBC1.5 189.63,179.92 ; 144.22,183.87 JCDRA.49 ; JCDRA.49 146.12,180.75 ; JCDRA.49 144.22,180.75 ; JCDRA.49 144.22,182.31 ; JCDRA.49 145.17,183.87 ; JCDRA.49 145.17,180.75 ; JCDRA.49 146.12,182.31 ; JCDRA.49 146.12,183.87 ; JUSB1.12 16.71,44.3 ; JUSB1.12 13.21,43.44 ; JUSB1.12 13.21,44.3 ; JUSB1.12 14.96,45.16 ; JUSB1.12 13.21,45.16 ; JUSB1.12 16.71,43.44 ; JUSB1.12 14.96,43.44 ; JUSB1.12 16.71,45.16 ; JUSBC2.6 6.35,57.21 ; JUSBC2.6 5.63,57.21 ; JUSBC2.6 7.07,57.21 ; JUSBC2.6 6.35,55.2 ; JUSBC2.6 5.63,56.3 ; JUSBC2.6 7.07,55.2 ; JUSBC2.6 5.63,55.2 ; 261.82,176.43 JLAN.14 ; JLAN.14 263.65,178.19 ; JLAN.14 262.74,176.43 ; JLAN.14 261.82,178.19 ; JLAN.14 263.65,179.94 ; JLAN.14 261.82,179.94 ; JLAN.14 263.65,176.43 ; JLAN.14 262.74,179.94 ; JUSBC1.4 197.87,182.33 ; JUSBC1.4 196.21,185.17 ; JUSBC1.4 197.87,183.75 ; JUSBC1.4 197.87,185.17 ; JUSBC1.4 196.21,182.33 ; JUSBC1.4 197.04,182.33 ; JUSBC1.4 196.21,183.75 ; JUSBC1.4 197.04,185.17 ; JCDRA.47 177.67,179.27 ; JCDRA.47 177.67,176.15 ; JCDRA.47 178.62,176.15 ; JCDRA.47 176.72,176.15 ; JCDRA.47 176.72,177.71 ; JCDRA.47 178.62,179.27 ; JCDRA.47 176.72,179.27 ; JCDRA.47 178.62,177.71 ; JLAN.16 244.6,179.94 ; JLAN.16 244.6,176.43 ; JLAN.16 243.69,179.94 ; JLAN.16 244.6,178.19 ; JLAN.16 242.77,179.94 ; JLAN.16 242.77,178.19 ; JLAN.16 242.77,176.43 ; JLAN.16 243.69,176.43 ; 100.65,5.08 H18.1 ; H18.1 102.07,8.43 ; H18.1 103.49,5.08 ; H18.1 104,6.5 ; H18.1 100.14,6.5 ; H18.1 102.07,4.57 ; H18.1 103.49,7.92 ; H18.1 100.65,7.92 ; 216.66,173.84 JHDMI.11 ; JHDMI.11 217.58,174.76 ; JHDMI.11 217.12,174.88 ; JHDMI.11 217.12,173.72 ; JHDMI.11 216.66,174.76 ; JHDMI.11 217.58,173.84 ; H22.1 197.87,57.53 ; H22.1 199.29,54.18 ; H22.1 195.94,55.6 ; H22.1 196.45,57.02 ; H22.1 199.8,55.6 ; H22.1 196.45,54.18 ; H22.1 197.87,53.67 ; H22.1 199.29,57.02 ; 117.97,158.36 JPCMC.36 ; JPCMC.36 119.77,159.04 ; JPCMC.36 119.77,154.08 ; JPCMC.36 122.25,156.56 ; JPCMC.36 121.57,154.76 ; JPCMC.36 117.97,154.76 ; JHDMI.8 216.08,172.29 ; JHDMI.8 215.62,173.33 ; JHDMI.8 216.08,173.21 ; JHDMI.8 215.62,172.17 ; JHDMI.8 215.16,173.21 ; JHDMI.8 215.16,172.29 ; 197.33,154.53 H13.1 ; H13.1 197.33,152 ; H13.1 197.33,149.47 ; H13.1 201.81,149.47 ; H13.1 201.81,154.53 ; H13.1 199.57,149.47 ; H13.1 199.57,154.53 ; H13.1 201.81,152 ; H23.1 267.97,8.74 ; H23.1 265.49,4.26 ; H23.1 270.45,6.5 ; H23.1 267.97,4.26 ; H23.1 265.49,6.5 ; H23.1 270.45,8.74 ; H23.1 265.49,8.74 ; H23.1 270.45,4.26 ; JDP.21 240.57,177.96 ; JDP.21 240.57,175.34 ; JDP.21 241.35,176.65 ; JDP.21 239.8,177.96 ; JDP.21 241.35,175.34 ; JDP.21 239.8,176.65 ; JDP.21 239.8,175.34 ; JDP.21 241.35,177.96 ; 3.14,69.8 H8.1 ; H8.1 5.07,67.87 ; H8.1 3.65,71.22 ; H8.1 6.49,71.22 ; H8.1 5.07,71.73 ; H8.1 6.49,68.38 ; H8.1 7,69.8 ; H8.1 3.65,68.38 ; JHDMI.23 226.7,183.33 ; JHDMI.23 224.84,182.05 ; JHDMI.23 225.77,183.33 ; JHDMI.23 224.84,180.77 ; JHDMI.23 225.77,180.77 ; JHDMI.23 224.84,183.33 ; JHDMI.23 226.7,180.77 ; JHDMI.23 226.7,182.05 ; JDP.22 241.35,172.96 ; JDP.22 241.35,170.34 ; JDP.22 240.57,172.96 ; JDP.22 241.35,171.65 ; JDP.22 239.8,171.65 ; JDP.22 239.8,170.34 ; JDP.22 240.57,170.34 ; H3.1 183.3,88.67 ; H3.1 180.04,91.93 ; H3.1 181.67,88.06 ; H3.1 183.3,91.93 ; H3.1 180.04,88.67 ; H3.1 179.43,90.3 ; H3.1 183.91,90.3 ; H3.1 181.67,92.54 ; 220.12,173.72 JHDMI.17 ; JHDMI.17 220.58,173.84 ; JHDMI.17 219.66,173.84 ; JHDMI.17 220.58,174.76 ; JHDMI.17 219.66,174.76 ; JHDMI.17 220.12,174.88 ; H14.1 203.64,181.52 ; H14.1 200.29,180.1 ; H14.1 203.64,178.68 ; H14.1 202.22,178.17 ; H14.1 202.22,182.03 ; H14.1 200.8,178.68 ; H14.1 200.8,181.52 ; H14.1 204.15,180.1 ; H10.1 28.07,55.93 ; H10.1 29.49,55.42 ; H10.1 26.65,55.42 ; H10.1 26.65,52.58 ; H10.1 29.49,52.58 ; H10.1 26.14,54 ; H10.1 30,54 ; H10.1 28.07,52.07 ; H1.1 161.87,153.9 ; H1.1 161.87,157.3 ; H1.1 162.51,155.6 ; H1.1 158.47,153.9 ; H1.1 160.17,153.26 ; H1.1 158.47,157.3 ; H1.1 160.17,157.94 ; H1.1 157.83,155.6 ; 120.97,92.6 H2.1 ; H2.1 124.37,89.2 ; H2.1 122.67,88.56 ; H2.1 120.97,89.2 ; H2.1 120.33,90.9 ; H2.1 125.01,90.9 ; H2.1 122.67,93.24 ; H2.1 124.37,92.6 ; 5.63,64.3 JUSBC2.5 ; JUSBC2.5 6.35,63.39 ; JUSBC2.5 7.07,65.4 ; JUSBC2.5 6.35,65.4 ; JUSBC2.5 7.07,63.39 ; JUSBC2.5 5.63,65.4 ; JUSBC2.5 5.63,63.39 ; 297.87,74.32 H20.1 ; H20.1 296.45,74.83 ; H20.1 299.8,76.25 ; H20.1 299.29,74.83 ; H20.1 299.29,77.67 ; H20.1 295.94,76.25 ; H20.1 297.87,78.18 ; H20.1 296.45,77.67 ; JUSB1.13 7.71,29.14 ; JUSB1.13 7.71,30 ; JUSB1.13 6.2,29.14 ; JUSB1.13 4.69,30 ; JUSB1.13 4.69,29.14 ; 203.37,50.2 H4.1 ; H4.1 206.77,50.2 ; H4.1 207.41,48.5 ; H4.1 205.07,50.84 ; H4.1 203.37,46.8 ; H4.1 206.77,46.8 ; H4.1 205.07,46.16 ; H4.1 202.73,48.5 ; JUSBC2.4 3.22,56.81 ; JUSBC2.4 0.38,55.98 ; JUSBC2.4 3.22,55.98 ; JUSBC2.4 3.22,55.15 ; JUSBC2.4 0.38,55.15 ; JUSBC2.4 0.38,56.81 ; JUSBC2.4 1.8,56.81 ; JUSBC2.4 1.8,55.15 ; 6.57,48.87 H9.1 ; H9.1 8.5,50.8 ; H9.1 7.99,52.22 ; H9.1 7.99,49.38 ; H9.1 5.15,52.22 ; H9.1 4.64,50.8 ; H9.1 6.57,52.73 ; H9.1 5.15,49.38 ; H12.1 277.59,172.02 ; H12.1 278.1,170.6 ; H12.1 274.24,170.6 ; H12.1 277.59,169.18 ; H12.1 276.17,172.53 ; H12.1 274.75,169.18 ; H12.1 276.17,168.67 ; H12.1 274.75,172.02 ; JUSB1.7 15.05,38.66 ; JUSB1.7 14.29,37.9 ; JUSB1.7 14.46,38.49 ; JUSB1.7 15.64,37.31 ; JUSB1.7 15.05,37.14 ; JUSB1.7 15.64,38.49 ; JUSB1.7 14.46,37.31 ; JUSB1.7 15.81,37.9 ; H19.1 92.87,58.83 ; H19.1 91.45,58.32 ; H19.1 90.94,56.9 ; H19.1 94.29,58.32 ; H19.1 91.45,55.48 ; H19.1 92.87,54.97 ; H19.1 94.29,55.48 ; H19.1 94.8,56.9 ; 231.91,174.15 JDP.1 ; JDP.1 232.84,173.23 ; JDP.1 232.37,174.27 ; JDP.1 232.37,173.11 ; JDP.1 232.84,174.15 ; JDP.1 231.91,173.23 ; JDP.1 231.79,173.69 ; 0.38,65.45 JUSBC2.2 ; JUSBC2.2 3.22,64.62 ; JUSBC2.2 3.22,63.79 ; JUSBC2.2 0.38,64.62 ; JUSBC2.2 3.22,65.45 ; JUSBC2.2 1.8,65.45 ; JUSBC2.2 0.38,63.79 ; JUSBC2.2 1.8,63.79 ; JHDMI.20 209.37,173.88 ; JHDMI.20 209.37,171.32 ; JHDMI.20 208.44,171.32 ; JHDMI.20 210.3,173.88 ; JHDMI.20 208.44,173.88 ; JHDMI.20 208.44,172.6 ; JHDMI.20 210.3,172.6
  GND4 w0.203: H1.1 160.17,157.94 ; H1.1 162.51,155.6 ; H1.1 161.87,153.9 ; H1.1 161.87,157.3 ; H1.1 157.83,155.6 ; H1.1 160.17,153.26 ; H1.1 158.47,157.3 ; H1.1 158.47,153.9 ; JUSBC1.1 189.18,179.93 ; JUSBC1.1 187.62,179.93 ; JUSBC1.1 188.4,177.47 ; JUSBC1.1 189.18,177.47 ; JUSBC1.1 188.4,179.93 ; JUSBC1.1 187.62,177.47 ; JUSBC1.1 187.62,178.7 ; 4.69,45.8 JUSB1.14 ; JUSB1.14 4.69,46.66 ; JUSB1.14 6.2,46.66 ; JUSB1.14 7.71,46.66 ; JUSB1.14 7.71,45.8 ; JUSB1.7 15.64,37.31 ; JUSB1.7 15.05,37.14 ; JUSB1.7 15.81,37.9 ; JUSB1.7 14.46,37.31 ; JUSB1.7 15.05,38.66 ; JUSB1.7 14.46,38.49 ; JUSB1.7 14.29,37.9 ; JUSB1.7 15.64,38.49 ; H9.1 6.57,52.73 ; H9.1 7.99,49.38 ; H9.1 6.57,48.87 ; H9.1 7.99,52.22 ; H9.1 8.5,50.8 ; H9.1 5.15,49.38 ; H9.1 4.64,50.8 ; H9.1 5.15,52.22 ; 231.91,173.23 JDP.1 ; JDP.1 232.37,173.11 ; JDP.1 231.79,173.69 ; JDP.1 232.84,174.15 ; JDP.1 232.37,174.27 ; JDP.1 231.91,174.15 ; JDP.1 232.84,173.23 ; JUSB1.11 16.71,32.36 ; JUSB1.11 14.96,30.64 ; JUSB1.11 13.21,32.36 ; JUSB1.11 13.21,30.64 ; JUSB1.11 16.71,31.5 ; JUSB1.11 14.96,32.36 ; JUSB1.11 13.21,31.5 ; JUSB1.11 16.71,30.64 ; 208.44,172.6 JHDMI.20 ; JHDMI.20 209.37,171.32 ; JHDMI.20 209.37,173.88 ; JHDMI.20 208.44,173.88 ; JHDMI.20 208.44,171.32 ; JHDMI.20 210.3,172.6 ; JHDMI.20 210.3,173.88 ; JHDMI.21 208.4,180.8 ; JHDMI.21 208.4,179.52 ; JHDMI.21 206.54,182.08 ; JHDMI.21 206.54,180.8 ; JHDMI.21 208.4,182.08 ; JHDMI.21 207.47,179.52 ; JHDMI.21 206.54,179.52 ; JHDMI.21 207.47,182.08 ; H10.1 30,54 ; H10.1 29.49,55.42 ; H10.1 29.49,52.58 ; H10.1 26.65,52.58 ; H10.1 26.65,55.42 ; H10.1 28.07,52.07 ; H10.1 28.07,55.93 ; H10.1 26.14,54 ; 181.8,178.68 H15.1 ; H15.1 183.22,182.03 ; H15.1 183.22,178.17 ; H15.1 185.15,180.1 ; H15.1 181.8,181.52 ; H15.1 184.64,181.52 ; H15.1 184.64,178.68 ; H15.1 181.29,180.1 ; JCDRA.47 178.62,177.71 ; JCDRA.47 176.72,177.71 ; JCDRA.47 176.72,179.27 ; JCDRA.47 178.62,176.15 ; JCDRA.47 178.62,179.27 ; JCDRA.47 177.67,176.15 ; JCDRA.47 177.67,179.27 ; JCDRA.47 176.72,176.15 ; 228.8,175.34 JDP.23 ; JDP.23 230.35,177.96 ; JDP.23 229.57,177.96 ; JDP.23 228.8,176.65 ; JDP.23 230.35,175.34 ; JDP.23 229.57,175.34 ; JDP.23 230.35,176.65 ; JDP.23 228.8,177.96 ; JUSBC2.2 3.22,64.62 ; JUSBC2.2 0.38,64.62 ; JUSBC2.2 3.22,65.45 ; JUSBC2.2 1.8,63.79 ; JUSBC2.2 1.8,65.45 ; JUSBC2.2 0.38,63.79 ; JUSBC2.2 3.22,63.79 ; JUSBC2.2 0.38,65.45 ; 195.81,179.92 JUSBC1.6 ; JUSBC1.6 197.82,179.92 ; JUSBC1.6 196.72,179.92 ; JUSBC1.6 197.82,179.2 ; JUSBC1.6 197.82,178.48 ; JDP.7 234.07,173.07 ; JDP.7 234.54,172.95 ; JDP.7 234.54,172.03 ; JDP.7 233.61,172.03 ; JDP.7 234.07,171.91 ; JDP.7 234.66,172.49 ; JDP.7 233.61,172.95 ; 200.8,181.52 H14.1 ; H14.1 203.64,178.68 ; H14.1 202.22,178.17 ; H14.1 203.64,181.52 ; H14.1 204.15,180.1 ; H14.1 200.29,180.1 ; H14.1 200.8,178.68 ; H14.1 202.22,182.03 ; 176.72,183.87 JCDRA.48 ; JCDRA.48 176.72,180.75 ; JCDRA.48 177.67,183.87 ; JCDRA.48 178.62,182.31 ; JCDRA.48 176.72,182.31 ; JCDRA.48 178.62,180.75 ; JCDRA.48 177.67,180.75 ; JCDRA.48 178.62,183.87 ; 222.94,173.88 JHDMI.22 ; JHDMI.22 223.87,173.88 ; JHDMI.22 224.8,171.32 ; JHDMI.22 224.8,172.6 ; JHDMI.22 222.94,171.32 ; JHDMI.22 224.8,173.88 ; JHDMI.22 223.87,171.32 ; JHDMI.22 222.94,172.6 ; 5.63,55.2 JUSBC2.6 ; JUSBC2.6 6.35,55.2 ; JUSBC2.6 6.35,57.21 ; JUSBC2.6 5.63,56.3 ; JUSBC2.6 7.07,55.2 ; JUSBC2.6 5.63,57.21 ; JUSBC2.6 7.07,57.21 ; JCDRA.49 146.12,183.87 ; JCDRA.49 144.22,183.87 ; JCDRA.49 144.22,182.31 ; JCDRA.49 145.17,180.75 ; JCDRA.49 146.12,180.75 ; JCDRA.49 144.22,180.75 ; JCDRA.49 145.17,183.87 ; JCDRA.49 146.12,182.31 ; JDP.19 238.24,174.15 ; JDP.19 238.36,173.69 ; JDP.19 237.31,173.23 ; JDP.19 237.31,174.15 ; JDP.19 238.24,173.23 ; JDP.19 237.77,173.11 ; JDP.19 237.77,174.27 ; H7.1 270.77,152.2 ; H7.1 267.37,148.8 ; H7.1 271.41,150.5 ; H7.1 269.07,152.84 ; H7.1 266.73,150.5 ; H7.1 269.07,148.16 ; H7.1 270.77,148.8 ; H7.1 267.37,152.2 ; JHDMI.17 220.58,174.76 ; JHDMI.17 219.66,174.76 ; JHDMI.17 220.12,174.88 ; JHDMI.17 220.12,173.72 ; JHDMI.17 220.58,173.84 ; JHDMI.17 219.66,173.84 ; 120.97,92.6 H2.1 ; H2.1 122.67,88.56 ; H2.1 125.01,90.9 ; H2.1 124.37,92.6 ; H2.1 124.37,89.2 ; H2.1 120.97,89.2 ; H2.1 122.67,93.24 ; H2.1 120.33,90.9 ; 13.21,44.3 JUSB1.12 ; JUSB1.12 14.96,45.16 ; JUSB1.12 16.71,45.16 ; JUSB1.12 13.21,45.16 ; JUSB1.12 16.71,43.44 ; JUSB1.12 13.21,43.44 ; JUSB1.12 16.71,44.3 ; JUSB1.12 14.96,43.44 ; JDP.13 236.07,173.07 ; JDP.13 235.61,172.03 ; JDP.13 235.61,172.95 ; JDP.13 235.49,172.49 ; JDP.13 236.54,172.03 ; JDP.13 236.07,171.91 ; JDP.13 236.54,172.95 ; JUSBC1.2 189.23,185.17 ; JUSBC1.2 188.4,185.17 ; JUSBC1.2 187.57,183.75 ; JUSBC1.2 189.23,182.33 ; JUSBC1.2 188.4,182.33 ; JUSBC1.2 187.57,185.17 ; JUSBC1.2 189.23,183.75 ; JUSBC1.2 187.57,182.33 ; 295.94,76.25 H20.1 ; H20.1 297.87,78.18 ; H20.1 299.29,74.83 ; H20.1 296.45,74.83 ; H20.1 297.87,74.32 ; H20.1 299.8,76.25 ; H20.1 296.45,77.67 ; H20.1 299.29,77.67 ; H22.1 197.87,57.53 ; H22.1 199.29,57.02 ; H22.1 199.29,54.18 ; H22.1 199.8,55.6 ; H22.1 195.94,55.6 ; H22.1 196.45,57.02 ; H22.1 196.45,54.18 ; H22.1 197.87,53.67 ; H4.1 206.77,46.8 ; H4.1 207.41,48.5 ; H4.1 202.73,48.5 ; H4.1 205.07,46.16 ; H4.1 205.07,50.84 ; H4.1 203.37,46.8 ; H4.1 206.77,50.2 ; H4.1 203.37,50.2 ; JHDMI.5 214.12,174.88 ; JHDMI.5 214.58,173.84 ; JHDMI.5 213.66,173.84 ; JHDMI.5 214.12,173.72 ; JHDMI.5 213.66,174.76 ; JHDMI.5 214.58,174.76 ; 239.8,175.34 JDP.21 ; JDP.21 240.57,175.34 ; JDP.21 241.35,177.96 ; JDP.21 239.8,176.65 ; JDP.21 241.35,176.65 ; JDP.21 240.57,177.96 ; JDP.21 239.8,177.96 ; JDP.21 241.35,175.34 ; 5.63,65.4 JUSBC2.5 ; JUSBC2.5 5.63,63.39 ; JUSBC2.5 6.35,65.4 ; JUSBC2.5 5.63,64.3 ; JUSBC2.5 6.35,63.39 ; JUSBC2.5 7.07,63.39 ; JUSBC2.5 7.07,65.4 ; JUSBC2.3 8.08,55.98 ; JUSBC2.3 5.62,55.98 ; JUSBC2.3 5.62,55.2 ; JUSBC2.3 6.85,55.2 ; JUSBC2.3 8.08,55.2 ; JUSBC2.3 8.08,56.76 ; JUSBC2.3 5.62,56.76 ; 260.14,6.5 H21.1 ; H21.1 262.07,4.57 ; H21.1 263.49,5.08 ; H21.1 264,6.5 ; H21.1 260.65,7.92 ; H21.1 263.49,7.92 ; H21.1 260.65,5.08 ; H21.1 262.07,8.43 ; JPCMC.36 122.25,156.56 ; JPCMC.36 121.57,154.76 ; JPCMC.36 119.77,154.08 ; JPCMC.36 117.97,154.76 ; JPCMC.36 117.97,158.36 ; JPCMC.36 119.77,159.04 ; 215.62,172.17 JHDMI.8 ; JHDMI.8 215.16,172.29 ; JHDMI.8 215.16,173.21 ; JHDMI.8 215.62,173.33 ; JHDMI.8 216.08,173.21 ; JHDMI.8 216.08,172.29 ; 5.62,65.4 JUSBC2.1 ; JUSBC2.1 8.08,63.84 ; JUSBC2.1 6.85,65.4 ; JUSBC2.1 5.62,63.84 ; JUSBC2.1 8.08,65.4 ; JUSBC2.1 5.62,64.62 ; JUSBC2.1 8.08,64.62 ; 228.8,172.96 JDP.24 ; JDP.24 230.35,171.65 ; JDP.24 228.8,171.65 ; JDP.24 230.35,170.34 ; JDP.24 228.8,170.34 ; JDP.24 229.57,172.96 ; JDP.24 229.57,170.34 ; 267.97,4.26 H23.1 ; H23.1 270.45,4.26 ; H23.1 265.49,6.5 ; H23.1 270.45,8.74 ; H23.1 265.49,4.26 ; H23.1 265.49,8.74 ; H23.1 270.45,6.5 ; H23.1 267.97,8.74 ; H16.1 23.49,2.78 ; H16.1 22.07,6.13 ; H16.1 20.14,4.2 ; H16.1 22.07,2.27 ; H16.1 24,4.2 ; H16.1 23.49,5.62 ; H16.1 20.65,2.78 ; H16.1 20.65,5.62 ; JUSBC1.5 189.63,179.2 ; JUSBC1.5 187.62,179.2 ; JUSBC1.5 187.62,178.48 ; JUSBC1.5 189.63,178.48 ; JUSBC1.5 189.63,179.92 ; JUSBC1.5 187.62,179.92 ; JUSBC1.5 188.73,179.92 ; 273.73,43.5 H5.1 ; H5.1 276.07,41.16 ; H5.1 277.77,41.8 ; H5.1 274.37,41.8 ; H5.1 274.37,45.2 ; H5.1 276.07,45.84 ; H5.1 278.41,43.5 ; H5.1 277.77,45.2 ; JHDMI.2 213.08,173.21 ; JHDMI.2 213.08,172.29 ; JHDMI.2 212.16,173.21 ; JHDMI.2 212.16,172.29 ; JHDMI.2 212.62,173.33 ; JHDMI.2 212.04,172.75 ; JHDMI.2 212.62,172.17 ; 181.67,88.06 H3.1 ; H3.1 183.3,91.93 ; H3.1 181.67,92.54 ; H3.1 183.91,90.3 ; H3.1 180.04,88.67 ; H3.1 183.3,88.67 ; H3.1 179.43,90.3 ; H3.1 180.04,91.93 ; H19.1 94.8,56.9 ; H19.1 94.29,55.48 ; H19.1 92.87,58.83 ; H19.1 94.29,58.32 ; H19.1 91.45,55.48 ; H19.1 90.94,56.9 ; H19.1 92.87,54.97 ; H19.1 91.45,58.32 ; H8.1 7,69.8 ; H8.1 5.07,71.73 ; H8.1 3.14,69.8 ; H8.1 6.49,68.38 ; H8.1 3.65,71.22 ; H8.1 5.07,67.87 ; H8.1 3.65,68.38 ; H8.1 6.49,71.22 ; 261.82,179.94 JLAN.14 ; JLAN.14 263.65,179.94 ; JLAN.14 262.74,176.43 ; JLAN.14 262.74,179.94 ; JLAN.14 261.82,178.19 ; JLAN.14 263.65,176.43 ; JLAN.14 263.65,178.19 ; JLAN.14 261.82,176.43 ; 22.07,9.26 H11.1 ; H11.1 24.31,11.5 ; H11.1 20.44,13.13 ; H11.1 23.7,9.87 ; H11.1 23.7,13.13 ; H11.1 19.83,11.5 ; H11.1 22.07,13.74 ; H11.1 20.44,9.87 ; H18.1 102.07,8.43 ; H18.1 104,6.5 ; H18.1 103.49,7.92 ; H18.1 103.49,5.08 ; H18.1 102.07,4.57 ; H18.1 100.65,5.08 ; H18.1 100.65,7.92 ; H18.1 100.14,6.5 ; JHDMI.11 217.58,174.76 ; JHDMI.11 216.66,174.76 ; JHDMI.11 216.66,173.84 ; JHDMI.11 217.12,173.72 ; JHDMI.11 217.58,173.84 ; JHDMI.11 217.12,174.88 ; 243.69,176.43 JLAN.16 ; JLAN.16 244.6,176.43 ; JLAN.16 242.77,179.94 ; JLAN.16 243.69,179.94 ; JLAN.16 244.6,178.19 ; JLAN.16 242.77,176.43 ; JLAN.16 242.77,178.19 ; JLAN.16 244.6,179.94 ; JCDRA.50 145.17,179.27 ; JCDRA.50 146.12,179.27 ; JCDRA.50 145.17,176.15 ; JCDRA.50 144.22,177.71 ; JCDRA.50 144.22,179.27 ; JCDRA.50 144.22,176.15 ; JCDRA.50 146.12,177.71 ; JCDRA.50 146.12,176.15 ; 224.84,180.77 JHDMI.23 ; JHDMI.23 226.7,183.33 ; JHDMI.23 226.7,180.77 ; JHDMI.23 224.84,182.05 ; JHDMI.23 224.84,183.33 ; JHDMI.23 225.77,183.33 ; JHDMI.23 226.7,182.05 ; JHDMI.23 225.77,180.77 ; 197.33,154.53 H13.1 ; H13.1 197.33,149.47 ; H13.1 201.81,154.53 ; H13.1 199.57,154.53 ; H13.1 199.57,149.47 ; H13.1 201.81,152 ; H13.1 201.81,149.47 ; H13.1 197.33,152 ; H6.1 179.67,8.43 ; H6.1 178.25,7.92 ; H6.1 177.74,6.5 ; H6.1 181.09,7.92 ; H6.1 178.25,5.08 ; H6.1 181.09,5.08 ; H6.1 179.67,4.57 ; H6.1 181.6,6.5 ; H17.1 145.99,172.92 ; H17.1 143.15,170.08 ; H17.1 145.99,170.08 ; H17.1 142.64,171.5 ; H17.1 144.57,169.57 ; H17.1 143.15,172.92 ; H17.1 144.57,173.43 ; H17.1 146.5,171.5 ; H12.1 277.59,169.18 ; H12.1 277.59,172.02 ; H12.1 278.1,170.6 ; H12.1 276.17,168.67 ; H12.1 274.24,170.6 ; H12.1 274.75,172.02 ; H12.1 276.17,172.53 ; H12.1 274.75,169.18 ; 239.8,170.34 JDP.22 ; JDP.22 239.8,171.65 ; JDP.22 241.35,171.65 ; JDP.22 241.35,170.34 ; JDP.22 240.57,172.96 ; JDP.22 240.57,170.34 ; JDP.22 241.35,172.96 ; JUSBC1.4 197.87,182.33 ; JUSBC1.4 197.87,183.75 ; JUSBC1.4 197.04,185.17 ; JUSBC1.4 196.21,182.33 ; JUSBC1.4 197.87,185.17 ; JUSBC1.4 197.04,182.33 ; JUSBC1.4 196.21,185.17 ; JUSBC1.4 196.21,183.75 ; 4.69,29.14 JUSB1.13 ; JUSB1.13 7.71,30 ; JUSB1.13 6.2,29.14 ; JUSB1.13 4.69,30 ; JUSB1.13 7.71,29.14 ; 15.79,34.4 JUSB1.4 ; JUSB1.4 17.14,34.99 ; JUSB1.4 16.55,35.16 ; JUSB1.4 17.14,33.81 ; JUSB1.4 16.55,33.64 ; JUSB1.4 15.96,33.81 ; JUSB1.4 15.96,34.99 ; JUSB1.4 17.31,34.4 ; 0.38,56.81 JUSBC2.4 ; JUSBC2.4 0.38,55.15 ; JUSBC2.4 3.22,55.98 ; JUSBC2.4 3.22,56.81 ; JUSBC2.4 3.22,55.15 ; JUSBC2.4 1.8,56.81 ; JUSBC2.4 1.8,55.15 ; JUSBC2.4 0.38,55.98 ; 197.04,177.47 JUSBC1.3 ; JUSBC1.3 197.82,177.47 ; JUSBC1.3 196.27,179.93 ; JUSBC1.3 197.82,178.7 ; JUSBC1.3 197.04,179.93 ; JUSBC1.3 196.27,177.47 ; JUSBC1.3 197.82,179.93
  IN4 w0.508: v1(229.05,175.1) 229.57,175.62 JDP.23
  GND5 w0.203: JUSB1.11 16.71,30.64 ; JUSB1.11 13.21,30.64 ; JUSB1.11 13.21,31.5 ; JUSB1.11 16.71,32.36 ; JUSB1.11 13.21,32.36 ; JUSB1.11 14.96,32.36 ; JUSB1.11 14.96,30.64 ; JUSB1.11 16.71,31.5 ; 179.67,4.57 H6.1 ; H6.1 178.25,7.92 ; H6.1 178.25,5.08 ; H6.1 179.67,8.43 ; H6.1 181.09,7.92 ; H6.1 181.09,5.08 ; H6.1 177.74,6.5 ; H6.1 181.6,6.5 ; JCDRA.49 146.12,180.75 ; JCDRA.49 146.12,182.31 ; JCDRA.49 144.22,183.87 ; JCDRA.49 146.12,183.87 ; JCDRA.49 145.17,183.87 ; JCDRA.49 145.17,180.75 ; JCDRA.49 144.22,182.31 ; JCDRA.49 144.22,180.75 ; 176.72,182.31 JCDRA.48 ; JCDRA.48 177.67,180.75 ; JCDRA.48 178.62,183.87 ; JCDRA.48 178.62,180.75 ; JCDRA.48 176.72,180.75 ; JCDRA.48 176.72,183.87 ; JCDRA.48 178.62,182.31 ; JCDRA.48 177.67,183.87 ; 297.87,74.32 H20.1 ; H20.1 299.29,74.83 ; H20.1 296.45,77.67 ; H20.1 299.8,76.25 ; H20.1 296.45,74.83 ; H20.1 295.94,76.25 ; H20.1 297.87,78.18 ; H20.1 299.29,77.67 ; JUSBC1.3 197.82,178.7 ; JUSBC1.3 197.04,177.47 ; JUSBC1.3 197.82,179.93 ; JUSBC1.3 196.27,179.93 ; JUSBC1.3 196.27,177.47 ; JUSBC1.3 197.82,177.47 ; JUSBC1.3 197.04,179.93 ; 5.62,64.62 JUSBC2.1 ; JUSBC2.1 6.85,65.4 ; JUSBC2.1 8.08,65.4 ; JUSBC2.1 5.62,65.4 ; JUSBC2.1 8.08,63.84 ; JUSBC2.1 5.62,63.84 ; JUSBC2.1 8.08,64.62 ; 217.12,173.72 JHDMI.11 ; JHDMI.11 217.58,173.84 ; JHDMI.11 217.58,174.76 ; JHDMI.11 217.12,174.88 ; JHDMI.11 216.66,174.76 ; JHDMI.11 216.66,173.84 ; JDP.1 232.84,174.15 ; JDP.1 231.91,173.23 ; JDP.1 232.84,173.23 ; JDP.1 232.37,174.27 ; JDP.1 231.79,173.69 ; JDP.1 232.37,173.11 ; JDP.1 231.91,174.15 ; JDP.13 236.07,173.07 ; JDP.13 236.54,172.03 ; JDP.13 235.61,172.03 ; JDP.13 235.49,172.49 ; JDP.13 235.61,172.95 ; JDP.13 236.54,172.95 ; JDP.13 236.07,171.91 ; 187.57,182.33 JUSBC1.2 ; JUSBC1.2 189.23,185.17 ; JUSBC1.2 189.23,183.75 ; JUSBC1.2 188.4,185.17 ; JUSBC1.2 188.4,182.33 ; JUSBC1.2 189.23,182.33 ; JUSBC1.2 187.57,185.17 ; JUSBC1.2 187.57,183.75 ; H8.1 6.49,68.38 ; H8.1 7,69.8 ; H8.1 5.07,71.73 ; H8.1 3.14,69.8 ; H8.1 3.65,71.22 ; H8.1 6.49,71.22 ; H8.1 3.65,68.38 ; H8.1 5.07,67.87 ; 26.65,52.58 H10.1 ; H10.1 29.49,52.58 ; H10.1 26.65,55.42 ; H10.1 29.49,55.42 ; H10.1 28.07,55.93 ; H10.1 28.07,52.07 ; H10.1 26.14,54 ; H10.1 30,54 ; JLAN.16 243.69,179.94 ; JLAN.16 243.69,176.43 ; JLAN.16 242.77,176.43 ; JLAN.16 242.77,178.19 ; JLAN.16 244.6,178.19 ; JLAN.16 244.6,179.94 ; JLAN.16 242.77,179.94 ; JLAN.16 244.6,176.43 ; JDP.23 230.35,177.96 ; JDP.23 229.57,177.96 ; JDP.23 229.57,175.34 ; JDP.23 230.35,176.65 ; JDP.23 228.8,177.96 ; JDP.23 228.8,176.65 ; JDP.23 230.35,175.34 ; JDP.23 228.8,175.34 ; 0.38,55.15 JUSBC2.4 ; JUSBC2.4 3.22,55.98 ; JUSBC2.4 1.8,55.15 ; JUSBC2.4 3.22,55.15 ; JUSBC2.4 1.8,56.81 ; JUSBC2.4 0.38,55.98 ; JUSBC2.4 3.22,56.81 ; JUSBC2.4 0.38,56.81 ; 237.31,174.15 JDP.19 ; JDP.19 237.31,173.23 ; JDP.19 238.36,173.69 ; JDP.19 238.24,173.23 ; JDP.19 238.24,174.15 ; JDP.19 237.77,174.27 ; JDP.19 237.77,173.11 ; JHDMI.17 220.58,173.84 ; JHDMI.17 220.12,173.72 ; JHDMI.17 219.66,173.84 ; JHDMI.17 220.12,174.88 ; JHDMI.17 220.58,174.76 ; JHDMI.17 219.66,174.76 ; 5.63,65.4 JUSBC2.5 ; JUSBC2.5 6.35,65.4 ; JUSBC2.5 6.35,63.39 ; JUSBC2.5 5.63,64.3 ; JUSBC2.5 5.63,63.39 ; JUSBC2.5 7.07,65.4 ; JUSBC2.5 7.07,63.39 ; H13.1 201.81,152 ; H13.1 197.33,149.47 ; H13.1 201.81,149.47 ; H13.1 199.57,154.53 ; H13.1 197.33,152 ; H13.1 197.33,154.53 ; H13.1 199.57,149.47 ; H13.1 201.81,154.53 ; 240.57,175.34 JDP.21 ; JDP.21 241.35,176.65 ; JDP.21 239.8,176.65 ; JDP.21 241.35,175.34 ; JDP.21 240.57,177.96 ; JDP.21 239.8,175.34 ; JDP.21 241.35,177.96 ; JDP.21 239.8,177.96 ; JUSB1.4 16.55,35.16 ; JUSB1.4 17.14,34.99 ; JUSB1.4 15.96,33.81 ; JUSB1.4 17.14,33.81 ; JUSB1.4 17.31,34.4 ; JUSB1.4 15.96,34.99 ; JUSB1.4 15.79,34.4 ; JUSB1.4 16.55,33.64 ; JHDMI.2 213.08,173.21 ; JHDMI.2 212.62,173.33 ; JHDMI.2 212.62,172.17 ; JHDMI.2 213.08,172.29 ; JHDMI.2 212.04,172.75 ; JHDMI.2 212.16,173.21 ; JHDMI.2 212.16,172.29 ; JCDRA.47 178.62,179.27 ; JCDRA.47 176.72,176.15 ; JCDRA.47 178.62,176.15 ; JCDRA.47 176.72,177.71 ; JCDRA.47 177.67,176.15 ; JCDRA.47 178.62,177.71 ; JCDRA.47 177.67,179.27 ; JCDRA.47 176.72,179.27 ; 228.8,170.34 JDP.24 ; JDP.24 229.57,170.34 ; JDP.24 229.57,172.96 ; JDP.24 228.8,171.65 ; JDP.24 230.35,170.34 ; JDP.24 230.35,171.65 ; JDP.24 228.8,172.96 ; 260.65,5.08 H21.1 ; H21.1 262.07,8.43 ; H21.1 260.14,6.5 ; H21.1 263.49,5.08 ; H21.1 262.07,4.57 ; H21.1 260.65,7.92 ; H21.1 263.49,7.92 ; H21.1 264,6.5 ; 195.94,55.6 H22.1 ; H22.1 197.87,57.53 ; H22.1 199.8,55.6 ; H22.1 199.29,57.02 ; H22.1 196.45,57.02 ; H22.1 196.45,54.18 ; H22.1 197.87,53.67 ; H22.1 199.29,54.18 ; 20.14,4.2 H16.1 ; H16.1 22.07,6.13 ; H16.1 23.49,2.78 ; H16.1 22.07,2.27 ; H16.1 23.49,5.62 ; H16.1 20.65,5.62 ; H16.1 20.65,2.78 ; H16.1 24,4.2 ; 181.29,180.1 H15.1 ; H15.1 185.15,180.1 ; H15.1 184.64,181.52 ; H15.1 184.64,178.68 ; H15.1 183.22,178.17 ; H15.1 183.22,182.03 ; H15.1 181.8,181.52 ; H15.1 181.8,178.68 ; 215.62,172.17 JHDMI.8 ; JHDMI.8 216.08,173.21 ; JHDMI.8 215.16,173.21 ; JHDMI.8 215.62,173.33 ; JHDMI.8 215.16,172.29 ; JHDMI.8 216.08,172.29 ; JUSBC1.6 197.82,178.48 ; JUSBC1.6 197.82,179.2 ; JUSBC1.6 195.81,179.92 ; JUSBC1.6 197.82,179.92 ; JUSBC1.6 196.72,179.92 ; 197.04,182.33 JUSBC1.4 ; JUSBC1.4 196.21,183.75 ; JUSBC1.4 197.87,185.17 ; JUSBC1.4 197.04,185.17 ; JUSBC1.4 197.87,183.75 ; JUSBC1.4 197.87,182.33 ; JUSBC1.4 196.21,185.17 ; JUSBC1.4 196.21,182.33 ; 6.35,55.2 JUSBC2.6 ; JUSBC2.6 7.07,57.21 ; JUSBC2.6 6.35,57.21 ; JUSBC2.6 5.63,57.21 ; JUSBC2.6 5.63,55.2 ; JUSBC2.6 7.07,55.2 ; JUSBC2.6 5.63,56.3 ; 117.97,154.76 JPCMC.36 ; JPCMC.36 121.57,154.76 ; JPCMC.36 117.97,158.36 ; JPCMC.36 119.77,159.04 ; JPCMC.36 119.77,154.08 ; JPCMC.36 122.25,156.56 ; 200.8,178.68 H14.1 ; H14.1 202.22,182.03 ; H14.1 200.29,180.1 ; H14.1 200.8,181.52 ; H14.1 204.15,180.1 ; H14.1 203.64,178.68 ; H14.1 202.22,178.17 ; H14.1 203.64,181.52 ; JHDMI.5 214.12,174.88 ; JHDMI.5 214.58,174.76 ; JHDMI.5 214.58,173.84 ; JHDMI.5 214.12,173.72 ; JHDMI.5 213.66,173.84 ; JHDMI.5 213.66,174.76 ; 265.49,6.5 H23.1 ; H23.1 270.45,4.26 ; H23.1 267.97,4.26 ; H23.1 270.45,8.74 ; H23.1 265.49,4.26 ; H23.1 270.45,6.5 ; H23.1 265.49,8.74 ; H23.1 267.97,8.74 ; 269.07,148.16 H7.1 ; H7.1 270.77,152.2 ; H7.1 267.37,148.8 ; H7.1 267.37,152.2 ; H7.1 266.73,150.5 ; H7.1 271.41,150.5 ; H7.1 270.77,148.8 ; H7.1 269.07,152.84 ; 100.65,5.08 H18.1 ; H18.1 100.65,7.92 ; H18.1 104,6.5 ; H18.1 103.49,7.92 ; H18.1 103.49,5.08 ; H18.1 100.14,6.5 ; H18.1 102.07,8.43 ; H18.1 102.07,4.57 ; 233.61,172.03 JDP.7 ; JDP.7 234.07,173.07 ; JDP.7 234.54,172.95 ; JDP.7 234.66,172.49 ; JDP.7 233.61,172.95 ; JDP.7 234.07,171.91 ; JDP.7 234.54,172.03 ; JHDMI.23 225.77,183.33 ; JHDMI.23 224.84,182.05 ; JHDMI.23 226.7,182.05 ; JHDMI.23 226.7,183.33 ; JHDMI.23 224.84,183.33 ; JHDMI.23 224.84,180.77 ; JHDMI.23 226.7,180.77 ; JHDMI.23 225.77,180.77 ; H5.1 277.77,45.2 ; H5.1 274.37,45.2 ; H5.1 274.37,41.8 ; H5.1 276.07,41.16 ; H5.1 273.73,43.5 ; H5.1 278.41,43.5 ; H5.1 276.07,45.84 ; H5.1 277.77,41.8 ; 239.8,171.65 JDP.22 ; JDP.22 240.57,170.34 ; JDP.22 241.35,172.96 ; JDP.22 241.35,170.34 ; JDP.22 241.35,171.65 ; JDP.22 239.8,170.34 ; JDP.22 240.57,172.96 ; JUSBC2.3 8.08,55.98 ; JUSBC2.3 5.62,56.76 ; JUSBC2.3 8.08,55.2 ; JUSBC2.3 6.85,55.2 ; JUSBC2.3 5.62,55.98 ; JUSBC2.3 5.62,55.2 ; JUSBC2.3 8.08,56.76 ; 206.54,179.52 JHDMI.21 ; JHDMI.21 208.4,180.8 ; JHDMI.21 207.47,182.08 ; JHDMI.21 207.47,179.52 ; JHDMI.21 206.54,182.08 ; JHDMI.21 208.4,182.08 ; JHDMI.21 206.54,180.8 ; JHDMI.21 208.4,179.52 ; 92.87,54.97 H19.1 ; H19.1 90.94,56.9 ; H19.1 91.45,55.48 ; H19.1 94.29,58.32 ; H19.1 94.29,55.48 ; H19.1 91.45,58.32 ; H19.1 94.8,56.9 ; H19.1 92.87,58.83 ; 13.21,45.16 JUSB1.12 ; JUSB1.12 16.71,44.3 ; JUSB1.12 13.21,43.44 ; JUSB1.12 13.21,44.3 ; JUSB1.12 14.96,43.44 ; JUSB1.12 16.71,43.44 ; JUSB1.12 16.71,45.16 ; JUSB1.12 14.96,45.16 ; H9.1 7.99,52.22 ; H9.1 8.5,50.8 ; H9.1 4.64,50.8 ; H9.1 6.57,48.87 ; H9.1 7.99,49.38 ; H9.1 5.15,52.22 ; H9.1 6.57,52.73 ; H9.1 5.15,49.38 ; JHDMI.22 224.8,171.32 ; JHDMI.22 222.94,171.32 ; JHDMI.22 223.87,173.88 ; JHDMI.22 224.8,173.88 ; JHDMI.22 222.94,172.6 ; JHDMI.22 224.8,172.6 ; JHDMI.22 223.87,171.32 ; JHDMI.22 222.94,173.88 ; JCDRA.50 145.17,179.27 ; JCDRA.50 144.22,177.71 ; JCDRA.50 146.12,179.27 ; JCDRA.50 146.12,176.15 ; JCDRA.50 145.17,176.15 ; JCDRA.50 146.12,177.71 ; JCDRA.50 144.22,179.27 ; JCDRA.50 144.22,176.15 ; H11.1 24.31,11.5 ; H11.1 20.44,13.13 ; H11.1 23.7,13.13 ; H11.1 20.44,9.87 ; H11.1 19.83,11.5 ; H11.1 22.07,13.74 ; H11.1 23.7,9.87 ; H11.1 22.07,9.26 ; H17.1 145.99,170.08 ; H17.1 145.99,172.92 ; H17.1 144.57,173.43 ; H17.1 144.57,169.57 ; H17.1 142.64,171.5 ; H17.1 146.5,171.5 ; H17.1 143.15,170.08 ; H17.1 143.15,172.92 ; JUSB1.7 15.81,37.9 ; JUSB1.7 14.46,37.31 ; JUSB1.7 15.05,37.14 ; JUSB1.7 15.64,38.49 ; JUSB1.7 14.46,38.49 ; JUSB1.7 15.64,37.31 ; JUSB1.7 15.05,38.66 ; JUSB1.7 14.29,37.9 ; JHDMI.20 209.37,173.88 ; JHDMI.20 209.37,171.32 ; JHDMI.20 210.3,172.6 ; JHDMI.20 210.3,173.88 ; JHDMI.20 208.44,173.88 ; JHDMI.20 208.44,172.6 ; JHDMI.20 208.44,171.32 ; 261.82,178.19 JLAN.14 ; JLAN.14 261.82,176.43 ; JLAN.14 263.65,176.43 ; JLAN.14 262.74,176.43 ; JLAN.14 261.82,179.94 ; JLAN.14 263.65,179.94 ; JLAN.14 262.74,179.94 ; JLAN.14 263.65,178.19 ; 274.24,170.6 H12.1 ; H12.1 277.59,172.02 ; H12.1 274.75,172.02 ; H12.1 274.75,169.18 ; H12.1 278.1,170.6 ; H12.1 277.59,169.18 ; H12.1 276.17,172.53 ; H12.1 276.17,168.67 ; H1.1 161.87,157.3 ; H1.1 160.17,157.94 ; H1.1 162.51,155.6 ; H1.1 158.47,153.9 ; H1.1 161.87,153.9 ; H1.1 158.47,157.3 ; H1.1 157.83,155.6 ; H1.1 160.17,153.26 ; 120.33,90.9 H2.1 ; H2.1 120.97,92.6 ; H2.1 122.67,93.24 ; H2.1 122.67,88.56 ; H2.1 125.01,90.9 ; H2.1 124.37,92.6 ; H2.1 120.97,89.2 ; H2.1 124.37,89.2 ; H4.1 205.07,50.84 ; H4.1 207.41,48.5 ; H4.1 205.07,46.16 ; H4.1 206.77,46.8 ; H4.1 203.37,46.8 ; H4.1 206.77,50.2 ; H4.1 202.73,48.5 ; H4.1 203.37,50.2 ; 187.62,177.47 JUSBC1.1 ; JUSBC1.1 189.18,179.93 ; JUSBC1.1 189.18,177.47 ; JUSBC1.1 187.62,178.7 ; JUSBC1.1 187.62,179.93 ; JUSBC1.1 188.4,179.93 ; JUSBC1.1 188.4,177.47 ; 180.04,91.93 H3.1 ; H3.1 183.3,91.93 ; H3.1 180.04,88.67 ; H3.1 183.91,90.3 ; H3.1 179.43,90.3 ; H3.1 181.67,88.06 ; H3.1 183.3,88.67 ; H3.1 181.67,92.54 ; JUSBC2.2 1.8,65.45 ; JUSBC2.2 1.8,63.79 ; JUSBC2.2 0.38,63.79 ; JUSBC2.2 0.38,65.45 ; JUSBC2.2 0.38,64.62 ; JUSBC2.2 3.22,65.45 ; JUSBC2.2 3.22,63.79 ; JUSBC2.2 3.22,64.62 ; 4.69,45.8 JUSB1.14 ; JUSB1.14 4.69,46.66 ; JUSB1.14 7.71,45.8 ; JUSB1.14 6.2,46.66 ; JUSB1.14 7.71,46.66 ; JUSBC1.5 189.63,178.48 ; JUSBC1.5 187.62,179.2 ; JUSBC1.5 188.73,179.92 ; JUSBC1.5 187.62,178.48 ; JUSBC1.5 187.62,179.92 ; JUSBC1.5 189.63,179.92 ; JUSBC1.5 189.63,179.2 ; JUSB1.13 7.71,30 ; JUSB1.13 4.69,30 ; JUSB1.13 4.69,29.14 ; JUSB1.13 6.2,29.14 ; JUSB1.13 7.71,29.14
  BOTTOM w0.102: v1(30.95,47.69) v4(30.95,48.4) ; v1(323.39,38.91) v4(322.87,39.43) ; v1(10.11,57.31) v4(9.47,57.31) ; v1(324.89,28.51) v4(324.21,28.51)
  BOTTOM w0.152: v1(202.06,18.86) UH1.T42 ; UH1.AF26 v1(206.73,27.44) ; UH1.AF26 206.73,26.66 UH1.AE28 ; UH1.AF26 207.51,26.66 ; v1(206.73,27.44) UH1.AF25 v1(206.73,28.21) ; v1(206.73,27.44) UH1.AE25 v1(206.73,28.21) ; UH1.AE28 206.73,25.89 ; UH1.AE28 v1(205.96,25.89) ; 206.73,25.89 UH1.AF28 ; 206.73,25.89 UH1.AE29 v1(205.96,25.89) ; UH1.U29 v1(202.86,25.89) ; v1(202.86,25.89) UH1.U28 ; v1(202.86,25.89) UH1.V29 ; 205.96,30.54 UH1.AC18 UH1.AA18 ; 205.96,30.54 UH1.AE20 ; 205.96,30.54 UH1.AE18 206.73,30.54 UH1.AE20 ; 205.96,30.54 UH1.AC20 ; v1(194.27,27.46) 194.35,27.37 UH1.A25 UH1.B25 ; UH1.AH28 v1(208.28,26.66) ; UH1.AH28 207.89,26.26 v1(208.27,25.88) ; UH1.AH28 207.51,26.66 ; UH1.AH28 207.51,25.89 UH1.AH29 ; v1(208.28,26.66) UH1.AJ28 v1(208.27,25.88) ; v1(208.28,26.66) UH1.AH26 ; v1(208.28,26.66) UH1.AJ26 v1(208.28,27.44) ; v1(203.63,29.76) UH1.V21 v1(203.63,28.99) ; v1(203.63,29.76) UH1.Y21 ; v1(203.63,29.76) UH1.Y20 ; v1(203.63,29.76) UH1.V20 202.83,30.56 UH1.V18 ; UH1.Y21 v1(203.63,28.99) ; UH1.Y21 204.41,29.76 ; UH1.V18 203.24,30.92 202.85,31.31 ; UH1.V18 UH1.Y20 ; UH1.U18 202.85,31.31 ; 202.85,31.31 202.47,31.69 UH1.U17 ; UH1.AA21 204.8,29.36 v1(205.18,28.98) UH1.AC21 ; UH1.AA21 204.8,29.38 204.41,29.76 ; UH1.AA21 v1(205.18,29.76) ; v1(203.63,28.99) UH1.V23 v1(203.63,28.21) UH1.V25 v1(203.63,27.44) UH1.Y26 v1(204.41,26.66) UH1.Y28 v1(204.41,25.89) ; UH1.AC25 v1(205.18,28.21) UH1.AA25 ; UH1.AH26 207.51,27.44 UH1.AH25 ; UH1.AH26 v1(208.28,27.44) ; UH1.AH26 207.51,26.66 ; UH1.AD8 205.89,35.67 205.89,34.83 UH1.AD11 ; 204.41,29.76 UH1.AA20 ; UH1.AH1 207.98,39.55 v1(207.98,39.91) ; UH1.BE18 217.13,30.87 v1(217.24,30.98) ; UH1.BB25 214.23,27.55 v1(214.19,27.59) ; UH1.AM29 UH1.AL29 UH1.AJ29 208.65,25.5 v1(208.27,25.88) ; UH1.BE23 216.45,28.66 217.32,28.66 217.86,29.2 v1(217.86,29.2) ; UH1.AC20 v1(205.18,29.76) ; UH1.AC20 v1(205.96,29.76) ; v1(205.18,29.76) UH1.AC21 ; v1(205.18,29.76) UH1.AA20 ; 204.41,31.31 UH1.Y17 ; 204.41,31.31 UH1.Y18 ; 204.41,31.31 UH1.AA18 ; 204.41,31.31 UH1.AA17 ; UH1.AA18 204.41,30.54 ; v1(214.5,34.21) 214.74,34.21 UH1.BB11 ; UH1.AC21 v1(205.96,29.76) ; UH1.AC21 v1(205.96,28.99) UH1.AE21 ; v1(205.96,29.76) UH1.AE21 ; v1(205.96,29.76) UH1.AE20 ; v1(215.39,31.92) 215.39,31.91 215.08,31.91 UH1.BB16 ; UH1.AA20 204.41,30.54 ; v1(201.86,39.85) 202.07,39.64 UH1.T1 UH1.T2 ; UH1.AE21 v1(206.73,29.76) ; UH1.AE21 v1(206.73,28.99) ; v1(206.73,29.76) UH1.AE20 ; v1(206.73,29.76) UH1.AF20 ; v1(206.73,29.76) UH1.AF21 ; UH1.AJ17 UH1.AJ15 ; UH1.AJ15 UH1.AJ14 ; UH1.AJ15 UH1.AH17 ; UH1.AF20 207.51,30.54 ; UH1.AF20 207.51,29.76 ; 207.51,30.54 UH1.AF18 ; 207.51,30.54 UH1.AH18 ; UH1.D45 196.11,17.25 v1(196.25,17.11) ; UH1.D36 196.15,21.99 UH1.C37 UH1.B37 194.83,21.68 UH1.A37 ; UH1.AC45 205.56,17.67 v1(205.3,17.41) ; UH1.AH45 207.84,17.6 v1(207.6,17.37) ; UH1.AC1 205.58,39.85 v1(205.57,39.86) ; UH1.AF21 v1(206.73,28.99) ; UH1.AF21 207.51,29.76 ; v1(206.73,28.99) UH1.AF23 ; v1(194.26,24.16) 194.26,24.16 194.46,24.16 194.57,24.06 UH1.A32 ; v1(208.27,25.88) UH1.AH29 ; CPU1.G26 168.77,112.39 168.77,113.09 169.08,113.41 CPU1.G28 ; UH1.AJ36 v1(209.22,22.3) ; v1(212.67,39.91) 212.67,39.66 UH1.AU1 ; v1(212.16,17.36) 212.41,17.61 UH1.AU45 ; v1(209.57,30.89) UH1.AM19 ; v1(209.57,30.89) UH1.AL17 ; v1(209.57,30.89) UH1.AM17 ; v1(209.57,30.89) UH1.AL19 ; 207.51,29.76 UH1.AH20 ; 207.51,29.76 UH1.AH21 207.51,28.99 UH1.AF23 ; UH1.AF29 UH1.AH29 ; v1(215.36,22.91) UH1.BB34 ; v1(216.38,23.44) 216.38,23.45 UH1.BE32 ; v1(204.41,25.89) UH1.Y29 ; v1(204.41,25.89) UH1.AA29 v1(205.18,25.89) UH1.AC29 v1(205.96,25.89) ; v1(208.28,27.44) UH1.AH25 ; v1(209,18.73) 209,18.79 209.07,18.87 UH1.AK42 ; UH1.AH25 207.51,28.21 ; v1(194.07,30.83) 194.13,30.88 UH1.A18 ; UH1.AM45 209.94,17.62 v1(209.94,17.38) ; UH1.Y20 204.41,30.54 ; UH1.AF23 v1(206.73,28.21) ; UH1.AF23 207.51,28.21 ; UH1.H24 v1(198.51,27.41) ; v1(216.98,32.97) 216.81,33.14 UH1.BE14 ; 207.51,28.21 UH1.AH23 ; UH1.V45 203.29,17.26 v1(203.15,17.11) ; v1(211.16,19.71) 211.34,19.53 UH1.AR42 ; v1(215.3,29.64) 215.11,29.83 UH1.BB21 ; UH1.P45 200.76,17.79 v1(200.6,17.63) ; v1(199.87,18.81) UH1.M42
  BOTTOM w0.178: CT83.2 180.55,167.16 v1(180,167.71)
  BOTTOM w0.203: CPU1.BP33 133.91,116.32 133.91,116.18 CPU1.BN31 134.62,115.47 v1(134.62,115.42) 134.62,115.31 CPU1.BN30 ; v1(143.35,100.46) 143.18,100.46 CPU1.BA12 ; v1(143.35,100.46) 143.35,99.83 v1(143.35,99.82) 143.35,99.82 v1(143.35,99.19) ; v1(143.35,100.46) 143.52,100.46 CPU1.AY12 ; CPU1.AE6 156,96.5 v1(156.08,96.5) 156.17,96.5 CPU1.AD6 ; CPU1.Y38 v1(159.75,119.89) CPU1.Y37 ; CPU1.AD7 CPU1.AD8 CPU1.AD9 ; v1(166.77,120.63) 166.81,120.63 CPU1.K38 ; v1(191.03,115.74) UV21.41 ; v1(136.8,96.46) 136.71,96.46 136.38,96.79 CPU1.BK6 CPU1.BL6 134.84,96.84 CPU1.BM6 ; v1(136.8,96.46) 136.8,96.39 137.01,96.19 CPU1.BH5 ; v1(136.8,96.46) 137.18,96.84 CPU1.BH6 ; v1(148.83,99.19) v1(148.83,98.55) ; v1(148.83,99.19) v1(148.84,99.82) 148.84,100.46 v1(148.83,100.46) ; v1(148.83,99.19) 148.58,99.45 CPU1.AP10 ; v1(148.83,98.55) 148.43,98.15 CPU1.AP8 148.82,97.71 148.82,97.36 148.96,97.22 CPU1.AN6 148.91,96.79 CPU1.AN5 149.23,95.86 v1(149.4,95.86) 149.73,96.19 CPU1.AM5 ; v1(148.83,98.55) 148.59,98.8 CPU1.AP9 ; CPU1.BB6 142.41,96.67 142.41,96.35 CPU1.BB5 ; CPU1.BB6 142.2,96.84 v1(141.87,96.51) ; CPU1.BB6 142.64,97.22 142.64,97.25 CPU1.BA7 CPU1.BA8 ; CPU1.BB6 CPU1.BA6 ; CPU1.BM23 134.96,109.55 v1(134.63,109.88) 134.63,109.95 CPU1.BN24 ; CPU1.BE3 139.32,94.47 v1(139.28,94.47) ; CPU1.BE3 139.74,95.01 139.75,95.02 139.75,95.4 139.74,95.41 CPU1.BE4 139.74,95.66 139.75,95.67 139.75,96.05 139.74,96.06 CPU1.BE5 ; CPU1.BE3 139.74,94.76 139.75,94.75 139.75,94.37 139.74,94.36 CPU1.BE2 CPU1.BE1 139.74,93.07 v1(139.29,92.62) ; v1(129.98,96.73) 130.22,96.73 130.79,97.3 131.13,97.3 131.59,97.76 132.92,97.76 CPU1.BR7 CPU1.BP7 CPU1.BN7 ; v1(169.41,110.11) 169.08,109.79 CPU1.G23 ; v1(169.41,110.11) 169.73,109.79 CPU1.F23 ; v1(169.41,110.11) 169.08,110.44 CPU1.G24 ; CPU1.BN7 134.38,97.6 v1(134.38,97.14) 134.75,96.76 CPU1.BM6 ; CPU1.BN7 CPU1.BM7 134.71,97.93 134.71,98.21 CPU1.BM8 134.71,98.71 134.71,99 CPU1.BM9 134.96,99.32 134.63,99.64 ; v1(157.39,120.54) CPU1.AC38 ; CPU1.BN12 134.31,100.78 134.63,100.46 ; CPU1.BN12 134.26,100.77 134.18,100.77 134.17,100.76 133.79,100.76 133.78,100.77 133.71,100.77 CPU1.BP12 133.53,100.82 133.5,100.8 133.16,100.8 133.14,100.82 CPU1.BR12 CPU1.BT12 132.21,100.97 v1(131.06,100.97) ; CPU1.BN12 134.63,101.14 v1(134.63,101.21) 134.96,101.54 CPU1.BM13 ; CPU1.AW3 CPU1.AW4 CPU1.AW5 145.17,96.59 145.35,96.59 CPU1.AU6 145.63,96.87 CPU1.AU7 ; CPU1.AW3 144.8,94.85 144.8,94.27 CPU1.AW2 144.8,94.2 144.8,93.62 CPU1.AW1 144.62,93.59 144.32,93.88 v1(144.32,93.91) ; CPU1.AW3 144.44,94.56 v1(144.32,94.56) ; CPU1.BJ32 136.45,116.31 v1(136.13,116.63) ; UH1.BE9 216.61,35.44 216.7,35.52 v1(216.94,35.52) ; CPU1.AH12 153.1,100.75 v1(153.41,101.06) ; v1(131.49,105.55) CPU1.BT18 CPU1.BR18 CPU1.BP18 CPU1.BN18 134.31,105.48 134.63,105.15 ; 164.45,117.28 v1(164.44,117.28) ; 164.45,117.28 164.84,116.96 CPU1.N33 ; 164.45,117.28 164.84,117.61 CPU1.N34 ; CPU1.AP34 148.4,117.61 v1(148.73,117.28) 148.41,116.96 CPU1.AP33 ; CPU1.J7 168.66,97.48 CPU1.G8 CPU1.F8 169.73,97.97 v1(170.06,98.3) ; CPU1.F11 169.41,100.58 v1(169.41,100.65) ; CPU1.T33 v1(162.9,117.28) 162.57,117.61 CPU1.T34 ; v1(172,101.46) 171.68,101.77 CPU1.C13 171.28,102.24 171.28,102.38 CPU1.D14 ; v1(156.88,95.23) 157.19,95.54 CPU1.AC4 ; CPU1.AR5 147.28,96.05 147.33,96 147.33,95.72 147.28,95.67 CPU1.AR4 147.28,95.41 147.29,95.4 147.29,94.9 CPU1.AR3 147.32,94.85 147.32,94.27 CPU1.AR2 ; CPU1.N11 CPU1.N12 ; CPU1.N11 CPU1.N10 CPU1.N9 ; CPU1.N11 164.96,100.1 v1(165.3,100.43) ; CPU1.N12 164.58,101.01 164.18,101.01 CPU1.P12 163.66,101.01 163.27,101.01 CPU1.R12 162.84,100.75 v1(162.55,100.46) 162.26,100.75 CPU1.T12 ; CPU1.N12 164.98,100.75 v1(165.3,100.43) ; CPU1.BA12 CPU1.BA11 CPU1.BA10 ; CPU1.BA12 142.76,100.75 v1(142.43,101.07) 142.3,101.07 CPU1.BB12 141.71,101.02 v1(141.52,101.02) ; CPU1.BA12 143.24,101.09 v1(143.35,101.09) 143.46,101.09 CPU1.AY12 ; v1(141.64,117.93) 141.32,117.61 CPU1.BC34 ; v1(166.89,94.52) 167.25,94.89 CPU1.K3 ; CPU1.E35 170.44,118.2 170.44,117.75 170.38,117.68 CPU1.E34 ; CPU1.H12 168.43,100.99 168.51,100.91 168.51,100.66 v1(168.76,100.66) ; v1(169.43,94.56) 169.75,94.24 CPU1.F2 ; U17.11 v1(64.69,14.08) ; CPU1.G6 169.04,96.75 169.09,96.69 169.09,96.31 169.04,96.26 CPU1.G5 ; v1(170.08,176.39) 169.82,176.65 JCDRA.44 ; v1(151.58,99.19) v1(151.58,99.82) 151.5,99.82 CPU1.AL10 CPU1.AL9 ; v1(151.58,99.19) 151.51,99.19 CPU1.AL9 ; v1(151.58,99.19) v1(151.58,98.55) 151.17,98.15 CPU1.AL8 ; CPU1.BM35 134.96,118.16 v1(135.3,118.5) 135.54,118.26 CPU1.BL35 ; CPU1.T10 CPU1.T11 ; CPU1.T10 162.47,99.82 162.47,99.82 ; CPU1.T10 CPU1.T9 CPU1.T8 CPU1.T7 161.84,97.25 161.84,97.15 CPU1.U6 CPU1.V6 160.44,96.59 160.25,96.59 CPU1.W5 CPU1.W4 CPU1.W3 ; CPU1.T11 CPU1.T12 ; CPU1.T11 162.2,100.1 162.47,99.82 ; v1(173.47,112.02) 173.41,112.08 CPU1.A26 ; v1(206.74,34.85) UH1.AD11 ; CPU1.N9 164.95,98.8 165.23,99.07 v1(165.29,99.07) 165.29,98.6 CPU1.N8 ; CPU1.N9 CPU1.N8 ; v1(173.62,101.05) CPU1.A12 ; v1(208.28,30.53) 207.89,30.91 UH1.AH18 207.9,30.92 v1(208.28,31.3) ; v1(208.28,30.53) 208.67,30.92 UH1.AJ18 208.66,30.92 v1(208.28,31.3) ; v1(208.28,30.53) 207.9,30.15 UH1.AH20 ; v1(138.49,119.23) 138.16,119.56 CPU1.BG37 ; CPU1.AL8 CPU1.AL9 ; CPU1.AL8 CPU1.AL7 151.43,97.19 151.62,97.19 151.72,97.09 152.06,97.09 CPU1.AJ6 CPU1.AH6 CPU1.AG6 154.24,97.09 v1(154.4,97.09) ; v1(131.58,116.51) CPU1.BT32 ; UH1.BE28 216.78,26.32 v1(216.87,26.23) ; v1(131.58,107.91) CPU1.BT21 CPU1.BR21 CPU1.BP21 133.66,107.84 v1(134,107.5) ; CPU1.BM27 135.28,112.96 v1(135.28,113.03) 134.96,113.35 CPU1.BM28 134.84,113.54 134.84,114.09 CPU1.BM29 ; 134.63,100.46 134.96,100.78 CPU1.BM12 135.28,101.15 v1(135.28,101.22) 135.28,101.29 CPU1.BL13 135.93,101.93 135.99,101.93 ; 134.63,100.46 134.96,100.13 CPU1.BM11 134.96,99.97 134.63,99.64 ; CPU1.G14 169.08,102.77 CPU1.F15 169.73,103.49 v1(169.41,103.81) 169.08,104.14 CPU1.G16 ; CPU1.AN12 149.01,100.46 v1(148.83,100.46) ; CPU1.AN12 148.93,101.11 v1(148.85,101.11) 148.74,101.11 CPU1.AP12 ; CPU1.AN12 149.55,101.01 149.95,101.01 CPU1.AM12 150.47,101.01 150.86,101.01 CPU1.AL12 ; CPU1.T12 161.83,101.01 161.58,101.01 161.31,100.75 CPU1.V12 160.92,101.01 160.53,101.01 CPU1.W12 ; CPU1.T12 CPU1.T13 161.95,101.4 v1(161.65,101.7) 162,102.05 CPU1.T14 ; JCDRA.23 161.42,176.25 161.63,176.04 161.69,176.04 v1(161.93,175.8) ; CPU1.BG13 138.67,101.05 v1(138.82,101.05) 139.12,100.75 CPU1.BF12 ; CPU1.BG13 CPU1.BG12 138.15,100.75 v1(137.86,100.46) 137.58,100.75 CPU1.BH12 ; CPU1.BG13 138.38,101.45 138.38,101.99 CPU1.BG14 ; CPU1.BD6 140.46,96.84 v1(140.13,96.51) 140.13,96.5 139.82,96.19 CPU1.BE5 ; CPU1.BD6 140.32,97.09 140.16,97.09 ; CPU1.BD6 CPU1.BC6 141.55,96.84 v1(141.87,96.51) ; v1(169.41,99.09) 169.73,98.76 CPU1.F9 169.73,98.62 v1(170.06,98.3) ; CPU1.BH8 137.46,98.15 v1(137.86,98.55) ; CPU1.BH8 CPU1.BH7 ; CPU1.BH8 CPU1.BH9 ; v1(150.66,101.72) 150.99,102.05 CPU1.AL14 ; PU6301.5 221.4,56.5 221.06,56.84 v1(220.93,56.84) ; CPU1.G5 169.18,96.33 CPU1.F5 ; CPU1.G5 168.97,96.19 168.64,95.86 ; 162.47,99.82 v1(162.56,99.82) ; CPU1.BH5 CPU1.BH4 CPU1.BH3 CPU1.BH2 136.97,93.98 CPU1.BH1 136.97,93.03 v1(137.18,92.82) ; CPU1.BH5 137.3,96.26 137.3,96.67 137.22,96.74 CPU1.BH6 ; CPU1.BF33 138.96,116.96 v1(139.28,117.28) 138.95,117.61 CPU1.BF34 ; v1(170.06,98.3) 170.38,98.62 CPU1.E9 ; v1(172.03,99.91) 171.97,99.91 171.68,100.2 CPU1.C11 171.4,100.55 171.4,100.69 CPU1.D12 ; CPU1.A9 CPU1.B9 172.17,98.53 172.17,98.46 v1(172.01,98.3) ; CPU1.F29 169.78,114.44 170.05,114.16 v1(170.05,114.1) ; CPU1.BH9 CPU1.BH10 ; CPU1.BH9 137.62,98.8 v1(137.86,98.55) ; CPU1.BH10 137.6,99.45 v1(137.86,99.19) ; CPU1.BH10 CPU1.BH11 ; v1(160.55,117.27) 160.21,117.61 CPU1.W34 ; v1(187.59,112.66) 187.59,112.55 186.99,111.95 UV21.57 ; CPU1.AU11 CPU1.AU10 CPU1.AU9 CPU1.AU8 CPU1.AU7 ; CPU1.AU11 145.81,100.1 145.9,100 145.92,100 v1(146.1,99.82) ; CPU1.AU11 CPU1.AU12 ; CPU1.BD8 CPU1.BD9 ; CPU1.BD8 CPU1.BD7 ; CPU1.BD8 140.2,98.15 v1(140.61,98.55) ; CPU1.BD9 140.36,98.8 v1(140.61,98.55) ; CPU1.BD9 CPU1.BD10 ; CPU1.A6 172.98,97.13 172.54,96.69 172.18,96.69 171.82,96.33 CPU1.C5 171.19,95.84 v1(170.85,95.84) ; CPU1.K4 CPU1.J4 168.56,95.86 168.64,95.86 ; CPU1.K4 167.4,95.41 167.41,95.4 167.41,95.02 167.4,95.01 CPU1.K3 ; CPU1.K4 167.4,95.66 167.41,95.67 167.41,96.05 167.4,96.06 CPU1.K5 167.07,96.51 v1(166.96,96.51) ; v1(250.53,53.89) 250.53,53.89 PU6102.26 ; JCDRA.41 168.62,176.52 168.42,176.32 168.42,175.88 v1(168.42,175.88) ; v1(157.34,93.04) CPU1.AC1 157.34,94.06 157.33,94.19 157.34,94.19 CPU1.AC2 CPU1.AC3 CPU1.AC4 ; v1(147.94,119.23) 147.61,119.56 CPU1.AR37 ; CPU1.AR38 147.62,120.21 v1(147.94,120.54) ; v1(172.01,104.6) 171.68,104.92 CPU1.C17 171.37,105.3 171.37,105.44 CPU1.D18 ; CPU1.AU7 145.89,97.25 146.03,97.25 CPU1.AT6 ; v1(246.76,55.84) 246.89,55.84 247.23,55.5 PU6102.5 ; CPU1.AB34 v1(158.18,117.28) CPU1.AB33 ; v1(137.86,98.55) 137.89,98.53 137.89,97.8 137.58,97.5 CPU1.BH7 ; v1(184.16,119.09) 184.32,118.94 UV21.18 ; v1(143.35,99.19) 143.23,99.19 142.97,99.45 CPU1.BA10 ; v1(143.35,99.19) v1(143.35,98.55) ; v1(172.01,110.9) 171.68,111.22 CPU1.C25 171.28,111.69 171.28,111.83 CPU1.D26 ; CPU1.F27 169.66,112.86 169.42,112.63 v1(169.42,112.45) 169.08,112.11 CPU1.G26 ; CPU1.AY12 143.9,100.75 v1(144.27,101.11) 144.37,101.11 144.72,100.76 CPU1.AW12 145.05,101.08 v1(145.2,101.08) 145.53,100.75 CPU1.AU12 ; v1(173.63,105.88) 173.52,105.78 CPU1.A18 ; CPU1.BB3 142.15,94.89 141.87,94.61 v1(141.87,94.56) ; CPU1.BB3 142.34,94.8 142.34,94.32 CPU1.BB2 142.25,94.1 142.29,94.05 142.29,93.77 142.25,93.72 CPU1.BB1 142.3,93.54 142.3,93.05 v1(141.9,92.65) ; CPU1.BB3 142.25,95.01 142.32,95.07 142.32,95.35 142.25,95.41 CPU1.BB4 142.25,95.66 142.32,95.72 142.32,96 142.25,96.06 CPU1.BB5 ; UH1.AY45 214.03,18.05 213.99,18.09 213.99,18.12 213.98,18.14 213.98,18.39 213.99,18.41 213.99,18.94 v1(214.13,19.08) ; UV21.8 184.19,114.94 v1(184.1,114.84) ; v1(210.34,27.41) UH1.AM27 ; v1(136.09,101.02) 136.26,101.19 CPU1.BK13 136.26,101.67 135.99,101.93 ; v1(229.62,55.85) 229.75,55.85 230.09,55.51 PU6202.5 ; CPU1.F19 169.73,106.64 v1(169.41,106.96) 169.08,107.29 CPU1.G20 ; CPU1.P6 CPU1.N6 ; CPU1.N6 164.92,96.8 164.92,96.23 CPU1.N5 CPU1.N4 CPU1.N3 ; CPU1.N6 CPU1.M6 ; CPU1.N6 164.88,97.19 164.84,97.24 CPU1.N7 CPU1.N8 ; v1(143.35,98.55) 142.94,98.15 CPU1.BA8 ; v1(143.35,98.55) 143.1,98.8 CPU1.BA9 ; v1(159.02,176.45) JCDRA.17 ; v1(173.55,104.2) CPU1.A16 ; JCDRA.32 165.02,178.7 164.82,178.9 164.54,178.9 164.4,179.04 v1(164.01,179.04) 163.82,178.85 JCDRA.29 ; CPU1.BH7 137.22,97.31 CPU1.BH6 ; v1(155.81,116.63) CPU1.AE33 CPU1.AE34 ; v1(191.78,119.16) 191.48,118.87 190.62,118.87 190.55,118.94 UV21.33 189.39,118.94 189.12,119.22 v1(188.86,119.22) ; v1(134,107.5) 134.31,107.19 CPU1.BN20 133.98,106.8 v1(133.98,106.73) 134.31,106.4 CPU1.BN19 ; v1(134,107.5) 134.31,107.8 CPU1.BN21 134.45,107.91 134.51,107.85 134.83,107.85 134.88,107.91 CPU1.BM21 134.96,107.98 v1(135.27,108.3) ; v1(213.29,24.85) 213.29,24.95 213.64,25.3 UH1.AW29 ; UH1.AE42 v1(206.8,19.69) ; PU6202.26 v1(233.39,53.9) ; CPU1.AG11 153.97,100.1 v1(154.28,100.42) 154.45,100.42 CPU1.AF12 CPU1.AF13 CPU1.AF14 ; v1(147.02,101.07) 147.13,101.07 CPU1.AR13 ; CPU1.BA9 CPU1.BA10 ; CPU1.BA9 CPU1.BA8 ; CPU1.J36 168.27,118.66 168.41,118.66 CPU1.H35 168.88,118.26 169.2,118.58 169.26,118.58 CPU1.F36 169.91,119.23 v1(169.99,119.23) 169.96,119.26 169.96,120.08 CPU1.E38 ; CPU1.AR13 147.79,101.72 v1(147.92,101.72) 147.6,102.05 CPU1.AR14 147.33,102.05 v1(147.01,101.72) ; CPU1.AR13 147.78,101.08 v1(147.92,101.08) 148.05,101.08 CPU1.AP12 ; v1(147.3,92.12) 147.3,93.56 147.28,93.57 ; v1(209.58,29.79) UH1.AM22 ; 140.16,97.09 140.15,97.1 CPU1.BD7 ; 140.16,97.09 139.99,97.09 CPU1.BE6 ; CPU1.L33 166.52,116.96 v1(166.84,117.28) 166.51,117.61 CPU1.L34 ; CPU1.U37 v1(162.11,119.89) CPU1.U38 ; CPU1.BM5 134.75,96.21 CPU1.BM6 ; CPU1.F25 169.42,110.98 v1(169.42,110.91) ; v1(140.61,98.55) 140.61,97.85 140.25,97.5 CPU1.BD7 ; v1(165.62,179.04) 165.87,179.04 166.22,178.69 JCDRA.35 ; v1(140.61,99.82) 140.42,99.82 CPU1.BD11 ; v1(164.88,92.81) 164.88,92.87 164.89,92.87 164.89,93.45 164.88,93.45 CPU1.N1 CPU1.N2 CPU1.N3 ; CPU1.AP12 148.55,100.75 v1(148.83,100.46) ; CPU1.BR29 CPU1.BP29 CPU1.BN29 CPU1.BM29 ; v1(241.96,53.9) PU6201.26 ; UH1.K27 v1(198.51,26.37) UH1.H27 ; CPU1.F13 169.35,101.46 169.35,101.32 CPU1.G12 169.08,100.99 v1(168.76,100.66) ; PU6400.26 270.6,52.87 v1(270.6,52.87) ; CPU1.D22 171.28,108.68 171.28,108.54 CPU1.C21 172.01,107.81 v1(172.01,107.69) ; v1(168.76,100.66) 168.43,100.34 CPU1.H11 ; v1(157.06,100.46) 157.06,99.83 v1(157.07,99.82) 156.98,99.82 CPU1.AD10 ; v1(157.06,100.46) 156.78,100.75 CPU1.AD12 CPU1.AD11 ; v1(157.06,100.46) 157.35,100.75 CPU1.AC12 157.78,101.01 158.18,101.01 CPU1.AA12 ; v1(157.06,100.46) 157.02,100.46 156.65,100.1 CPU1.AD11 ; v1(172.01,109.32) 172.01,109.39 CPU1.C23 171.28,110.11 171.28,110.25 CPU1.D24 ; v1(146.36,116.63) 146.04,116.96 CPU1.AU33 ; 134.63,99.64 134.31,99.32 CPU1.BN9 ; CPU1.BE6 139.6,96.7 139.6,96.33 CPU1.BE5 ; CPU1.BE6 CPU1.BF6 CPU1.BG6 CPU1.BH6 ; v1(173.24,120.3) 173.24,119.9 CPU1.A37 172.43,119.64 CPU1.B37 CPU1.C37 ; CPU1.AU12 145.72,100.75 v1(146.08,101.11) ; CPU1.AV37 145.26,119.56 v1(145.58,119.89) 145.25,120.21 CPU1.AV38 ; CPU1.BN2 134.62,94.24 CPU1.BM2 134.93,95.12 CPU1.BM3 134.86,95.43 v1(135.09,95.66) ; UH1.AL24 v1(209.53,27.41) UH1.AM24 ; v1(173.53,115.58) 173.38,115.43 CPU1.A30 ; CPU1.BD11 CPU1.BD12 140.32,100.75 v1(140.61,100.46) 140.89,100.75 CPU1.BC12 CPU1.BC13 140.87,101.4 v1(140.59,101.12) ; CPU1.BD11 CPU1.BD10 ; v1(164.41,94.58) 164.46,94.58 164.77,94.89 CPU1.N3 ; v1(210.33,29.74) UH1.AN22 ; CPU1.F21 169.73,108.21 v1(169.41,108.54) 169.08,108.86 CPU1.G22 ; 135.99,101.93 136.26,102.19 CPU1.BK14 136.26,102.4 v1(135.87,102.79) 135.85,102.79 135.85,102.81 136.23,103.19 CPU1.BK15 CPU1.BJ15 ; v1(173.8,108.93) CPU1.A22 ; v1(266.84,54.82) 266.96,54.82 267.3,54.48 PU6400.5 ; v1(168.42,116.63) 168.1,116.31 CPU1.J32 ; v1(168.42,116.63) 168.73,116.31 CPU1.H32 169.07,116.04 169.7,116.04 CPU1.F31 ; v1(168.42,116.63) 168.08,116.96 CPU1.J33 ; v1(160.16,176.44) 160.22,176.5 JCDRA.20 ; CPU1.BD10 140.35,99.45 v1(140.61,99.19) ; v1(159.41,92.5) 159.85,92.87 CPU1.W1 159.85,93.89 159.85,94.11 CPU1.W2 159.89,94.27 159.89,94.85 CPU1.W3 ; UH1.AL4 209.56,37.92 UH1.AK4 208.89,38.28 v1(209.01,38.4) ; CPU1.AG8 CPU1.AG7 ; CPU1.AD9 156.39,98.8 v1(156.13,98.53) ; CPU1.AD9 CPU1.AD10 ; CPU1.AG10 154.24,99.82 v1(154.33,99.82) ; v1(171.78,121.12) 171.5,120.84 171.3,120.84 170.89,120.42 CPU1.D38 ; CPU1.AM38 149.97,120.21 v1(150.3,119.89) 149.98,119.56 CPU1.AM37 ; v1(143.35,102.37) 143.67,102.05 CPU1.AY14 ; v1(236.14,149.98) 235.97,149.98 235.49,150.46 UL1.27 ; UH1.AJ17 208.67,31.7 v1(208.28,31.3) ; UH1.BE40 216.38,20.22 216.78,20.62 v1(216.97,20.62) ; 168.64,95.86 168.97,95.54 CPU1.G4 CPU1.F4 ; UH1.AV24 v1(212.51,27.37) UH1.AV27 ; v1(173.99,110.5) CPU1.A24 ; CPU1.AH33 153.13,116.96 v1(153.45,117.28) 153.12,117.61 CPU1.AH34 ; CPU1.K3 CPU1.K2 CPU1.K1 ; v1(131.36,96.36) 131.39,96.38 132.34,96.38 CPU1.BT5 ; CPU1.P37 v1(164.47,119.89) CPU1.P38 ; v1(200.19,33.2) UH1.L15 ; v1(200.19,33.2) UH1.L13 ; v1(200.19,33.2) UH1.N15 ; CPU1.BT35 132.24,118.08 v1(131.79,118.53) 132.15,118.9 CPU1.BT36 132.47,118.78 CPU1.BR36 ; CPU1.D16 171.28,103.95 171.28,103.81 CPU1.C15 172.01,103.09 v1(172.01,103.02) ; CPU1.L30 CPU1.L29 ; CPU1.AC4 157.34,95.71 157.35,95.72 157.35,96.05 157.34,96.06 CPU1.AC5 157.34,96.31 157.35,96.32 157.35,96.7 157.34,96.72 CPU1.AC6 CPU1.AB6 158.48,97.14 158.58,97.14 158.69,97.25 159.1,97.25 CPU1.Y7 CPU1.Y8 CPU1.Y9 CPU1.Y10 ; CPU1.W3 159.74,94.89 159.41,94.56 v1(159.41,94.59) ; CPU1.BC33 141.31,116.96 v1(141.64,116.63) ; CPU1.BD37 140.53,119.56 v1(140.85,119.89) 140.52,120.21 CPU1.BD38 ; CPU1.AD10 CPU1.AD11 ; v1(165.3,100.43) 165.61,100.75 CPU1.M12 CPU1.M13 CPU1.M14 ; v1(131.72,111.98) 131.85,111.85 CPU1.BT26 ; 171.28,99.09 171.28,99.23 CPU1.D10 ; 171.28,99.09 CPU1.D9 ; 171.28,99.09 CPU1.C9 171.68,98.62 v1(172.01,98.3) ; CPU1.E4 CPU1.F4 ; CPU1.F4 169.82,95.43 CPU1.F3 ; CPU1.AJ38 CPU1.AJ37 152.2,119.56 v1(151.88,119.24) ; CPU1.D30 171.03,115.25 v1(171.35,115.57) ; v1(173.67,113.74) 173.58,113.65 CPU1.A28 ; CPU1.C29 171.66,114.42 171.66,114.42 v1(172,114.07) ; v1(137.87,99.82) 137.77,99.82 137.5,100.1 CPU1.BH11 ; CPU1.AL34 150.63,117.61 v1(150.3,117.28) 150.62,116.96 CPU1.AL33 ; v1(132.53,120.63) CPU1.BR38 ; CPU1.T5 CPU1.T4 CPU1.T3 CPU1.T2 CPU1.T1 162.37,93.49 162.37,93.49 162.37,93.08 v1(161.92,92.62) ; CPU1.BH11 CPU1.BH12 ; CPU1.AU34 146.04,117.61 v1(146.36,117.93) ; PU6301.26 v1(224.7,54.89) ; CPU1.A34 173.08,117.95 v1(173.62,117.95) ; v1(216.94,21.8) 216.88,21.75 UH1.BE37 ; v1(172.01,98.3) 172.01,98.23 CPU1.C8 CPU1.D6 ; v1(160.54,116.63) CPU1.W33 ; v1(208.28,31.3) 207.89,31.69 UH1.AH17 ; JCDRA.38 167.42,178.95 v1(167.39,178.98) ; CPU1.Y14 159.45,102.05 v1(159.78,101.72) 159.45,101.4 CPU1.Y13 ; v1(172.03,106.21) 171.97,106.21 171.68,106.5 CPU1.C19 171.28,106.96 171.28,107.1 CPU1.D20 ; CPU1.AY34 143.67,117.61 v1(144,117.28) 143.68,116.96 CPU1.AY33 ; CPU1.AM4 149.8,95.41 149.82,95.38 149.82,95.04 149.8,95.01 CPU1.AM3 CPU1.AM2 CPU1.AM1 v1(149.8,93.04) ; CPU1.BB5 142.17,96.19 141.87,96.48 v1(141.87,96.51) ; CPU1.BA38 142.82,120.14 142.88,120.07 142.88,119.7 142.82,119.63 CPU1.BA37 142.89,119.56 v1(143.21,119.23) ; UH1.R14 v1(202.04,33.24) UH1.U14 ; UH1.M35 v1(199.79,23.08) ; CPU1.BM29 135.02,114.28 135.54,114.28 CPU1.BL29 135.82,114.42 CPU1.BK29 136.66,114.82 CPU1.BJ30 136.52,114.94 v1(136.13,115.33) 136.46,115.66 CPU1.BJ31 ; v1(148.83,100.46) 148.74,100.46 CPU1.AP11 ; v1(173.73,107.35) CPU1.A20 ; CPU1.A4 CPU1.A3 172.41,94.84 CPU1.B3 ; CPU1.BM38 135.1,120.22 v1(135.47,120.59) 135.81,120.25 CPU1.BL38 ; v1(203.39,21.51) UH1.W38 ; v1(157.39,119.23) CPU1.AC37 ; v1(213.3,31.11) UH1.AV17 ; v1(131.28,99.15) 131.28,99.3 131.49,99.5 132.1,99.5 CPU1.BT9 ; v1(173.55,99.44) 173.52,99.48 CPU1.A10 ; CPU1.Y10 159.44,99.45 v1(159.81,99.82) 159.63,100 159.62,100 159.52,100.1 CPU1.Y11 CPU1.Y10 ; CPU1.BJ12 136.58,100.79 v1(136.95,100.42) 137.27,100.75 CPU1.BH12 ; v1(172.01,112.51) 171.68,112.83 CPU1.C27 171.28,113.26 171.28,113.4 CPU1.D28 ; v1(156.62,176.45) JCDRA.11 ; v1(167.21,105.78) CPU1.J18 CPU1.H18 CPU1.G18 169.41,105.45 v1(169.41,105.39) 169.73,105.06 CPU1.F17 169.41,104.67 v1(169.41,104.59) ; v1(174,102.63) CPU1.A14 ; CPU1.BR34 CPU1.BP34 133.98,117.03 v1(133.98,116.97) 134.31,117.29 CPU1.BN34 ; JCDRA.14 157.82,176.51 v1(157.74,176.44) ; v1(135.28,111.45) 134.96,111.78 CPU1.BM26 ; v1(213.16,34.24) 213.56,33.84 UH1.AW13 ; v1(238.2,55.85) 238.32,55.85 238.66,55.51 PU6201.5 ; v1(131.78,95.41) 131.91,95.54 132.29,95.54 CPU1.BT4 ; v1(198.47,25.13) UH1.H29 ; v1(207.8,21.54) UH1.AG38 ; v1(167.16,111.74) 167.16,111.57 167.44,111.29 CPU1.J25 CPU1.H25 ; v1(154.22,176.45) JCDRA.5 ; v1(155.42,176.45) JCDRA.8 ; v1(214.56,24.97) 214.58,24.97 UH1.BB30 ; v1(138.49,120.54) CPU1.BG38
  BOTTOM w0.229: DT8.2 v1(197.28,174.12) ; DT7.2 v1(194.72,174.12)
  BOTTOM w0.254: CPU1.BT14 CPU1.BR14 133.01,102.47 v1(133.33,102.79) 133.66,102.47 CPU1.BP14 CPU1.BN14 ; CPU1.T3 162.07,94.58 v1(161.91,94.58) ; CPU1.A3 172.98,94.32 v1(172.9,94.24) ; v1(171.73,94.92) 172.23,94.92 CPU1.B3 ; v1(171.73,94.92) 171.63,94.82 CPU1.D3 ; v1(171.73,94.92) 171.73,94.39 CPU1.C2 ; v1(151.58,101.1) 151.23,100.75 CPU1.AL12 ; CPU1.AE6 155.25,96.43 155.25,95.97 CPU1.AF4 154.84,95.52 154.84,94.9 CPU1.AF3 CPU1.AF2 CPU1.AF1 v1(154.82,93.04) ; CPU1.F36 169.86,118.64 170,118.64 CPU1.E35 ; CPU1.K10 167.44,99.45 v1(167.08,99.09) 167.21,99.09 CPU1.K9 ; v1(167.91,97.76) 168.19,97.48 CPU1.J7 ; v1(167.91,97.76) 167.65,97.5 CPU1.K7 ; v1(167.91,97.76) 167.52,98.15 CPU1.K8 ; DT3.2 v1(191.65,175.84) ; CPU1.F3 169.75,94.89 v1(169.43,94.56) ; CPU1.BK25 CPU1.BJ25 v1(137.48,111.06) ; CPU1.AU8 145.74,98.15 v1(146.13,97.76) ; v1(135.26,107.52) 135.26,107.54 CPU1.BM21 ; v1(137.47,108.75) 137.41,108.7 CPU1.BJ22 CPU1.BK22 ; CPU1.BT3 132.25,94.77 131.83,94.77 v1(131.75,94.69) ; v1(189.11,174.59) 189.05,174.53 DT5.2 ; CPU1.D33 171.03,116.75 v1(171.38,116.4) ; CPU1.J10 168.28,99.48 v1(167.97,99.79) 167.81,99.79 CPU1.K11 ; CPU1.A36 173.01,118.86 v1(173.37,119.22) ; CPU1.L29 166.44,113.83 v1(166.51,113.76) ; CPU1.AP11 148.65,99.82 v1(148.84,99.82) ; UH1.N41 v1(199.9,19.76) UH1.L41 ; PU511.3 183.43,144.02 183.33,144.11 v1(183.33,144.75) ; UE8.7 292.71,46.28 292.87,46.44 v1(292.87,47.07) ; CL8.1 238.94,158.27 239.28,158.27 239.58,158.57 v1(239.58,161.36) 239.58,161.47 239.09,161.96 235.34,161.96 234.9,161.51 v1(234.9,160.18) 234.9,160.05 235.15,159.8 235.15,158.41 v1(235.21,158.35) ; CPU1.BN24 134.26,110.32 133.8,110.32 133.75,110.27 CPU1.BP24 133.54,110.27 133.45,110.36 133.09,110.36 CPU1.BR24 CPU1.BT24 ; CPU1.BG14 138.18,102.05 v1(137.86,101.73) 137.54,102.05 CPU1.BH14 ; CPU1.AC6 157.3,96.84 v1(156.96,97.17) ; JSSD2.33 270.89,16.25 v1(270.71,16.44) ; v1(215.38,147.01) 215.68,147.01 216.14,147.47 U1302.4 ; v1(135.09,95.66) 135.09,95.87 CPU1.BM5 134.44,95.69 CPU1.BN4 ; v1(146.83,94.52) 147.2,94.89 CPU1.AR3 ; CPU1.C31 171.35,115.68 v1(171.35,115.57) ; JHDD.6 115.92,9.27 115.44,8.8 v1(114.82,8.8) 114.42,9.2 JHDD.3 ; JHDD.9 117.42,10.57 117.8,10.95 v1(117.99,10.95) ; CPU1.BD12 140.02,100.75 v1(139.69,101.07) 139.37,100.75 CPU1.BF12 ; v1(197.67,159.64) 198.09,160.07 UT4.A1 ; CPU1.AD7 156.64,97.5 v1(156.96,97.17) ; C3.2 127.12,100.91 127.6,100.43 UZ21.5 ; v1(170.01,120.74) 170.09,120.66 CPU1.E38 ; UU7.12 v1(15.51,51.63) ; UT4.L1 197.89,165.33 197.89,165.64 197.47,166.06 v1(197.34,166.06) ; CPU1.AR5 147.23,96.19 v1(146.83,95.79) ; UH1.AA42 204.52,19 v1(204.35,18.83) ; CPU1.AG7 153.86,96.96 CPU1.AG6 ; DT4.2 186.83,174.53 186.35,174.53 v1(186.32,174.5) ; JHDD.12 118.92,8.95 119.13,8.73 120.21,8.73 120.42,8.94 JHDD.15 v1(120.42,10.95) ; v1(156.96,97.17) 156.63,96.84 CPU1.AD6 ; v1(203.62,165.24) 203.6,165.22 203.31,165.22 UT4.L11 ; v1(188.48,46.45) 188.39,46.36 187.45,46.36 187.19,46.61 U2407.6 ; CPU1.G9 169.41,99.02 v1(169.41,99.09) 169.08,99.41 CPU1.G10 ; CPU1.AR2 147.25,94.24 v1(146.83,93.82) ; CPU1.BP26 CPU1.BR26 CPU1.BT26 ; CPU1.AM4 149.76,95.54 149.44,95.86 v1(149.4,95.86) ; PU800.18 v1(196.87,75.55) ; UH1.AW19 v1(213.3,31.11) ; CPU1.AL4 CPU1.AK4 151.83,95.13 v1(151.83,94.58) ; CPU1.BK29 136.58,114.08 CPU1.BJ29 ; CPU1.AR1 147.28,93.57 v1(146.83,93.12) ; CPU1.BC14 CPU1.BC13 ; CPU1.J22 167.88,108.78 168.23,108.78 CPU1.H22 168.48,108.83 168.98,108.83 CPU1.G22 169.08,109 v1(169.4,109.31) ; v1(140.13,96.51) 139.81,96.84 CPU1.BE6 ; v1(121.92,8.92) JHDD.18 ; v1(152.31,93.04) CPU1.AJ1 CPU1.AJ2 CPU1.AJ3 CPU1.AJ4 CPU1.AJ5 CPU1.AJ6 ; CPU1.BM25 v1(135.28,111.45) ; CT77.2 183.75,163.1 RT3.2 183.77,163.16 v1(183.25,163.16) ; v1(140.61,99.19) 140.54,99.19 CPU1.BD9 ; UE8.18 292.71,40.08 v1(292.86,39.94) ; CPU1.BK18 CPU1.BJ18 137.34,105.55 v1(137.5,105.39) ; UE8.23 v1(290.21,39.94) ; CPU1.BM18 134.63,105.15 ; UM8.25 126.03,157.18 v1(125.98,157.23) ; CPU1.T9 162.17,98.8 v1(162.56,99.19) 162.47,99.19 162.21,99.45 CPU1.T10 ; PU800.7 197.32,73.42 v1(197.56,73.18) 197.05,73.18 196.87,73.36 PU800.8 ; UH1.D1 UH1.C1 ; v1(189.24,175.84) DT2.2 ; v1(188.67,152.88) CT45.2
  BOTTOM w0.279: v1(190,177.01) 190.1,177.1 JUSBC1.A1
  BOTTOM w0.3: UG1.AW43 217.67,83.15 v1(217.52,83.15) ; UG13.A12 v1(207.07,144.4) ; UG17.M10 v1(273.32,122.21) ; UG13.A14 v1(205.47,144.4) ; UG16.U3 v1(249.07,144.4) ; UG14.U1 v1(219.47,144.4) ; UG1.BC42 219.27,80.05 219.27,80.75 UG1.BB42 UG1.BB43 217.75,80.53 v1(217.75,79.49) ; v1(273.32,80.21) UG20.F5 ; v1(257.07,136.4) UG16.H13 ; UG14.U3 v1(221.07,144.4) ; v1(268.52,111.41) UG18.A1 ; v1(268.52,97.41) UG19.U14 ; v1(273.32,108.21) UG18.F5 ; UG15.A14 v1(233.47,144.4) ; v1(273.32,94.21) UG19.M10 ; UG17.U14 v1(268.52,125.41) ; v1(235.07,144.4) UG15.A12
  BOTTOM w0.305: UG17.E14 v1(278.12,125.41) ; JDIMM2.171 156.2,48.24 155.89,48.55 v1(155.65,48.55) 155.33,48.55 155.2,48.41 JDIMM2.167 ; v1(132.19,48.6) 131.69,48.11 JDIMM2.81 ; UG16.H1 247.07,136.8 v1(247.47,136.4) UG16.H2 ; UG15.G5 v1(239.87,139.6) UG15.F5 ; UG1.AW38 UG1.AW36 224.26,83.5 v1(224.67,83.09) ; UG17.G10 v1(277.32,122.21) UG17.F10 ; UG17.N14 v1(271.72,125.41) ; v1(213.47,144.4) 213.87,144 UG13.A3 ; UG17.B5 280.92,118.61 v1(281.32,119.01) ; UG16.K14 v1(257.07,138.8) 256.67,138.4 UG16.K13 ; v1(221.07,134) 220.67,134.4 UG14.E3 ; v1(205.47,130.8) 205.07,131.2 UG13.U14 ; UG14.U14 229.47,144 v1(229.07,144.4) ; UG16.F5 v1(250.67,135.6) ; UG15.A1 243.47,144 v1(243.07,144.4) ; UG17.H14 276.12,125.81 v1(276.52,125.41) ; JDIMM1.171 156.19,61.15 v1(156.34,61.3) 155.33,61.3 155.19,61.16 JDIMM1.167 ; JDIMM2.201 163.69,48.09 v1(164.05,48.44) 164.39,48.44 164.69,48.13 JDIMM2.205 ; v1(222.67,132.4) 222.27,132 UG14.B5 ; v1(280.52,125.41) 280.12,125.81 UG17.C14 ; v1(159.34,145.83) 159.58,145.59 PU502.4 ; v1(208.67,135.6) 208.27,135.2 UG13.M10 ; v1(127.94,61.29) 127.82,61.29 127.69,61.16 JDIMM1.65 ; UG13.U3 213.87,131.2 v1(213.47,130.8) ; UG15.D10 v1(235.87,141.2) ; UG17.R14 v1(270.12,125.41) ; UG16.D10 254.27,133.6 v1(254.67,134) ; JDIMM1.217 167.69,61.13 v1(167.39,61.44) ; v1(170.8,54.69) 170.65,54.69 169.94,53.99 JDIMM1.226 ; JDIMM2.89 133.69,48.31 134,48.61 v1(134.09,48.61) 134.5,48.61 134.69,48.42 JDIMM2.93 ; UG15.C11 v1(235.07,142.8) 234.67,142.4 UG15.C12 ; UG18.B10 269.72,104.61 v1(270.12,105.01) ; v1(132.24,49.27) 132.69,48.81 JDIMM2.85 ; v1(226.67,134) 226.27,133.6 UG14.D10 ; UG18.H14 v1(274.12,101.81) 274.52,102.21 UG18.H13 ; v1(112.68,58.46) 112.69,58.48 JDIMM1.5 ; v1(212.67,132.4) 213.07,132.8 UG13.R4 ; JDIMM2.252 176.44,38.08 176.06,37.7 v1(175.73,37.7) 175.44,37.99 JDIMM2.248 ; v1(158.19,48.54) 158.69,48.04 JDIMM2.181 ; v1(271.72,95.01) 271.32,94.61 UG19.P10 ; v1(161.62,48.43) 161.69,48.35 JDIMM2.193 ; UG15.U3 241.87,131.2 v1(241.47,130.8) ; UG18.E3 v1(271.72,109.81) ; JDIMM1.247 175.19,61.66 175.61,62.07 v1(176.03,62.07) ; UG18.C3 v1(270.12,109.81) UG18.C4 ; UG16.T5 v1(250.67,143.6) ; UG15.T5 v1(239.87,132.4) ; UG20.P10 279.32,76.61 v1(278.92,76.21) ; UG14.M5 v1(222.67,139.6) UG14.L5 ; UG15.H13 v1(233.47,138.8) UG15.H14 ; UG19.A12 v1(282.12,95.81) ; v1(270.92,76.21) 271.32,76.61 UG20.D10 ; v1(282.12,87.81) 281.72,87.41 UG19.A1 ; UG13.C4 213.07,142.4 v1(212.67,142.8) ; UG17.G5 276.92,118.61 v1(277.32,119.01) UG17.F5 ; UG16.H14 257.47,136.8 v1(257.07,136.4) ; JDIMM2.172 156.44,37.93 v1(156.66,37.71) 157.06,37.71 157.44,38.1 JDIMM2.176 ; v1(205.47,134) 205.07,134.4 UG13.N14 ; UG16.U14 257.47,144 v1(257.07,144.4) ; UG16.C12 255.87,132.8 v1(255.47,132.4) UG16.C11 ; v1(243.07,130.8) 243.47,131.2 UG15.U1 ; JDIMM1.64 127.44,50.81 127.08,50.45 v1(126.6,50.45) 126.44,50.6 JDIMM1.60 ; v1(243.07,138.8) 242.67,138.4 UG15.H2 ; UG16.B5 250.27,132 250.66,132.39 250.68,132.39 v1(250.72,132.43) ; v1(207.87,133.2) 208.27,133.6 UG13.P10 ; JDIMM1.98 135.94,50.71 136.02,50.64 v1(136.02,50.48) ; UG13.N3 213.87,134.4 v1(213.47,134) ; v1(113.71,48.65) 113.69,48.64 JDIMM2.9 ; JWLAN.49 314.32,34.59 v1(314.14,34.77) ; UG19.A14 281.72,97.81 v1(282.12,97.41) ; UG18.K13 v1(276.52,101.81) 276.12,101.41 UG18.K14 ; JSSD2.73 272.8,6.26 v1(273.12,6.57) 272.94,6.76 JSSD2.71 ; UG18.U1 281.72,111.81 v1(282.12,111.41) ; JDIMM1.248 175.44,50.46 v1(175.42,50.44) 176.08,50.44 176.44,50.8 JDIMM1.252 ; v1(273.02,23.56) 272.93,23.65 272.93,24.04 272.71,24.25 JSSD2.1 ; UG16.E1 247.07,134.4 v1(247.47,134) ; v1(281.32,105.01) 280.92,104.61 UG18.T10 ; JDIMM2.18 115.94,38.09 v1(115.58,37.72) 115.37,37.72 114.94,38.14 JDIMM2.14 ; UG17.U3 268.92,117.01 v1(268.52,117.41) ; UG18.P10 279.32,104.61 v1(278.92,104.21) ; UG20.K1 276.12,83.81 v1(276.52,83.41) UG20.K2 ; UG20.E3 v1(271.72,81.81) ; v1(233.47,130.8) 233.07,131.2 UG15.U14 ; v1(153.48,53.99) 153.55,53.93 155,53.93 155.44,53.48 JDIMM1.168 ; v1(112.13,50.35) 111.94,50.53 JDIMM1.2 ; UG18.H2 v1(274.12,111.41) UG18.H1 ; v1(257.07,130.8) 257.47,131.2 UG16.A14 ; UG13.R12 206.67,132.8 v1(207.07,132.4) 207.47,132.8 UG13.R11 ; v1(273.25,20.35) 273.25,21.88 272.87,22.25 JSSD2.9 ; v1(124.66,41.06) 124.45,40.85 JDIMM2.52 ; JDIMM2.227 170.19,48.39 169.97,48.62 v1(169.48,48.62) 169.19,48.34 JDIMM2.223 ; UG19.U12 v1(268.52,95.81) ; JDIMM2.39 121.2,47.2 121.2,48.33 v1(121.04,48.48) 121.03,48.47 120.47,48.47 120.2,48.19 120.2,47.2 JDIMM2.35 ; JDIMM1.10 113.94,53.93 114.07,54.06 v1(114.07,54.82) ; JDIMM1.72 129.44,50.82 129.14,50.51 v1(129.03,50.51) ; UG19.L5 273.72,90.61 v1(274.12,91.01) ; UG14.K2 v1(219.47,138.8) UG14.K1 ; UG20.C14 v1(270.12,73.81) ; UG14.C3 220.67,132.8 v1(221.07,132.4) 221.47,132.8 UG14.C4 ; UG18.U14 281.72,101.41 v1(282.12,101.81) ; UG18.K1 276.12,111.81 v1(276.52,111.41) 276.12,111.01 UG18.K2 ; v1(274.12,119.01) 273.72,118.61 UG17.L5 ; UG13.H14 v1(205.47,138.8) UG13.H13 ; v1(270.12,77.01) 269.72,76.61 UG20.B10 ; UG16.E14 257.47,134.4 v1(257.07,134) ; JSSD2.21 270.78,19.25 v1(270.71,19.18) ; UG17.M5 272.92,118.61 v1(273.32,119.01) ; UG13.H2 214.67,138.4 v1(215.07,138.8) 215.47,138.4 UG13.H1 ; v1(129.03,49.9) 128.88,49.9 128.44,50.33 JDIMM1.68 ; UG14.A12 227.87,131.2 v1(227.47,130.8) ; v1(136.78,37.71) 136.94,37.87 JDIMM2.102 ; UG15.R4 v1(241.47,132.4) 241.87,132.8 UG15.R3 ; v1(227.47,134) 227.87,134.4 UG14.E12 ; v1(317.32,34.76) JWLAN.61 ; v1(280.52,101.81) 280.12,101.41 UG18.R14 ; UG20.H13 274.52,74.21 v1(274.12,73.81) UG20.H14 ; v1(113.42,50.52) 113.35,50.52 112.94,50.92 JDIMM1.6 ; UG13.C12 206.67,142.4 v1(207.07,142.8) UG13.C11 ; JDIMM2.209 165.69,48.21 165.9,48.42 v1(166.31,48.42) 166.48,48.42 166.69,48.21 JDIMM2.213 ; JDIMM1.222 168.94,50.93 v1(169.46,50.42) ; v1(243.07,134) 243.47,134.4 UG15.N1 ; UG15.N3 241.87,134.4 v1(241.47,134) ; UG16.E3 248.67,134.4 v1(249.07,134) ; UG14.P10 v1(225.87,142) ; v1(207.07,130.8) 206.67,131.2 UG13.U12 ; UG15.R12 234.67,132.8 v1(235.07,132.4) 235.47,132.8 UG15.R11 ; v1(130.25,50.51) 130.53,50.51 130.94,50.92 JDIMM1.78 ; JDIMM1.185 159.69,61.48 159.12,62.05 v1(158.84,62.05) 158.69,61.9 JDIMM1.181 ; UG14.N3 v1(221.07,141.2) ; UG14.R11 227.07,142.4 v1(227.47,142.8) 227.87,142.4 UG14.R12 ; v1(311.32,34.76) JWLAN.37 ; v1(280.52,73.81) 280.12,73.41 UG20.R14 ; JDIMM1.43 122.19,61.04 122.95,61.79 v1(123.38,61.79) ; UG18.N3 v1(278.92,109.81) ; UG20.N1 278.52,83.81 v1(278.92,83.41) ; v1(213.47,142.8) 213.87,142.4 UG13.C3 ; JDIMM2.107 138.19,48.19 137.86,48.52 v1(137.42,48.52) 137.19,48.3 JDIMM2.103 ; v1(324.74,41.75) 324.88,41.61 JSSD1.27 ; JDIMM1.230 170.94,50.74 171.17,50.51 v1(171.57,50.51) 171.94,50.88 JDIMM1.234 ; JSSD3.1 254.02,14.06 v1(254.52,14.55) ; v1(224.82,81.3) 225.23,81.7 UG1.BA35 225.47,81.65 v1(226.03,81.65) 226.57,81.65 UG1.BA33 ; UG20.H2 v1(274.12,83.41) UG20.H1 ; JDIMM2.51 124.2,47.2 124.2,48.25 124.43,48.49 v1(124.79,48.49) 125.39,48.49 125.69,48.18 JDIMM2.57 ; JDIMM2.226 169.95,39 169.95,41.17 170.67,41.89 v1(170.8,41.89) ; v1(221.07,130.8) 220.67,131.2 UG14.A3 ; UG17.C11 280.12,123.41 v1(280.52,123.81) UG17.C12 ; JDIMM1.238 172.94,50.82 v1(173.28,50.49) ; UG18.R4 280.12,109.41 v1(280.52,109.81) UG18.R3 ; JDIMM2.180 158.44,38.07 v1(158.8,37.71) ; JDIMM1.218 167.94,50.91 v1(167.55,50.52) ; v1(247.47,132.4) 247.07,132.8 UG16.C1 ; UG13.K13 v1(205.47,136.4) 205.07,136.8 UG13.K14 ; JDIMM1.86 132.94,50.79 132.66,50.51 v1(132.17,50.51) 131.94,50.73 JDIMM1.82 ; UG20.N14 v1(278.12,73.81) ; UG20.E12 v1(271.72,75.41) ; UG16.R1 v1(247.47,142.8) ; JSSD3.33 246.02,14.33 v1(244.85,15.5) 244.53,15.17 JSSD3.39 ; JDIMM2.23 117.2,47.2 117.2,48.28 v1(117.48,48.56) 117.95,48.56 118.2,48.32 118.2,47.2 JDIMM2.27 ; JDIMM2.30 118.94,38.17 v1(119.41,37.7) 120.05,37.7 120.45,38.09 JDIMM2.36 ; UG16.F10 v1(253.87,135.6) UG16.G10 ; UG14.R4 v1(221.07,142.8) 220.67,142.4 UG14.R3 ; UG19.B10 v1(281.32,94.21) ; UG20.G10 v1(273.32,77.01) 272.92,76.61 UG20.F10 ; UG16.A1 247.07,131.2 v1(247.47,130.8) ; UG16.U12 255.87,144 v1(255.47,144.4) ; v1(241.47,144.4) 241.87,144 UG15.A3 ; JDIMM2.2 111.94,38.06 112.34,37.67 112.65,37.67 112.94,37.96 JDIMM2.6 112.94,41.44 112.17,42.22 v1(112.06,42.22) ; JDIMM1.201 163.69,61 164,61.31 v1(164.54,61.31) 164.54,61.13 164.69,60.97 JDIMM1.205 ; UG14.N14 229.47,140.8 v1(229.07,140.4) ; v1(270.12,119.01) 269.72,118.61 UG17.T5 ; UG18.L5 v1(277.32,108.21) UG18.M5 ; UG20.E1 v1(271.72,83.41) ; JDIMM2.69 128.69,48.29 129.03,48.62 v1(129.03,48.86) ; UG16.C3 248.67,132.8 v1(249.07,132.4) 249.47,132.8 UG16.C4 ; JSSD1.39 326.87,38.61 326.94,38.67 327.74,38.67 v1(327.97,38.45) ; v1(282.12,73.81) 281.72,73.41 UG20.U14 ; JDIMM2.47 123.2,47.2 123.2,48.27 v1(122.94,48.52) ; UG16.R14 257.47,142.4 v1(257.07,142.8) ; UG19.K14 v1(274.12,97.41) UG19.K13 ; UG19.F5 v1(277.32,91.01) 276.92,90.61 UG19.G5 ; v1(278.92,75.41) 278.52,75.01 UG20.N12 ; JDIMM1.192 161.44,50.62 v1(161.51,50.56) 162.14,50.56 162.44,50.86 JDIMM1.196 ; UG14.H1 219.07,136.8 v1(219.47,136.4) UG14.H2 ; JDIMM2.175 157.2,48.61 156.66,49.14 v1(155.65,49.14) ; UG19.C12 v1(280.52,95.81) 280.12,95.41 UG19.C11 ; UG19.A3 281.72,89.01 v1(282.12,89.41) ; JDIMM2.64 127.45,38.04 127.11,37.71 v1(126.63,37.71) 126.63,37.81 126.45,38 JDIMM2.60 ; v1(127.94,61.9) 128.23,61.9 128.69,61.43 JDIMM1.69 ; UG18.N12 278.52,103.01 v1(278.92,103.41) ; UG15.M5 v1(239.87,135.6) UG15.L5 ; UG19.H14 276.12,97.81 v1(276.52,97.41) UG19.H13 ; UG14.A1 219.07,131.2 v1(219.47,130.8) ; v1(119.19,56.22) 119.19,56.22 JDIMM1.31 ; UG19.N12 v1(271.72,95.81) ; JDIMM2.202 163.95,39 163.95,38.14 164.38,37.71 v1(164.51,37.71) 164.59,37.71 164.95,38.06 164.95,39 JDIMM2.206 ; UG14.H14 229.47,136.8 v1(229.07,136.4) ; JDIMM1.9 113.69,60.85 v1(114.11,61.27) ; UG20.K13 v1(276.52,73.81) 276.12,73.41 UG20.K14 ; UG20.C11 270.52,75.81 v1(270.12,75.41) UG20.C12 ; UG17.E1 278.52,115.41 v1(278.92,115.81) ; v1(255.47,134) 255.87,134.4 UG16.E12 ; JDIMM1.48 123.44,52.95 123.51,53.02 123.51,54.24 123.12,54.63 v1(122.95,54.63) 122.57,54.63 122.31,54.36 122.31,53.02 122.44,52.88 JDIMM1.44 ; v1(175.39,48.52) 175.19,48.33 JDIMM2.247 ; UG19.N3 v1(271.72,89.41) ; UG13.C1 215.47,142.4 v1(215.07,142.8) ; JDIMM1.231 171.19,61.04 v1(171.41,61.26) 171.44,61.29 172.05,61.29 172.19,61.15 JDIMM1.235 ; JWLAN.1 v1(300.32,34.72) ; PU510.4 151.89,149 v1(151.87,149.02) ; UG14.N12 227.87,140.8 v1(227.47,141.2) ; UG16.R3 v1(249.07,142.8) UG16.R4 ; UG19.E1 278.52,87.41 v1(278.92,87.81) ; UG13.N1 215.47,134.4 v1(215.07,134) ; UG16.N12 255.87,140.8 v1(255.47,141.2) ; UG16.M10 v1(253.87,139.6) UG16.L10 ; v1(135.26,40.93) 135.39,40.93 135.94,40.37 JDIMM2.98 ; JDIMM1.189 160.69,61.12 160.91,61.33 161.68,61.33 161.69,61.32 v1(161.74,61.32) 161.69,61.27 JDIMM1.193 ; JWLAN.31 v1(309.82,34.98) ; v1(219.47,134) 219.07,134.4 UG14.E1 ; JSSD2.39 v1(270.65,14.76) ; UG20.N3 v1(278.92,81.81) ; v1(167.9,37.72) 167.94,37.76 JDIMM2.218 ; UG13.L5 v1(211.87,135.6) UG13.M5 ; v1(155.34,36.88) 155.44,36.98 JDIMM2.168 ; JSSD2.27 270.78,17.76 v1(270.71,17.68) ; JWLAN.55 315.82,34.31 316.28,34.77 v1(316.74,34.77) ; v1(268.52,87.81) 268.92,87.41 UG19.U1 ; v1(283.47,12.35) 283.88,11.94 JEC.8 ; UG15.C3 241.87,142.4 v1(241.47,142.8) 241.07,142.4 UG15.C4 ; JDIMM1.202 163.94,50.5 v1(164.07,50.38) 164.07,50.38 164.69,50.38 164.94,50.64 JDIMM1.206 ; UG14.C1 219.07,132.8 v1(219.47,132.4) ; UG17.K1 v1(274.12,115.81) 274.52,116.21 UG17.K2 ; v1(282.12,75.41) 281.72,75.01 UG20.U12 ; v1(271.72,123.01) 271.32,122.61 UG17.P10 ; CPU1.AF14 154.61,102.05 v1(154.32,101.76) ; UG15.B10 v1(236.67,143.6) ; UG17.R3 v1(270.12,117.41) 270.52,117.81 UG17.R4 ; UG14.K14 229.47,138.4 v1(229.07,138.8) 228.67,138.4 UG14.K13 ; UG18.E14 v1(271.72,101.81) ; UG19.E3 278.92,89.41 v1(278.92,89.41) ; v1(281.32,91.01) 280.92,90.61 UG19.B5 ; JDIMM2.31 119.19,43.57 v1(119.04,43.42) ; v1(205.47,132.4) 205.07,132.8 UG13.R14 ; JDIMM2.99 136.19,48.23 v1(135.98,48.44) ; UG15.K14 233.07,136.8 v1(233.47,136.4) UG15.K13 ; UG17.R11 v1(270.12,123.81) UG17.R12 ; v1(111.46,58.7) 111.69,58.93 JDIMM1.1 ; UG15.U12 234.67,131.2 v1(235.07,130.8) ; JDIMM2.48 123.45,40.58 123.58,40.71 123.58,41.38 123.12,41.83 v1(122.95,41.83) 122.57,41.83 122.31,41.56 122.31,40.4 122.45,40.26 JDIMM2.44 ; UG19.C14 280.12,97.81 v1(280.52,97.41) ; JDIMM1.102 136.94,50.72 137.16,50.51 v1(137.41,50.51) 137.49,50.51 137.94,50.96 JDIMM1.106 ; UG19.L10 v1(273.32,94.21) ; JSSD3.21 v1(249.02,14.55) ; UG14.C11 v1(227.47,132.4) 227.87,132.8 UG14.C12 ; UG16.B10 v1(253.87,132.4) ; 115.57,50.54 115.94,50.91 JDIMM1.18 ; 115.57,50.54 115.37,50.54 114.94,50.97 JDIMM1.14 ; 115.57,50.54 v1(115.57,50.52) ; UG19.R4 270.52,89.81 v1(270.12,89.41) UG19.R3 ; JWLAN.18 304.57,41.88 v1(304.99,42.3) ; JDIMM1.243 174.19,58.88 173.78,58.47 v1(173.17,58.47) 173.19,58.5 JDIMM1.239 ; UG19.T5 269.72,90.61 v1(270.12,91.01) ; UG17.R1 v1(270.12,115.81) ; v1(280.52,83.41) 280.12,83.81 UG20.R1 ; UG19.R11 v1(270.12,95.81) UG19.R12 ; UG15.M10 v1(236.67,135.6) 236.27,136 UG15.L10 ; v1(270.71,20.68) 270.78,20.76 JSSD2.15 ; JDIMM2.235 172.19,48.23 171.93,48.49 v1(171.71,48.49) 171.44,48.49 171.19,48.24 JDIMM2.231 ; UG17.H13 276.12,124.91 v1(275.83,124.62) ; v1(233.47,132.4) 233.07,132.8 UG15.R14 ; 166.69,61.63 166.32,61.26 165.91,61.26 165.69,61.04 JDIMM1.209 ; 166.69,61.63 JDIMM1.213 ; 166.69,61.63 v1(167.39,62.33) ; UG16.M5 v1(250.67,139.6) UG16.L5 ; v1(327.16,30.45) 327,30.61 JSSD1.71 ; v1(242.86,10.85) 242.86,10.99 243.02,11.16 JSSD3.45 243.02,13.7 242.72,14 241.83,14 241.53,13.7 JSSD3.51 ; JDIMM2.73 129.69,48.98 129.9,49.19 v1(130.31,49.19) 130.85,48.64 130.85,48.21 130.69,48.05 JDIMM2.77 ; v1(327.03,46.45) 326.69,46.11 JSSD1.9 ; UG15.R1 243.47,132.8 v1(243.07,132.4) ; UG13.U1 215.47,131.2 v1(215.07,130.8) ; JSSD3.75 235.53,13.88 v1(235.34,14.07) ; UG15.K1 243.47,136.8 v1(243.07,136.4) UG15.K2 ; UG17.K13 v1(274.12,125.41) UG17.K14 ; UG20.A12 268.92,75.01 v1(268.52,75.41) ; UG15.E1 243.47,140.8 v1(243.07,141.2) ; JDIMM2.43 122.2,47.2 122.2,48.66 122.76,49.22 v1(122.94,49.22) ; UG17.A3 281.72,117.01 v1(282.12,117.41) ; UG18.R11 v1(280.52,103.41) 280.12,103.01 UG18.R12 ; UG13.F10 v1(208.67,139.6) 208.27,139.2 UG13.G10 ; v1(125.36,37.69) 125.45,37.77 JDIMM2.56 ; JDIMM2.184 159.44,38 159.74,37.7 160.32,37.7 160.32,37.7 ; v1(167.89,145.7) 167.91,145.68 PU503.4 ; JDIMM2.210 165.95,39 165.95,38.08 v1(166.3,37.72) 166.55,37.72 166.95,38.11 166.95,39 JDIMM2.214 ; UG20.T5 v1(281.32,80.21) ; JDIMM1.51 124.19,60.91 123.9,61.21 v1(123.37,61.21) 123.19,61.03 JDIMM1.47 ; v1(268.52,89.41) 268.92,89.01 UG19.U3 ; JDIMM2.188 160.44,37.83 160.32,37.7 ; v1(120.59,41.83) 120.77,41.83 121.45,41.16 JDIMM2.40 ; UG17.H2 v1(276.52,115.81) 276.12,115.41 UG17.H1 ; v1(175.39,49.16) 175.71,49.16 176.19,48.67 JDIMM2.251 ; JDIMM1.15 115.19,60.84 115.37,61.01 115.37,61.04 115.54,61.21 v1(115.94,61.21) 116.19,60.95 JDIMM1.19 ; UG18.E12 v1(271.72,103.41) ; v1(173.26,49.74) 173.26,49.75 174.44,50.93 JDIMM1.244 ; UG20.U1 281.72,83.81 v1(282.12,83.41) ; UG14.T10 v1(225.87,143.6) ; JDIMM2.65 127.69,48.22 127.41,48.5 v1(126.58,48.5) 126.69,48.39 JDIMM2.61 ; JDIMM2.185 159.69,48.22 160.21,48.73 v1(160.34,48.73) 160.45,48.73 160.69,48.48 JDIMM2.189 ; UG13.T5 212.27,132 v1(211.87,131.6) ; v1(121.14,61.58) 121.19,61.53 JDIMM1.39 ; UG20.G5 v1(273.32,80.21) ; UG19.C3 280.12,89.01 v1(280.52,89.41) UG19.C4 ; JDIMM1.172 156.44,50.89 156.75,50.59 157.26,50.59 v1(157.26,50.59) 157.44,50.77 JDIMM1.176 ; UG17.A1 281.72,115.41 v1(282.12,115.81) ; v1(174.1,37.71) 174.44,38.06 JDIMM2.244 ; UG15.E12 v1(235.07,141.2) ; UG13.K1 215.47,136.8 v1(215.07,136.4) UG13.K2 ; v1(213.47,141.2) 213.87,140.8 UG13.E3 ; JDIMM2.234 171.94,38.05 171.6,37.71 v1(171.38,37.71) 171.21,37.71 170.94,37.98 JDIMM2.230 ; UG14.M10 v1(225.87,139.6) UG14.L10 ; UG16.T10 v1(253.87,143.6) ; JDIMM1.251 176.19,61.28 v1(176.06,61.42) ; v1(327.43,36.72) 327.18,36.72 326.79,37.11 JSSD1.45 ; JDIMM2.239 173.19,46.17 173.11,46.09 v1(173.11,45.67) 173.79,45.67 174.19,46.08 JDIMM2.243 ; v1(250.53,14.55) JSSD3.15 ; UG16.P10 v1(254.67,141.2) ; v1(215.07,141.2) 215.47,140.8 UG13.E1 ; UG17.N12 v1(271.72,123.81) ; UG16.C14 257.47,132.8 v1(257.07,132.4) ; UG17.L10 v1(273.32,122.21) ; JDIMM1.188 160.44,50.63 v1(160.32,50.51) 160.32,50.5 159.74,50.5 159.44,50.8 JDIMM1.184 ; v1(280.52,111.41) 280.12,111.81 UG18.R1 ; JSSD2.75 v1(273.12,5.76) ; UG14.T5 v1(222.67,143.6) ; JSSD1.51 324.76,35.61 324.72,35.65 v1(324.71,35.65) ; UG15.C14 v1(233.47,142.8) ; JDIMM1.223 169.19,61.17 169.32,61.3 v1(169.86,61.3) 170.19,60.97 JDIMM1.227 ; v1(213.47,132.4) 213.87,132.8 UG13.R3 ; UG16.N1 v1(247.47,141.2) ; JDIMM1.93 134.69,61.14 134.56,61.28 v1(134.41,61.28) 134,61.28 133.69,60.97 JDIMM1.89 ; v1(207.07,134) 206.67,134.4 UG13.N12 ; UG16.A12 255.87,131.2 v1(255.47,130.8) ; v1(229.07,142.8) 229.47,142.4 UG14.R14 ; UG17.E3 278.52,117.01 v1(278.92,117.41) ; UG19.G10 v1(277.32,94.21) UG19.F10 ; UG19.R1 v1(270.12,87.81) ; v1(235.07,134) 234.67,134.4 UG15.N12 ; UG14.F10 v1(225.87,135.6) UG14.G10 ; UG17.C3 280.12,117.01 v1(280.52,117.41) UG17.C4 ; JTP.7 193.82,10.1 v1(194.1,9.83) 194.32,10.05 JTP.6 ; UG20.B5 v1(270.12,80.21) ; JDIMM1.81 131.69,61.56 132.16,62.03 v1(132.64,62.03) ; v1(270.72,23.51) 270.96,23.76 JSSD2.3 ; UG16.K1 v1(247.47,138.8) UG16.K2 ; UG13.E12 v1(207.07,140.4) ; UG18.A3 v1(268.52,109.81) ; UG15.N14 233.07,134.4 v1(233.47,134) ; JDIMM2.78 130.94,38.07 130.69,37.81 v1(130.18,37.81) ; UG15.P10 v1(235.87,134) ; UG18.C11 270.52,103.81 v1(270.12,103.41) UG18.C12 ; UG13.F5 v1(211.87,139.6) UG13.G5 ; JSSD3.27 247.53,13.81 247.79,14.08 v1(247.79,14.55) ; UG18.A12 268.92,103.01 v1(268.52,103.41) ; UG18.D10 v1(271.72,104.21) ; JSSD2.57 272.74,10.25 272.96,10.04 v1(272.96,9.77) ; UG19.M5 272.92,90.61 v1(273.32,91.01) ; JDIMM1.85 132.69,61.21 v1(132.64,61.26) ; UG13.B5 v1(211.87,143.6) ; JDIMM2.86 132.94,38.02 132.68,37.75 v1(132.66,37.75) 132.34,37.75 131.94,38.14 JDIMM2.82 ; UG18.C1 v1(270.12,111.41) ; PU507.4 143.56,148.97 v1(143.54,148.99) ; v1(282.12,103.41) 281.72,103.01 UG18.U12 ; v1(121.24,62.16) 120.97,62.16 120.19,61.39 JDIMM1.35 ; JDIMM1.27 118.19,61.04 117.95,61.28 v1(117.74,61.28) 117.5,61.28 117.19,60.97 JDIMM1.23 ; v1(280.52,115.81) 280.12,115.41 UG17.C1 ; UG20.R11 v1(280.52,75.41) 280.12,75.01 UG20.R12 ; JSSD1.75 327.04,29.61 v1(327.16,29.73) 326.79,30.11 JSSD1.73 ; v1(324.71,34.17) 324.78,34.11 JSSD1.57 ; UG13.C14 v1(205.47,142.8) ; v1(169.23,37.71) 169.23,37.86 168.95,38.14 168.95,39 JDIMM2.222 ; v1(229.07,130.8) 229.47,131.2 UG14.A14 ; v1(318.82,34.76) JWLAN.67 ; UG18.E1 v1(271.72,111.41) ; UG13.T10 208.27,132 v1(207.91,132.37) ; UG16.N3 v1(249.07,141.2) ; UG20.E14 v1(271.72,73.81) ; UG18.U3 v1(282.12,109.81) ; UG18.T5 v1(281.32,108.21) ; UG20.M10 v1(277.32,77.01) 276.92,76.61 UG20.L10 ; UG18.N14 v1(278.12,101.81) ; JDIMM2.19 116.2,47.2 116.2,48.41 v1(116.13,48.47) 115.53,48.47 115.19,48.14 JDIMM2.15 ; UG13.A1 215.47,144 v1(215.07,144.4) ; UG19.C1 280.12,87.41 v1(280.52,87.81) ; JSSD3.73 236.02,13.93 v1(236.17,14.07) 236.53,13.71 JSSD3.71 ; v1(120.59,54.63) 120.77,54.63 121.44,53.96 JDIMM1.40 ; JDIMM2.238 172.94,38.02 v1(173.25,37.72) ; v1(124.72,49.82) 124.83,49.82 125.44,50.44 JDIMM1.56 ; UG16.R12 255.87,142.4 v1(255.47,142.8) 255.07,142.4 UG16.R11 ; v1(215.07,132.4) 215.47,132.8 UG13.R1 ; JDIMM2.5 112.69,48.51 v1(112.13,49.08) 111.69,48.65 JDIMM2.1 ; UG17.T10 v1(270.12,122.21) ; JWLAN.7 301.82,34.53 v1(301.63,34.72) ; v1(278.92,111.41) 278.52,111.81 UG18.N1 ; JDIMM1.57 125.69,61.42 126.18,61.91 v1(126.69,61.91) ; UG17.N1 v1(271.72,115.81) ; UG20.L5 v1(277.32,80.21) UG20.M5 ; UG14.F5 v1(222.67,135.6) ; JDIMM1.107 138.19,61.15 v1(137.99,61.35) 137.56,61.35 137.19,60.99 JDIMM1.103 ; UG15.B5 v1(239.87,143.6) ; UG20.C4 v1(270.12,81.81) UG20.C3 ; UG18.G10 v1(273.32,105.01) 272.92,104.61 UG18.F10 ; UG19.E12 v1(278.92,95.81) ; UG18.M10 v1(277.32,105.01) 276.92,104.61 UG18.L10 ; JDIMM2.106 137.94,37.99 138.18,37.75 v1(138.44,37.75) ; UG19.K1 v1(274.12,87.81) 274.52,88.21 UG19.K2 ; JSSD3.57 240.02,13.83 v1(239.78,14.07) ; v1(308.27,35.07) 308.32,35.02 JWLAN.25 ; UG13.D10 v1(207.87,141.2) ; UG20.A14 268.92,73.41 v1(268.52,73.81) ; UG17.U12 v1(268.52,123.81) ; UG20.U3 v1(282.12,81.81) ; UG20.A3 v1(268.52,81.81) ; UG13.L10 208.27,136 208.64,136.37 v1(208.78,136.37) ; v1(282.12,125.41) 281.72,125.81 UG17.A14 ; JDIMM1.90 133.94,50.56 v1(134.12,50.39) 134.6,50.39 134.94,50.74 JDIMM1.94 ; UG14.N1 v1(219.47,140.4) ; v1(241.47,141.2) 241.87,140.8 UG15.E3 ; UG19.R14 v1(270.12,97.41) ; v1(249.07,130.8) 248.67,131.2 UG16.A3 ; UG13.E14 v1(205.47,141.2) ; UG14.U12 227.87,144 v1(227.47,144.4) ; v1(281.32,77.01) 280.92,76.61 UG20.T10 ; JDIMM1.180 158.44,50.78 158.21,50.55 v1(158.12,50.55) ; UG19.N14 v1(271.72,97.41) ; v1(208.67,143.6) 208.27,143.2 UG13.B10 ; JDIMM1.26 117.94,50.91 117.87,50.84 117.54,50.51 117.52,50.51 v1(117.52,50.51) 117.32,50.51 116.94,50.88 JDIMM1.22 ; JDIMM2.94 134.94,39.85 134.57,40.23 v1(134.12,40.23) 134.07,40.23 133.94,40.1 JDIMM2.90 ; JSSD1.3 326.89,47.61 v1(327.16,47.88) 326.94,48.11 JSSD1.1 ; JDIMM2.197 162.69,48.56 162.24,49.01 v1(161.63,49.01) ; UG17.E12 v1(278.92,123.81) ; UG14.B10 v1(225.87,132.4) ; v1(137.99,62.04) 136.72,62.04 136.19,61.51 JDIMM1.99 ; UG16.G5 v1(250.67,136.4) ; v1(161.74,61.94) 162.11,61.94 162.69,61.36 JDIMM1.197 ; UG15.E14 v1(233.47,140.4) ; v1(268.52,101.81) 268.92,101.41 UG18.A14 ; v1(124.79,53.61) 124.44,53.26 JDIMM1.52 ; JDIMM1.210 165.94,50.88 v1(166.3,50.52) 166.6,50.52 166.94,50.86 JDIMM1.214 ; JSSD3.9 v1(252.02,14.55) ; v1(243.07,142.8) 243.47,142.4 UG15.C1 ; v1(160.32,37.71) 160.32,37.7 ; UG14.R1 v1(219.47,142.8) ; UG15.G10 v1(236.67,139.6) UG15.F10 ; UG19.H1 276.12,87.41 v1(276.52,87.81) UG19.H2 ; JSSD1.33 v1(327.29,40.11) ; v1(167.53,48.4) 167.69,48.24 JDIMM2.217 ; JSSD2.45 v1(270.71,13.25) ; v1(229.07,134) 229.47,134.4 UG14.E14 ; JDIMM1.77 130.69,61.59 130.3,61.99 v1(130.07,61.99) 129.65,61.99 129.49,61.82 129.49,61.12 129.69,60.92 JDIMM1.73 ; UG14.G5 v1(222.67,136.4) ; UG19.N1 v1(271.72,87.81) ; JDIMM2.196 162.44,38.08 162.07,37.7 v1(162.07,37.71) 162.06,37.7 161.9,37.7 161.44,38.16 JDIMM2.192 ; v1(257.07,140.4) 257.47,140.8 UG16.N14 ; v1(247.47,144.4) UG16.U1 ; v1(176.23,145.73) 176.25,145.71 PU504.4 ; UG19.D10 v1(278.92,95.01) ; UG19.E14 v1(278.12,97.41) ; UG15.T10 v1(235.87,132.4) ; UG17.U1 268.92,115.41 v1(268.52,115.81) ; UG14.H13 v1(228.27,137.2) ; UG19.T10 v1(270.12,94.21) ; JSSD2.51 v1(270.67,11.76) ; UG17.A12 v1(282.12,123.81) ; v1(190.32,9.89) JTP.14 ; UG17.B10 v1(281.32,122.21) ; UG20.R4 280.12,81.41 v1(280.52,81.81) UG20.R3 ; v1(113.94,40.86) JDIMM2.10 ; JDIMM1.30 118.94,50.79 119.24,50.5 v1(119.64,50.5) 119.98,50.5 120.44,50.96 JDIMM1.36 ; JDIMM1.175 157.19,61.41 156.66,61.94 v1(156.34,61.94) ; JSSD3.3 253.53,13.84 v1(252.81,14.56) ; UG17.D10 v1(278.92,123.01) ; v1(128.45,40.44) JDIMM2.68 ; UG17.N3 v1(271.72,117.41) ; v1(126.69,61.27) JDIMM1.61 ; JDIMM2.26 117.94,38.13 v1(117.52,37.71) 117.31,37.71 116.94,38.07 JDIMM2.22 ; UG20.A1 v1(268.52,83.41) ; JSSD1.15 v1(327.05,44.61) ; JSSD1.21 v1(327.11,43.11) ; v1(312.82,34.76) JWLAN.43 ; v1(129.56,40.8) 129.45,40.69 JDIMM2.72 ; UG18.B5 v1(270.12,108.21) ; UG18.C14 v1(270.12,101.81) ; UG18.G5 v1(273.32,108.21)
  BOTTOM w0.356: RV670.2 186.22,125.17 v4(185.14,126.24) 184.54,126.84 v1(184.54,127.35) ; RM62.1 137.34,150.29 137.34,149.79 v1(137.36,149.77) ; v1(197.37,12.64) 197.34,12.67 197.34,13.11 RH22.2 ; 233.05,23.93 RE485.2 233.05,23.72 233.49,23.29 v1(233.49,23.11) ; v1(231.82,159.2) 231.82,159.52 232.2,159.9 RV15.1 ; v1(227.58,29.53) 227.58,29.7 227.15,30.13 RE472.2 227.55,30.41 227.77,30.62 QE42.1 ; v1(215.15,80.61) 214.99,80.77 CG34.1 ; v1(167.55,164.18) 167.46,164.27 RV600.1 ; v1(227.58,22.92) 227.58,23.19 227.15,23.62 RE458.2 227.83,23.93 QE40.1 ; RT80.2 176.73,167.1 176.73,166.44 v1(176.77,166.4) ; v1(230.77,155.54) 231.19,155.96 RV17.2 ; v1(233.16,163.37) 233.3,163.5 CV23.2 ; CT57.2 175.45,151.55 v1(175.71,151.29) ; RH28.2 197.4,14.68 v1(197.62,14.89) ; v1(223.67,170.15) 223.64,170.12 CV1069.2 ; RA52.2 36.12,11.88 ; RG150.2 241.69,76.38 v1(241.78,76.3) ; CG31.2 v1(214.94,82.62) ; RE638.2 252.02,15.17 v1(252.02,14.55) ; 233.05,20.69 RE491.2 233.05,20.32 v1(233.37,20) ; CV35.2 237.24,168.29 v1(237.24,168.43) ; RV669.2 189.15,125.17 189.62,125.64 v1(191.12,125.64) ; RM87.2 124.65,158.41 124.32,158.74 RM72.2 123.93,159.07 v1(123.52,158.66) ; RE641.2 257.71,16.99 v1(257.95,17.22) ; QE41.1 227.77,27.39 227.56,27.17 RE465.2 227.15,26.89 227.58,26.46 v1(227.58,26.29) ; CT59.2 181.24,164.57 180.77,164.57 v1(180.65,164.46) ; QE39.1 227.83,20.69 RE453.2 227.15,20.35 227.72,19.78 v1(227.97,19.78) ; v1(210.4,84.03) 210.19,83.83 RG159.2 ; RG168.1 230.76,76.54 230.37,76.16 v1(230.37,75.89) ; v1(233.02,26.3) 233.02,27.07 RE479.2 ; RE401.2 v1(233.05,29.51) ; v1(139.4,153.75) RM75.1
  BOTTOM w0.381: CT102.2 196.1,168.18 195.4,168.18 v1(195.21,167.99) ; QM2.1 151.86,166.42 v1(152.32,165.96) ; v1(231.34,162.26) 231.05,162.55 UV3.15 ; v1(227.15,158.76) UV3.8 ; v1(182.62,170.54) 182.65,170.5 CT82.2 ; 199.08,169.08 v1(199.14,169.13) ; 199.08,169.08 RT69.2 RT68.2 ; 199.08,169.08 198.5,168.49 198.5,168.08 RT71.2 ; PR5034.1 125.43,116.19 v1(125.04,115.79) ; CV484.2 197.38,89.71 197.14,89.47 UV22.15 ; UG1.BA14 244.77,81.7 v1(245.22,81.25) ; QE29.1 233.67,30.35 RE401.2 ; v1(179.97,170.4) 179.97,170.31 179.84,170.18 CT65.2 ; RT79.2 RT78.2 v1(179.97,151.29) ; QE41.4 230.26,28.69 230.54,28.96 RE468.2 v1(230.83,29.75) ; QE40.4 230.26,25.45 230.54,25.72 RE462.2 v1(230.83,26.51) ; v1(236.82,81.25) 237.27,81.7 UG1.BA21 ; DT10.3 192.81,172.85 v1(192.88,172.79) ; QE45.1 233.73,20.69 233.05,20.69 ; CT64.2 180.41,169.98 180.51,170.08 180.51,170.12 180.68,170.29 180.71,170.29 180.79,170.38 v1(180.98,170.38) 180.98,170.37 CT66.2 ; PC210.2 93.02,48.05 93.93,47.15 PR207.2 94.1,47.1 94.15,47.06 94.15,46.52 v1(94.07,46.44) ; v1(229.07,132.4) 229.47,132.8 UG14.C14 ; RT72.2 197.81,168.88 198.26,169.32 v1(198.45,169.32) ; v1(181.95,166.41) 181.95,166.46 182.4,166.91 CT86.2 ; v1(176.79,156.62) 176.84,156.67 176.84,157.12 177.36,157.64 v4(177.36,158.78) 177.36,159.5 RT39.2 ; v1(230.83,32.99) RE473.2 230.54,32.2 230.26,31.92 QE42.4 ; CT58.2 176.08,152.06 176.28,151.86 176.28,151.42 176.32,151.38 v1(176.32,151.32) 176.35,151.36 176.83,151.36 RT24.2 ; v1(179.35,163.81) 179.38,163.84 CT61.2 ; CM9.2 133.68,161.74 131.86,161.74 v1(131.83,161.72) ; RH30.2 RH26.2 198.95,16.2 v1(198.88,16.28) ; v1(179.21,173.2) 178.86,172.85 RT42.2 RT45.2 ; CT80.2 180.58,164.38 v1(180.65,164.46) ; UG1.W4 252.82,101.9 UG1.V3 253.72,102.95 v1(254.17,103.4) ; QE45.4 236.24,22.21 236.24,22.22 236.43,22.41 236.51,22.41 236.58,22.49 RE490.2 236.74,23.05 v1(236.44,23.34) ; v1(242.82,90.35) 242.37,90.8 UG1.AK17 v1(241.62,90.8) 241.62,91.4 UG1.AJ17 ; v1(206.96,162.4) RT63.2 ; CT60.2 181.34,161.89 v1(181.3,161.86) ; UG1.V32 227.42,102.95 v1(226.97,103.4) ; RT22.2 202.21,158.08 CT90.2 ; v1(184.56,165.1) 184.51,165.06 CT71.2 ; CM17.2 175.01,160.31 175.37,159.95 175.37,159.3 v1(175.36,159.29) ; UG1.AD5 252.82,95.9 UG1.AE4 252.82,95.45 v1(253.27,95) ; v1(131.15,101.57) 130.82,101.57 130.49,101.24 C11.2 ; v1(178.05,166.41) 178.11,166.47 CT47.2 ; CU21.2 10.5,56.92 v1(10.11,57.31) ; UG1.BA18 241.17,81.7 v1(241.62,81.25) ; 235.97,170.7 235.97,169.45 v1(235.72,169.2) ; UG1.AU23 236.37,85.2 237.17,86 UG1.AT21 ; UM4.19 170.54,158.17 v1(170.28,157.91) ; JKBBL.2 v1(169.32,6.71) ; QM2.4 149.68,164.81 v1(149.93,164.56) ; 233.05,23.93 233.73,23.93 QE44.1 ; v1(230.83,23.27) RE456.2 230.54,22.49 230.26,22.21 QE39.4 ; v1(234.93,77.07) 235.12,76.87 RG161.1 RG163.1 ; v1(250.22,112) UG1.F6 v1(251.32,113.1) ; UG15.H1 v1(243.07,138.8) ; QE29.4 236.17,31.92 236.44,32.2 RE397.2 236.99,32.2 237.37,31.82 v1(237.37,31.21) ; UG1.U14 244.22,103.6 UG1.U15 ; v1(237.31,76.78) 237.19,76.78 RG165.1 ; v1(210.46,117.63) 210.89,118.06 UG2.3 ; RS3.2 101.46,13.11 v1(101.39,13.18) ; UG1.BA9 248.37,81.7 v1(248.82,81.25) ; v1(169.82,8.91) JKBBL.1 ; CT84.2 184.46,166.97 v1(184.56,167.07) 185.19,167.07 RT44.2 ; CT81.2 183.54,170.33 v1(183.74,170.53) ; UM4.15 v1(167.94,158.61) ; UG20.C1 v1(270.12,83.41) ; v1(205.11,168.75) 205.15,168.71 RT65.2 204.76,168.13 204.11,168.13 203.84,167.86 RT64.2 ; PR6045.2 239.56,75.93 PC6540.2 ; RE479.2 233.67,27.11 QE43.1 ; CT55.2 185.15,163.21 v1(185.2,163.17) ; v1(247.62,79.45) 247.17,79.9 UG1.BC11 ; RT19.2 184.79,161.46 v1(184.55,161.22) ; RA75.2 33.86,1.47 34.47,1.47 v1(34.49,1.45) ; CT69.2 181.56,170.5 v1(181.59,170.53) ; v1(222.82,85.4) 222.82,85.8 UG1.AT38 ; CT62.2 178.01,165.15 v1(178.05,165.11) ; UM4.6 167.94,154.82 v1(168.48,155.36) ; v1(139.71,160.5) 139.33,160.12 RM23.1 RM82.1 ; UG3.5 204.47,116.49 202.47,118.48 v1(201.14,118.48) ; UG1.AT39 221.27,85.55 v1(221.27,85.4) 220.82,85.85 UG1.AT40 ; v1(124.38,149.93) RM84.1 ; QE44.4 236.17,25.45 236.44,25.72 RE484.2 237.02,26 v1(237.02,26.45) ; UG1.H8 UG1.J9 ; JDP.8 234.18,169.62 v1(233.86,169.3) ; RG166.1 232.74,77.03 v1(232.55,77.22) ; v1(184.55,165.76) 184.46,165.67 CT85.2 ; RT43.2 186.61,166.4 v1(186.76,166.25) ; QE43.4 236.17,28.69 236.44,28.96 RE478.2 237.05,29.28 v1(237.05,29.75) ; RM64.2 v1(139.58,157.36) ; CT57.2 CT78.2
  BOTTOM w0.4: UG1.AR33 226.62,87.2 v1(226.02,87.8) ; UG1.AR33 226.17,86.35 v1(226.02,86.35) ; UG1.AR33 226.77,86.8 v1(227.22,86.35) 227.37,86.35 UG1.AR32 ; UG1.AN1 255.97,87.95 v1(255.97,87.8) ; UG1.V12 246.67,103.25 v1(246.67,103.4) ; v1(222.97,93.8) 222.97,93.65 UG1.AG37 ; v1(246.67,99.8) 246.67,99.65 UG1.AA12 ; UG1.A6 251.07,117.75 v1(251.22,117.75) ; v1(250.02,114.15) 249.87,114.15 UG1.E8 ; v1(219.52,115.4) 219.52,115.2 UG1.D41 ; v1(244.02,87.15) 243.87,87.15 UG1.AP15 ; UG1.BA27 230.99,82.13 v1(230.82,82.13) 230.64,82.13 UG1.BA29 ; v1(229.62,83.92) 230.1,84.4 UG1.AV29 ; v1(229.62,83.92) 230.05,83.5 UG1.AW29 ; v1(229.62,83.92) 229.2,83.5 UG1.AW30 ; v1(229.62,83.92) 229.15,84.4 UG1.AV30 ; v1(220.37,86.6) UG1.AT41 ; v1(220.37,86.6) UG1.AT40 v1(220.37,85.4) ; v1(220.37,86.6) UG1.AR40 v1(220.37,87.8) ; v1(220.37,86.6) UG1.AR41 ; UG1.AT41 219.47,86.6 ; UG1.AT41 v1(220.37,85.4) ; UG1.AT41 v1(219.47,85.4) UG1.AT42 ; UG1.K25 233.37,110.05 v1(233.22,110.05) ; UG1.AA32 v1(226.97,98.6) ; v1(226.97,98.6) UG1.AA33 v1(226.17,98.6) UG1.AC33 ; v1(226.97,98.6) UG1.AC32 v1(226.97,97.4) ; v1(226.97,98.6) UG1.AC33 ; v1(226.97,107) 226.97,106.85 UG1.P32 ; UG1.A38 222.57,117.75 v1(222.42,117.75) ; UG1.AR9 v1(248.92,86.5) ; v1(242.82,111.65) 242.67,111.65 UG1.H17 ; UG1.R4 253.27,105.65 253.27,105.95 UG1.P3 254.17,106.85 v1(254.17,107) 254.17,107.15 UG1.M2 ; v1(223.62,114.15) 223.77,114.15 UG1.E36 ; UG1.AW35 225.57,83.5 v1(226.02,83.95) ; UG1.Y36 223.77,99.95 v1(223.77,99.8) ; UG1.AL23 236.67,89.55 v1(236.82,89.55) ; UG1.L43 217.8,109.12 v1(217.8,109.4) ; v1(250.58,109.38) 250.58,109.16 UG1.L7 ; UG1.AJ1 v1(256.15,92) ; v1(251.47,90.2) 251.47,90.35 UG1.AK6 ; v1(226.02,87.8) UG1.AR35 ; v1(226.02,87.8) UG1.AN33 ; UG1.AR35 225.37,87 v1(226.02,86.35) ; UG1.AR35 224.42,87 UG1.AR36 223.77,86.75 v1(223.77,86.6) ; UG1.D15 243.87,115.05 244.17,115.05 UG1.C14 245.07,115.95 v1(245.22,115.95) 245.37,115.95 UG1.B12 ; v1(250.67,95) 250.67,94.75 UG1.AF6 ; UG1.AM11 247.47,89.15 v1(247.47,89) ; v1(221.27,116.85) 221.37,116.85 UG1.B39 ; v1(221.27,111.8) 221.27,111.65 UG1.H39 ; v1(222.07,85.4) UG1.AT39 ; v1(222.07,85.4) 222.07,85.45 222.57,86 UG1.AT38 ; v1(222.07,85.4) UG1.AV39 221.27,84.2 UG1.AV40 v1(220.37,85.4) ; UG1.AT21 237.65,86 v1(238.06,86.4) ; v1(220.37,105.8) 220.37,105.65 UG1.R40 ; v1(223.77,91.4) 223.77,91.55 UG1.AJ36 ; UG1.BA30 228.6,82.13 228.46,82.13 v1(228.42,82.17) 228.38,82.13 228.25,82.13 UG1.BA32 ; v1(246.42,87.95) 246.27,87.95 UG1.AN12 ; UG1.AT42 219.47,86.6 ; UG1.AT42 UG1.AT43 ; v1(224.61,96.16) 224.61,96.39 UG1.AD35 ; v1(217.67,105.8) 217.67,105.65 UG1.R43 ; v1(254.17,90.2) 254.17,90.35 UG1.AK3 253.27,91.25 253.27,91.55 UG1.AJ4 ; UG1.A19 v1(239.82,118) ; v1(228.42,87.25) 228.67,87.25 UG1.AP30 ; UG1.Y37 222.97,100.85 v1(222.97,101) 222.62,101.35 UG1.W38 UG1.W39 UG1.W40 v1(220.37,101) ; UG1.BA4 UG1.AY3 254.17,81.95 v1(254.17,81.8) ; UG1.B24 235.47,115.95 v1(235.62,115.95) 235.77,115.95 UG1.C23 ; UG1.K29 229.77,110.05 v1(229.62,110.05) ; UG1.U2 254.17,103.55 v1(254.17,103.4) ; UG1.AG35 224.57,92.75 v1(224.57,92.6) ; v1(228.42,113.25) 228.57,113.25 UG1.F30 ; v1(232.02,91) 231.62,91 UG1.AK27 ; UG1.A42 218.66,117.76 v1(218.58,117.76) ; UG1.AK36 223.77,90.35 v1(223.77,90.2) ; UG1.P24 234.57,106.85 v1(234.42,106.85) ; UG1.BB2 v1(255.02,80.4) ; UG1.C35 224.97,115.95 v1(224.82,115.95) ; v1(220.37,87.8) UG1.AN40 v1(220.37,89) UG1.AM40 v1(220.37,90.2) ; v1(220.37,87.8) UG1.AR41 ; v1(254.17,114.2) 254.17,114.05 UG1.E3 ; UG1.BB8 249.42,80.71 v1(249.78,80.35) ; UG1.AM8 249.87,89.15 v1(249.87,89) ; v1(248.27,95) 248.27,95.15 UG1.AE10 ; UG1.AD40 v1(220.37,97.4) ; v1(220.37,97.4) UG1.AC41 ; v1(220.37,97.4) UG1.AC40 v1(220.37,98.6) ; v1(248.23,102.08) 248.23,102.01 UG1.W10 ; v1(226.02,117.75) 226.17,117.75 UG1.A33 ; v1(224.72,110.7) UG1.J35 ; v1(226.02,86.35) 225.77,86.35 UG1.AT35 ; UG1.B1 255.97,116.75 v1(255.97,116.9) ; UG1.H24 235.37,110.85 v1(235.62,110.85) ; v1(255.07,89) 255.07,89.15 UG1.AM2 ; v1(220.37,91.4) UG1.AK41 ; v1(220.37,91.4) UG1.AK40 v1(220.37,90.2) ; v1(220.37,91.4) UG1.AJ40 ; UG1.AK41 v1(219.47,90.2) ; UG1.AK41 v1(219.47,91.4) ; UG1.AK41 v1(220.37,90.2) ; UG1.BC2 254.96,79.46 v1(254.96,79.41) ; UG1.Y35 224.57,100.85 v1(224.57,101) 224.57,101.25 UG1.W36 ; v1(255.07,83.05) 255.07,83.15 UG1.AW2 ; UG1.AK18 241.16,90.8 v1(241.62,90.8) ; UG1.AY19 240.27,82.15 v1(240.42,82.15) 240.87,82.6 UG1.AY18 ; v1(229.62,90.35) 229.77,90.35 UG1.AK29 230.22,91.2 UG1.AJ29 ; v1(252.42,80.53) 252.09,80.53 UG1.BB5 ; v1(251.32,113.1) UG1.E5 v1(252.42,114.2) ; v1(249.87,108.2) 249.87,108.05 UG1.M8 ; v1(232.02,108.45) 232.17,108.45 UG1.M26 ; UG1.AD37 222.97,97.25 v1(222.97,97.4) ; UG1.AV32 227.67,84.4 v1(227.22,83.95) ; v1(229.69,87.25) 229.87,87.25 UG1.AP29 ; UG1.H20 238.27,110.85 v1(238.02,110.85) 237.87,110.85 UG1.J21 ; v1(220.37,101) UG1.W41 v1(219.47,101) ; v1(220.37,101) UG1.Y40 ; v1(218.57,111.8) 218.57,111.65 UG1.H42 ; UG1.AC41 v1(219.47,97.4) ; UG1.AC41 v1(219.47,98.6) ; UG1.AC41 v1(220.37,98.6) ; UG1.B20 238.18,115.96 v1(238.02,115.96) 237.88,115.96 UG1.C21 ; v1(222.42,115.05) 222.57,115.05 UG1.D38 ; UG1.BB1 255.97,80.45 v1(255.97,80.3) ; UG1.Y30 228.57,100.85 v1(228.57,101) ; v1(255.97,84.2) 255.97,84.35 UG1.AV1 ; v1(227.22,83.95) 226.77,83.5 UG1.AW33 ; v1(227.22,83.95) 226.77,84.4 UG1.AV33 ; v1(227.22,83.95) 227.37,83.95 UG1.AW32 ; 219.47,86.6 UG1.AR41 ; UG1.AF12 246.67,93.95 v1(246.67,93.8) ; UG1.F9 248.22,112.85 248.77,113.4 v1(248.82,113.4) ; v1(219.47,107) 219.47,106.85 UG1.P41 ; v1(227.22,116.85) 227.37,116.85 UG1.B32 ; v1(252.37,101) 252.37,100.85 UG1.Y5 ; v1(249.87,104.6) 249.87,104.45 UG1.U8 ; UG1.F1 255.97,112.85 v1(255.97,113) ; UG1.AE36 223.77,95.15 v1(223.77,95) ; UG1.F26 232.97,112.45 v1(233.22,112.45) ; v1(241.62,79.45) 241.47,79.45 UG1.BC18 UG1.BB18 ; UG1.AU24 234.62,84.8 v1(234.45,84.8) 234.36,84.79 UG1.AU25 ; UG1.AE40 v1(220.37,95) ; v1(220.37,95) UG1.AF41 ; v1(220.37,95) UG1.AF40 v1(220.37,93.8) ; v1(219.47,93.8) UG1.AF41 ; UG1.AF41 v1(220.37,93.8) ; UG1.AF41 v1(219.47,95) ; UG1.BA14 244.47,81.7 v1(244.02,82.15) 243.87,82.15 UG1.AY15 ; UG1.P11 247.47,106.85 v1(247.47,107) 247.02,107.45 UG1.M11 247.47,108.05 v1(247.47,108.2) ; UG1.K15 243.87,110.05 v1(244.02,110.05) ; v1(220.37,93.8) UG1.AG40 ; v1(233.22,87.15) UG1.AP25 ; v1(253.27,113) 253.27,112.85 UG1.F4 ; v1(240.42,112.45) 240.67,112.45 UG1.F18 ; v1(228.42,108.45) 228.57,108.45 UG1.M30 ; UG1.H2 254.17,110.75 254.17,110.6 v1(254.17,110.6) 254.17,110.45 UG1.J3 253.27,109.55 253.27,109.25 UG1.L4 ; v1(246.42,109.25) 246.27,109.25 UG1.L12 245.67,108.8 v1(245.22,109.25) 245.07,109.25 UG1.L14 ; v1(220.37,98.6) UG1.AA40 ; v1(251.22,79.45) 251.07,79.45 UG1.BC6 ; UG1.Y8 249.07,100.05 v1(249.07,99.8) 249.07,99.65 UG1.AA9 ; UG1.AY11 247.47,82.15 v1(247.62,82.15) 248.07,81.7 UG1.BA9 ; UG1.B36 223.77,116.85 v1(223.62,116.85) ; UG1.A29 230.22,117.87 v1(230.24,117.89) ; UG1.B8 249.01,115.99 v1(248.8,115.99) 248.75,115.95 248.67,115.95 UG1.C9 247.77,115.05 247.47,115.05 UG1.D11 ; v1(256.17,108.8) UG1.L1 ; v1(232.02,111.65) 232.17,111.65 UG1.H26 ; UG1.Y2 254.18,99.96 v1(254.18,99.8) 254.18,99.66 UG1.AA3 ; v1(240.42,87.15) 240.27,87.15 UG1.AP19 ; UG1.AC33 v1(226.17,97.4) ; UG1.AC33 v1(226.97,97.4) ; UG1.P29 229.77,106.85 v1(229.62,106.85) ; UG1.A11 v1(247.02,118) ; UG1.BB12 246.27,80.35 v1(246.42,80.35) 246.87,79.9 UG1.BC11 ; UG1.C5 252.27,115.95 v1(252.42,115.95) ; UG1.M23 235.77,108.45 v1(235.62,108.45) ; v1(251.62,110.6) 251.62,110.55 251.07,110 UG1.J6 ; UG1.AR41 v1(219.47,87.8) ; v1(245.07,104.6) 245.07,104.45 UG1.U14 ; UG1.AK20 239.07,90.35 v1(239.22,90.35) ; UG1.AU19 240.15,84.87 v1(240.42,84.87) 240.69,84.87 UG1.AU18 ; UG1.J41 219.47,110.45 v1(219.47,110.6) ; UG1.AK12 246.67,90.35 v1(246.67,90.2) ; v1(233.22,82.15) 233.07,82.15 UG1.BA26 ; UG1.M42 218.57,108.05 v1(218.57,108.2) ; v1(248.27,91.4) 248.27,91.55 UG1.AJ10 ; v1(220.37,113) 220.37,112.85 UG1.F40 ; UG1.E42 218.57,114.05 v1(218.57,114.15) ; v1(242.82,106.85) 242.67,106.85 UG1.P17 ; v1(248.27,105.8) 248.27,105.65 UG1.R10 ; UG1.W1 v1(256.22,101.6) ; UG1.AM26 232.17,88.75 v1(232.02,88.75) 231.67,88.4 UG1.AN27 ; v1(230.82,110.05) 230.97,110.05 UG1.K27 ; v1(245.07,91.4) 245.07,91.55 UG1.AJ14 ; UG1.L40 220.37,109.25 v1(220.37,109.4) ; v1(227.22,111.65) 227.37,111.65 UG1.H32 ; UG1.F14 245.07,113.25 v1(245.22,113.25) ; v1(241.62,81.25) 242.07,80.8 UG1.BB17 242.67,80.35 v1(242.82,80.35) ; v1(223.77,93.8) 223.77,93.95 UG1.AF36 ; UG1.AY6 251.07,82.15 v1(251.22,82.15) ; v1(249.07,97.4) 249.07,97.15 UG1.AD8 ; UG1.M18 241.47,108.45 v1(241.62,108.45) ; UG1.M33 226.17,108.05 v1(226.17,108.2) ; UG1.D19 240.27,115.05 240.57,115.05 UG1.C18 241.47,115.95 v1(241.62,115.95) 241.77,115.95 UG1.B17 ; v1(252.37,111.8) 252.37,111.65 UG1.H5 ; v1(225.37,102.2) 225.37,102.05 UG1.W34 ; UG1.AV14 245.07,83.95 v1(245.22,83.95) ; v1(238.02,113.26) 237.88,113.26 UG1.F21 ; UG1.R34 225.37,105.65 v1(225.37,105.8) ; UG1.V37 222.97,103.25 v1(222.97,103.4) ; v1(251.47,86.6) 251.47,86.75 UG1.AR6 ; UG1.AM32 226.97,90.05 v1(226.97,90.2) UG1.AK32 v1(226.97,91.4) UG1.AJ32 v1(226.97,92.6) UG1.AG32 v1(226.97,93.8) 226.97,93.95 UG1.AF32 v1(226.97,95) UG1.AE32 v1(226.97,96.2) UG1.AD32 v1(226.97,97.4) ; UG1.AA36 223.77,98.75 v1(223.77,98.6) ; v1(246.67,97.4) 246.67,97.55 UG1.AC12 ; UG1.AN4 253.27,87.95 v1(253.27,87.8) ; UG1.AW8 249.27,83.5 v1(248.82,83.95) 248.67,83.95 UG1.AV9 ; UG1.AL29 229.77,89.55 v1(229.62,89.55) ; UG1.AN24 v1(234.42,87.95) ; v1(238.02,108.45) 237.87,108.45 UG1.M21 ; v1(223.77,104.6) 223.77,104.45 UG1.U36 ; UG1.AW27 231.76,83.84 v1(232.11,83.84) 232.28,83.84 UG1.AW26 233.07,83.05 v1(233.22,83.05) 233.37,83.05 UG1.AY25 ; v1(249.87,92.6) 249.87,92.75 UG1.AG8 ; UG1.F23 235.77,113.25 v1(235.62,113.25) 235.47,113.25 UG1.E24 234.57,114.15 234.27,114.15 UG1.D25 233.37,115.05 v1(233.22,115.05) 233.07,115.05 UG1.C26 232.17,115.95 231.87,115.95 UG1.B27 ; UG1.U29 UG1.V30 228.57,103.25 v1(228.57,103.4) UG1.U30 228.57,104.45 v1(228.57,104.6) UG1.R30 228.57,105.65 v1(228.57,105.8) ; UG1.AM37 222.97,89.15 v1(222.97,89) ; UG1.P6 251.47,106.85 v1(251.47,107) ; v1(223.77,87.8) 223.77,87.95 UG1.AN36 224.61,88.79 224.61,89.19 UG1.AM35 ; v1(224.82,113.25) 224.97,113.25 UG1.F35 ; v1(223.77,108.2) 223.77,108.05 UG1.M36 ; v1(253.27,95) 253.27,94.85 UG1.AF3 254.17,93.95 254.17,93.65 UG1.AG2 ; v1(217.67,116.9) 217.67,116.75 UG1.B43 ; UG1.D6 251.07,115.05 v1(251.22,115.05) ; UG1.H12 246.27,111.65 v1(246.42,111.65) ; UG1.AT5 252.37,85.55 v1(252.37,85.4) 252.37,85.25 UG1.AV4 ; UG1.BA36 223.77,81.25 223.66,81.25 223.65,81.24 v1(223.59,81.24) 223.53,81.24 223.53,81.25 223.47,81.25 UG1.BA38 UG1.BA39 UG1.BA40 ; v1(245.22,88.75) 245.07,88.75 UG1.AM14 ; v1(222.17,107) 222.17,106.85 UG1.P38 ; UG1.J9 247.92,109.7 v1(247.52,109.3) UG1.L11 ; UG1.AK24 v1(234.42,90.25) UG1.AL25 ; UG1.AR3 254.17,86.75 v1(254.17,86.6) 254.62,86.15 UG1.AT2 ; UG1.AD2 254.17,97.25 v1(254.17,97.4) 254.17,97.55 UG1.AC3 ; UG1.H27 230.97,111.65 v1(230.82,111.65) ; UG1.AE1 v1(256.22,95.6) ; UG1.AA6 251.48,99.66 v1(251.48,99.8) ; UG1.L32 227.37,109.25 v1(227.22,109.25) ; v1(222.17,110.6) 222.17,110.45 UG1.J38 ; UG1.U42 218.57,104.45 v1(218.57,104.6) ; v1(228.42,115.95) 228.57,115.95 UG1.C30 229.47,115.05 229.77,115.05 UG1.D29 ; v1(220.55,114.67) 220.54,114.67 220.54,114.71 220.62,114.79 UG1.C40 ; v1(255.12,117.75) 254.97,117.75 UG1.A2 ; v1(240.42,110.05) 240.27,110.05 UG1.K19 ; v1(242.82,85.55) 242.67,85.55 UG1.AT17 ; v1(250.22,112) UG1.H8 ; v1(236.82,81.25) 236.67,81.25 UG1.BA23 ; v1(230.77,85.5) 231.27,86 UG1.AT27 231.57,86 v1(232.02,85.55) 232.17,85.55 UG1.AT26 ; v1(241.62,88.75) 241.47,88.75 UG1.AM18 ; UG1.AD5 251.47,97.25 v1(251.47,97.4) 251.47,97.55 UG1.AC6 ; v1(244.02,79.45) 243.87,79.45 UG1.BC15 ; UG1.AG10 248.27,92.75 v1(248.27,92.6) ; UG1.P9 249.07,106.85 v1(249.07,107) ; UG1.F38 v1(222.32,113.1) ; v1(250.67,102.2) 250.67,102.45 UG1.V6 ; UG1.A25 v1(233.82,118) ; UG1.B2 v1(255.02,116.8) ; UG1.AV20 239.07,83.95 v1(239.22,83.95) ; UG1.A15 v1(243.42,118) ; UG1.AW41 219.89,83.6 219.49,83.2 v1(219.49,83.03) 219.49,82.8 219.89,82.4 UG1.AY41 ; UG1.F43 217.67,112.85 v1(217.67,113) ; v1(241.62,106.85) 241.47,106.85 UG1.P18 ; UG1.AV38 222.82,84.37 v1(222.39,83.94) 221.99,83.55 UG1.AW39 ; v1(246.42,85.55) 246.27,85.55 UG1.AT12 ; UG1.AV6 v1(251.32,84.1) UG1.AW5 ; UG1.AD14 245.07,96.35 v1(245.07,96.2) ; UG1.E39 v1(221.27,114.15) ; UG1.B42 219.35,116.07 v1(219.97,116.07) ; v1(226.02,115.05) 226.17,115.05 UG1.D33 ; v1(244.02,90.35) 243.87,90.35 UG1.AK15 ; UG1.AF8 249.87,93.95 v1(249.87,93.8) ; v1(223.77,97.4) 223.77,97.55 UG1.AC36 ; v1(256.22,105.2) UG1.R1
  BOTTOM w0.406: v1(213.11,117.06) 213.68,117.63 UG4.3 ; v1(286.14,12.35) 286.14,12.8 286.29,12.94 JEC.10 ; v1(159.08,172.82) 159.58,172.82 UM3.3 ; UV23.2 211.72,107.95 v1(211.91,107.77) ; v1(150.58,175.29) 150.91,174.95 UM7.3
  BOTTOM w0.432: QE57.4 252.86,14.56 v1(252.81,14.56) ; UX2.3 211.7,156.37 v1(212.09,155.99) ; QG507.4 v1(260.46,49.6) ; QG505.4 v1(257.84,49.64) ; QG507.1 v1(261.76,49.18) ; QG505.1 v1(259.14,49.65) ; QE57.1 255.41,16.98 v1(254.84,16.4) ; JEC.9 v1(286.06,7.44)
  BOTTOM w0.457: v1(36.8,32.01) 36.84,31.97 36.99,31.97 CA12.2 ; C258.2 65.9,17.84 v1(66.11,17.62)
  BOTTOM w0.5: v1(240.32,101.1) UG1.W18 v1(240.32,102.1) ; v1(240.32,101.1) UG1.Y18 ; v1(240.32,101.1) UG1.W19 ; v1(240.32,101.1) UG1.Y19 ; v1(232.32,95.1) UG1.AE26 232.32,96.1 ; v1(232.32,95.1) UG1.AF27 v1(232.32,94.1) ; v1(232.32,95.1) UG1.AE27 ; v1(232.32,95.1) UG1.AF26 v1(232.32,94.1) ; UG1.W23 v1(235.32,101.1) UG1.Y23 ; UG1.W23 236.32,102.1 ; UG1.W23 v1(235.32,102.1) UG1.V23 ; UG1.W23 v1(236.32,101.1) ; v1(237.32,105.1) UG1.R22 v1(236.32,105.1) ; v1(237.32,105.1) 237.56,105.34 UG1.R21 237.86,105.6 v1(238.32,105.13) ; v1(237.32,105.1) UG1.T22 v1(236.32,105.1) ; 232.32,100.1 UG1.AA26 ; 232.32,100.1 UG1.AA27 232.34,99.08 ; 232.32,100.1 UG1.Y26 ; 232.32,100.1 UG1.Y27 v1(232.32,101.1) ; UG1.AA26 233.33,100.11 ; UG1.AA26 232.34,99.12 232.34,99.08 ; UG1.AA26 232.89,99.6 v1(233.38,99.1) 232.88,98.6 UG1.AB26 232.82,98.48 v1(232.43,98.09) ; v1(232.32,94.1) UG1.AG27 ; v1(232.32,94.1) UG1.AG26 ; v1(232.32,103.1) UG1.U26 ; v1(232.32,103.1) UG1.V27 v1(232.32,102.1) ; v1(232.32,103.1) UG1.U27 232.32,104.1 ; v1(232.32,103.1) UG1.V26 v1(232.32,102.1) ; UG1.U26 v1(233.32,104.1) UG1.T26 ; UG1.U26 232.32,104.1 ; 236.32,102.1 UG1.W22 v1(236.32,101.1) ; 236.32,102.1 UG1.V22 v1(236.32,103.1) ; 236.32,102.1 UG1.V23 ; v1(236.32,103.1) UG1.U23 v1(235.32,104.1) UG1.T23 v1(236.32,105.1) ; v1(236.32,103.1) UG1.V23 ; v1(236.32,103.1) UG1.U22 ; 240.32,104.1 UG1.U18 v1(241.32,103.1) UG1.V18 v1(240.32,102.1) ; 240.32,104.1 UG1.U19 v1(239.32,103.1) UG1.V19 ; 240.32,104.1 UG1.T18 v1(241.32,105.1) UG1.R17 ; 240.32,104.1 UG1.T19 ; UG1.Y26 v1(232.32,101.1) ; UG1.Y26 233.31,100.11 233.33,100.11 ; v1(232.32,101.1) UG1.W27 v1(232.32,102.1) ; v1(232.32,101.1) UG1.W26 v1(232.32,102.1) ; 232.36,97.06 UG1.AC27 ; 232.36,97.06 v1(232.36,97.14) ; 232.36,97.06 UG1.AD26 232.32,96.1 ; 232.36,97.06 232.28,97.06 UG1.AD27 ; 240.32,100.1 UG1.AA18 ; 240.32,100.1 UG1.AA19 ; 240.32,100.1 UG1.Y19 ; 240.32,100.1 UG1.Y18 ; UG1.AA18 240.33,99.11 ; UG1.AA18 v1(241.32,100.1) UG1.Y18 ; UG1.AE19 v1(239.32,96.1) UG1.AD19 ; UG1.AE19 240.32,95.1 ; UG1.AE19 240.32,96.1 ; v1(232.43,98.09) 232.82,97.7 UG1.AC26 ; v1(232.43,98.09) 231.92,98.6 UG1.AB27 ; UG1.R29 v1(230.32,105.1) UG1.T28 ; UG1.R29 229.33,105.35 UG1.R30 ; UG1.R29 UG1.P29 v1(230.82,106.85) UG1.P27 UG1.R27 232.29,105.13 ; 240.32,98.1 UG1.AC18 ; 240.32,98.1 UG1.AB19 ; 240.32,98.1 UG1.AB18 240.82,98.63 240.33,99.11 ; 240.32,98.1 UG1.AC19 ; UG1.AD19 240.32,96.1 ; UG1.AD19 v1(239.32,97.1) UG1.AC19 ; UG1.AG19 240.32,94.1 ; 240.32,94.1 UG1.AF18 ; 240.32,94.1 UG1.AF19 ; 240.32,94.1 UG1.AG18 ; UG1.Y23 236.32,100.1 ; UG1.Y23 v1(235.32,100.1) UG1.AA23 ; 236.32,100.1 UG1.Y22 v1(236.32,101.1) ; 236.32,100.1 UG1.AA22 v1(236.32,99.1) ; 236.32,100.1 UG1.AA23 ; 236.32,97.1 UG1.AC23 ; 236.32,97.1 UG1.AD22 ; 236.32,97.1 UG1.AC22 ; UG1.AC23 235.64,97.78 235.64,98.43 UG1.AB23 ; UG1.AC23 236.32,98.1 ; UG1.AF22 v1(237.32,95.1) UG1.AE22 ; UG1.AF22 v1(236.32,95.1) ; UG1.AF22 236.32,94.1 ; v1(240.32,102.1) UG1.W19 ; v1(240.32,102.1) UG1.V19 ; 240.32,95.1 UG1.AF18 ; 240.32,95.1 UG1.AE18 ; v1(236.32,99.1) UG1.AA23 ; v1(236.32,99.1) UG1.AB22 236.32,98.1 ; v1(236.32,99.1) UG1.AB23 ; v1(236.32,105.1) UG1.R23 UG1.P24 ; UG1.AE27 232.32,96.1 ; UG1.AE27 v1(231.32,96.1) UG1.AD27 ; 232.32,96.1 UG1.AD27 ; v1(243.32,94.1) UG1.AG15 UG1.AG14 v1(245.07,92.6) UG1.AJ14 UG1.AJ15 ; 233.33,100.11 v1(233.47,100.11) ; 240.33,99.11 239.85,99.6 UG1.AA19 ; 240.33,99.11 UG1.AB19 ; UG1.AC19 v1(239.32,98.1) UG1.AB19 ; 232.34,99.08 v1(232.34,99.07) ; UG1.AJ15 v1(243.32,92.1) UG1.AH16 ; UG1.AJ15 UG1.AK15 v1(242.82,90.35) ; UG1.AB23 236.32,98.1 ; UG1.AF18 v1(241.32,95.1) UG1.AE18 ; 236.32,96.1 UG1.AD23 ; 236.32,96.1 UG1.AE22 ; 236.32,96.1 UG1.AD22 ; 236.32,96.1 UG1.AE23 ; 237.29,96.07 237.29,96.13 UG1.AD22 ; 237.29,96.07 v1(237.35,96.07) ; 237.29,96.07 UG1.AE22 ; UG1.T26 232.29,105.13 ; UG1.T26 232.32,104.1 ; 232.29,105.13 v1(232.29,105.13) ; UG1.AE23 v1(235.32,95.1) UG1.AF23 ; UG1.AE23 v1(235.29,96.13) ; UG1.AE23 v1(236.32,95.1) ; UG1.U30 229.42,103.6 UG1.U29 ; UG1.AF23 235.36,94.14 235.28,94.14 ; UG1.AF23 v1(236.32,95.1) ; UG1.AF23 236.32,94.1 ; v1(236.32,95.1) UG1.AE22 ; UG1.W19 v1(239.32,101.1) UG1.Y19 ; UG1.W19 v1(239.32,102.1) UG1.V19 ; 236.32,94.1 UG1.AG22 v1(236.32,93.1) UG1.AG23 ; 236.32,94.1 UG1.AG23 ; 235.28,94.14 UG1.AG23 ; 235.28,94.14 v1(235.28,94.11) ; v1(243.32,100.1) UG1.AA15 v1(243.32,99.1) UG1.AB15 243.82,98.55 v1(243.38,98.1) 243.82,97.66 UG1.AC15 UG1.AD14 ; UG1.AB19 v1(239.32,99.1) UG1.AA19 ; UG1.AA19 v1(239.32,100.1) UG1.Y19 ; UG1.R15 v1(243.32,105.1) ; UG1.AD18 240.32,96.1 ; 240.32,96.1 UG1.AE18
  BOTTOM w0.508: JSSD2.77 v1(274.39,4.66) ; PR813.1 192.21,74.5 v1(191.79,74.92) ; v1(271.58,129.77) CG232.2 ; JHDD.35 130.08,8 v1(129.23,7.14) ; RM42.2 v1(152.66,173.07) ; RH589.1 222.53,25.04 v1(222.5,25.06) ; CG274.2 v1(285.37,90.84) ; CH179.2 199.34,43.34 v1(199.59,43.59) ; v1(21.47,55.47) 22.36,55.47 22.63,55.2 CU33.2 ; CU19.2 12.86,57.88 12.77,57.97 v1(12.77,58.77) 11.86,59.68 DU11.1 ; CM36.2 v1(130.11,161.31) ; v1(223.04,130.21) 223.66,129.58 CG164.2 ; v1(203.53,168.69) 203.21,168.69 CT104.2 ; YH2.4 192.82,44.75 v1(191.97,45.6) ; v1(301.06,10.45) 301.95,9.55 JELC.7 ; v1(264.71,124.01) 265.04,123.69 RG125.2 CG225.2 ; JSSD1.77 v1(324.89,28.51) ; CL7.2 237.87,148.58 v1(238.12,148.83) ; v1(238.77,73.88) 238.96,74.07 PC6540.2 ; C265.2 58.53,16.96 C264.2 v1(58.53,15.26) ; PR547.1 122.54,147.76 PC537.2 v1(122.59,148.45) ; v1(175.97,31.66) 176.52,31.1 JDIMM2.262 ; JDIMM1.261 113.81,67.9 v1(114.25,67.47) ; v1(213.99,129.17) 214.08,129.08 CG175.2 ; CL12.2 CL13.2 v1(230.96,151.81) ; JDIMM1.262 176.45,67.9 v1(175.39,68.95) ; QV2.3 156.48,166.39 155.99,166.89 v1(155.99,167.87) ; v1(261.37,129.91) CG214.2 ; v1(275.39,129.77) CG228.2 ; PC214.2 PC213.2 96.97,44.55 v1(97.48,44.04) ; v1(178.05,162.51) 178.04,162.52 RT5.2 ; PC815.2 v1(200.34,80.97) ; v1(17.24,1.8) 15.89,3.14 11.3,3.14 10.82,3.62 JACK1.7 ; PC101.2 54.15,50.15 v1(54.75,50.15) 55.19,49.72 PR103.1 ; v1(261.37,138.29) CG186.2 ; CG289.2 v1(285.25,76.64) ; UV17.2 164.6,167.08 164.49,167.19 v1(164.49,167.5) 165.74,167.5 166.33,168.09 CV373.2 CV17.2 166.65,169.26 v1(166.95,169.56) ; v1(35.19,16.99) 34.74,16.54 RA67.2 CA74.2 ; v1(42.3,7.14) 40.91,5.75 RA73.2 ; v1(208.15,125.51) 208.48,125.51 209.55,126.58 CG148.2 ; v1(71.7,9.2) 71.98,9.2 73,10.22 C261.2 73,11.61 C260.2 ; CG149.2 208.05,126.37 208.1,126.32 v1(208.1,126.14) ; CA35.2 37.68,35.92 38.05,36.29 v1(38.05,36.42) 38.05,36.68 CA34.2 ; JTRONR.6 278.77,29.78 v1(279.11,29.43) 279.57,29.88 JTRONR.7 ; CU17.2 v1(260.44,23.39) ; RG142.2 v1(285.39,98.35) ; v1(226.51,148.19) 226.37,148.05 CL42.2 ; v1(281.29,51.73) 281.86,51.73 PR6061.2 282.14,50.77 282.34,50.57 PC6023.1 ; CV21.2 168.09,167.29 168.82,168.02 v1(168.82,168.03) ; JSSD3.76 255.12,13.39 254.52,14 v1(254.52,14.55) ; v1(128.34,116.75) CH194.2 ; JSPK.6 45.93,15.28 v1(45.58,15.63) ; RE167.2 285.85,43.45 v1(285.89,43.42) 285.89,43.02 285.86,43 CE168.2 ; v1(282.12,72.41) 282.12,71.88 CG300.2 ; CA4.2 31.72,35.09 v1(31.71,35.08) ; v1(36.22,23.68) 37.55,23.68 38.06,24.19 CA18.2 ; v1(264.87,52.74) 264.61,52.99 PC6401.2 ; YH2.2 v1(194.08,46.45) ; CE85.2 32.01,48.8 31.5,49.31 v1(31.5,49.82) ; RH466.2 153.73,122.24 v1(153.16,121.67) 152.84,121.99 RH472.2 ; v1(257.63,127.45) CG209.2 ; v1(123.58,131.86) 124.06,132.34 PC501.2 ; PC805.2 v1(200.35,82.25) ; v1(261.37,133.09) CG213.2 ; PC3.2 PC4.2 v1(74.06,31.77) ; RV622.2 RV626.2 185.99,105.46 185.91,105.38 ; JELC.8 307.77,9.21 v1(307.6,9.05) ; JACK2.7 10.82,16.34 11.38,15.78 15.38,15.78 16.07,15.08 16.07,14.51 v4(16.68,13.91) 18.68,11.91 ; RG23.2 RG24.2 214.49,87.06 v1(213.89,87.65) ; JDIMM2.261 111.27,32.7 v1(110.14,33.83) ; v1(123.64,155.9) 123.83,156.09 CM33.2 ; v1(33.37,52.38) JTRONL.14 ; PC806.2 232.75,36.07 v1(232.41,36.41) ; v1(186.81,105.02) 186.46,105.38 185.91,105.38 ; v1(163.71,172.24) 163.61,172.24 RM6.1 ; v1(208.48,166.96) 208.12,167.33 DT15.1 ; v1(19.82,50.26) 19.82,50.25 20.33,49.74 CU35.2 ; v1(234.9,160.18) 235.79,159.29 YL1.2 ; RH581.2 207.13,43.18 RH109.2 205.65,43.18 205.14,42.67 CH177.2 ; v1(279.22,70.01) 279.42,70.21 CG305.2 ; v1(212.41,159.01) 212.75,158.67 CV443.2 ; CG306.2 207.3,87.69 207.29,87.68 v1(207.29,87.66) 207.29,87.2 207.37,87.12 CG130.2 ; RE162.2 291.44,49.03 v1(291.44,49.41) ; UL2.2 v1(227.27,149.29) ; v1(39.06,8.8) 39.01,8.74 CA71.1 38.38,8.73 RA62.1 ; CU45.2 266.83,25.19 v1(266.82,25.19) CU11.2 ; PC115.2 31.29,47.35 v1(30.95,47.69) ; v1(231.4,41.13) PR808.2 233.06,41.13 PC811.2 ; v1(228.04,34.51) 228.42,34.89 PC812.2 ; PC6012.1 v1(291.98,64.87) ; RG38.2 214.36,102.2 213.85,102.71 v1(213.85,102.8) ; v1(191.36,124.13) 191.36,124.08 191.7,123.74 RV20.2 ; CA36.2 39.98,32.97 v1(39.7,33.24) ; C2523.2 63.42,10.51 v1(63.19,10.28) ; CT88.2 194.18,163.67 v1(194.08,163.77) ; v1(221.07,34.52) 220.55,35.03 CH46.2 ; PC1012.2 143.79,130.42 v1(143,130.42) ; v1(84.1,39.42) PC1.2 ; CG246.2 v1(285.39,102.08) ; v1(109.95,8) JHDD.31 ; RG139.2 CG267.2 265.79,78.93 v1(265.02,79.7) ; v1(285.39,120.81) CG235.2 ; CV9.2 v1(166.33,170.85) 166.37,170.88 CV19.2 ; v1(270.56,129.77) CG233.2 ; QG3.3 206.83,92.17 v1(206.83,92.87) ; v1(195.25,160.05) 195.25,160.08 195.21,160.12 195.21,160.62 CT98.2 194.69,161.37 CT103.2 ; PC108.2 31.29,41.08 v1(30.18,42.18) ; RH149.1 RH150.1 167.88,89.85 v1(167.59,90.14) ; CL8.1 239.16,157.46 v1(239.16,157.46) ; PR1302.2 PC1301.2 v1(100.72,52.23) ; v1(64.18,10.28) 64.18,10.93 C2506.2 C2507.2 ; v1(207.84,78.45) 208.43,79.04 PC1315.2 208.92,79.05 PC1314.2 ; PR5015.2 v1(119.59,121.56) ; RM70.1 v1(128.33,149.94) ; PR6086.2 v1(282.57,65.06) ; v1(85.2,39.4) PC2.2 ; v1(239.58,161.36) 239.1,160.89 YL1.4 ; PC6013.1 292.62,65.69 v1(291.98,65.69) ; PC813.2 228.35,39.85 v1(228.35,40.93) ; JTP.17 198.97,8.55 197.69,9.83 v1(197.66,9.83) ; CE84.2 45.3,47.81 v1(45.55,48.06) ; v1(227.19,127.7) 226.83,128.06 CG140.2 226.32,128.04 RG97.2 ; v1(173.48,8.56) 172.68,8.56 171.47,7.35 JKBBL.21 ; v1(93.61,40.1) PC207.1 ; RG100.2 CG144.2 201.8,138.14 202.31,138.65 203.15,138.65 v1(203.27,138.53) ; v1(222.11,153.26) CV447.2 CV445.2 ; v1(126.1,101.21) 126.63,100.68 C2519.2 ; v1(204.35,90.33) 204.14,90.54 CG131.2 ; v1(182.74,107.45) 182.74,108.36 CV437.2 ; CU34.2 20.96,54.68 v1(20.61,55.02) ; CV1312.2 v1(212.56,146.91) ; v1(285.22,30.19) 285.22,30.48 285.45,30.72 CE86.2 ; v1(150.19,169.13) 150.19,169.26 149.61,169.83 CM70.2 ; CV22.2 RV537.2 212.42,106.14 212.92,106.65 v1(212.92,106.83) ; v1(206.45,129.51) 206.63,129.51 207.14,129 CG141.2 ; CX1.2 RV18.1 233.38,166.68 233.88,167.18 v1(233.88,167.99) ; CL9.1 235.59,157.97 v1(235.21,158.35) ; v1(168.34,150.74) CM20.2 ; DU1.1 v1(19.12,36.99) ; v1(24.77,50.39) 24.01,50.39 23.82,50.2 CU42.2 ; 185.91,105.38 RV630.2 ; v1(34.5,23.27) 34.5,23.71 34.77,23.98 CA1.2 ; CV484.2 198.69,89.71 v1(198.83,89.57) ; RV1309.2 CV1313.2 220.2,147.52 v1(220.91,148.23) ; PC5011.1 121.1,147.24 121.12,147.23 v1(121.8,147.23) ; v1(54.38,7.02) 55.03,7.67 55.03,9.29 JSPK.7 ; CH178.2 202.17,42.18 202.17,41.02 201.81,40.67 v1(201.81,40.46) ; CH47.2 v1(192.55,42.84) ; v1(194.7,86.99) 195.21,87.49 PC804.2 ; CL40.2 222.68,149.18 v1(222.12,149.74) ; v1(285.29,125.43) CG237.2 ; v1(29.41,39.59) CA6.2 ; CT91.2 204.82,157.32 v1(204.03,157.32) ; RG110.2 CG182.2 254.33,127.2 254.84,126.7 v1(255.72,126.7) ; RL3.2 v1(240.66,157.75) ; JSSD1.76 328.15,49.21 v1(328.43,48.93) ; v1(261.37,140.07) CG218.2 ; v1(131.26,149.51) 131.12,149.65 CM32.2 ; UH5.4 v1(209.9,71.36) ; PC1013.2 v1(149.45,130.59) ; v1(15.88,65.25) 15.88,64.55 DU20.1 ; CM35.2 v1(129.6,149.94) ; CG162.2 220.18,129.02 v1(220.67,129.51) ; JRTC1.2 291.44,35.94 v1(291.66,35.72) ; v1(41.66,10) 41.66,9.87 42.24,9.3 JSPK.8 ; v1(51.81,50.08) 51.81,49.65 PR104.2 ; v1(125.04,119.98) 125.43,119.59 PR5008.2 125.43,119.09 PC590.2 ; v1(231.82,159.2) 232.32,158.71 CL11.2 ; PC8210.2 271.53,156.13 271.47,156.06 271.47,155.99 270.84,155.35 v1(270.2,155.35) ; CG258.2 v1(285.39,103.35) ; CG224.2 RG124.2 264.95,104.64 v1(264.74,104.43) ; v1(225.54,167.17) 225.07,166.7 225.07,166.26 224.61,165.8 CV20.2 ; v1(237.27,167.28) 237.87,166.68 CV34.2 ; v1(100.64,22.09) 100.43,21.88 UE9.2 100.43,21.02 100.03,20.63 CE19.2 ; PR518.2 127.62,134.87 v1(127.83,134.65) 128.15,134.65 128.5,135 PR517.2 ; v1(130.63,134.53) 130.63,134.94 PR519.2 PR516.2 ; PC1015.2 149.91,129.32 v1(149.3,129.93) ; CH50.2 205.76,60.03 206.26,59.53 207.72,59.53 v1(208.03,59.85) ; v1(212.99,110.33) 213.25,110.6 CV651.2 ; v1(174.19,31.72) 174.74,31.72 CLRP1.2 ; JRTC1.3 295.24,35.52 v1(294.54,36.23) ; v1(287.4,80.6) 288.11,79.89 CG3000.2 ; U1302.9 v1(215.38,147.01) ; v1(193.24,111.54) 193.04,111.33 CV439.2 192.4,112.2 RV23.1 CV438.2 ; PC1006.2 179.37,126.49 179.65,126.77 v1(179.65,127.16) ; v1(206.96,160.95) 206.73,160.95 206.32,161.36 CT93.2 CT92.2 ; CV442.2 CV441.2 v1(220.8,150.04) ; v1(210.4,84.03) 210.51,84.15 YG1.2 ; v1(203.54,141.33) CG158.2 202.08,141.33 201.8,141.05 RG92.2 ; PC6531.2 234.13,74.07 v1(234.01,74.2) ; RH9.2 CH45.2 219.39,37.99 v1(219.02,37.62) ; v1(193.75,161) 193.75,160.62 193.99,160.38 UT2.4 ; RG2.2 209.82,120.42 210.45,119.79 v1(210.45,119.79) ; CV444.2 212.53,155.99 v1(212.09,155.99) ; CH49.2 229.18,15.73 229.69,15.23 v1(229.69,15.17) ; v1(14.07,56.23) 14.5,55.79 CU32.2 ; CV440.2 221.15,162.1 218.93,162.1 RV197.2 218.27,162.07 v1(218.26,162.08) 218.25,162.07 RV199.2 ; CG288.2 v1(285.37,88.55) ; v1(285.95,30.19) 285.95,29.78 JTRONR.14 ; CH177.2 205.28,42.07 v1(205.88,41.47) ; CH177.2 204.73,41.66 204.73,40.88 204.59,40.73 v1(204.59,40.56) ; CV372.2 161.48,163.45 v1(161.64,163.29) ; v1(285.44,81.57) CG298.2 CG302.2 ; RV628.2 RV22.2 v1(187.19,105.64) ; v1(69.62,18.19) 69.54,18.27 C263.2 ; v1(69.74,16.83) 69.36,17.21 C262.2 ; v1(193.87,86.82) 194.46,86.24 PC816.2 ; CV436.2 183.52,121.96 v1(182.51,122.97) ; v1(161.48,173.77) 162.06,173.77 CM23.2 RM17.1 ; RH148.1 173.21,89.5 175.19,89.5 v1(175.61,89.92) ; CA65.2 37.43,16.84 v1(37.28,16.99) ; CG295.2 v1(285.37,75.66) ; CU16.2 260.79,26.14 v1(260.3,26.64) ; CG251.2 v1(285.39,104.62) ; v1(285.39,121.76) RG119.2 ; v1(261.37,134.1) CG215.2 ; v1(261.37,137.4) RG114.2 ; v1(128.34,118.23) 128.6,118.23 128.81,118.45 CH195.2 ; v1(261.37,142.74) CG206.2 ; PC1003.2 177.23,126.49 177.74,127 v1(177.74,127.16) ; CA7.2 31.82,36.94 v1(31.29,36.94) ; PC1011.2 v1(149.45,131.79) ; CL30.1 257.11,164.01 PC8208.2 ; RH469.2 172.6,123.84 v1(171.78,123.03) ; v1(261.37,139.18) RG107.2 ; v1(215.59,45.17) 214.9,44.48 CH175.2 ; v1(34.89,25.6) 34.89,25.04 CA2.2 ; CV1314.2 212.46,150.36 v1(212.46,151.25) 212.46,152.4 CV446.2 ; v1(13.09,67.79) DU21.1 ; v1(203.13,158.32) 203.13,158.31 CT90.2 ; CE22.2 v1(104.09,25.11) ; v1(210.39,154.43) 210.29,154.32 RX8.2 ; v1(300.3,35.72) 299.22,34.64 JWLAN.68 ; RG45.1 226.25,76.27 v1(226.83,76.27) ; v1(203.58,142.37) 203.25,142.7 CG168.2 ; PC1014.2 143.52,129.32 v1(143.2,129.64) ; v1(226.78,122.21) CG129.2 ; v1(119.83,133.45) 119.56,133.72 PC5010.1 119.54,134.36 PR513.1 119.55,135.25 PC507.2 ; PC8200.2 273.6,158.62 v1(273.6,158.88) ; v1(140.03,155.54) CM34.2 ; RH166.1 126.61,114.88 126.2,115.28 v1(126.12,115.28) ; CG299.2 v1(285.37,84.17) ; QG4.3 203.96,87.92 v1(204.29,87.6) ; v1(175.84,127.16) 175.52,126.84 PC1004.2 ; CG304.2 v1(284.76,78.65) ; v1(60.65,4.93) JKB3.8 ; PR811.2 v1(237.83,38.84) ; v1(94.94,40.1) PC212.2 ; CA41.2 38.99,29.68 v1(39.01,29.66) ; QV95.3 190.67,106.77 v1(191.13,107.22) ; v1(65.17,9.14) 65.17,9.76 66.07,10.66 C2524.2 ; CM21.2 164.96,151.44 164.09,152.31 v1(164.09,152.69) ; RG138.2 CG266.2 265.79,95.06 v1(266.14,95.41) ; PC1016.2 v1(143.2,131.86) ; JKB.32 208.58,6.55 v1(208.66,6.47) ; CE65.2 103.04,20.36 v1(103.04,21.3) ; CU20.2 v1(11.69,61.35) ; CG290.2 268.51,73.82 v1(268.52,73.81) ; CG277.2 v1(285.37,94.14) ; v1(261.37,130.93) CG219.2 ; v1(250.16,145.53) CG205.2 ; CG124.2 202.62,80.72 v1(202.32,80.42) 201.49,79.6 PC1312.2 ; CE20.2 v1(94.89,11.02) ; DV14.1 v1(158.81,162.08) ; C2499.2 204.64,106.27 v1(205.48,105.43) ; CM18.2 169.05,162.29 169.15,162.39 RM25.1 170.14,162.39 v1(170.61,162.86) ; CG248.2 268.48,101.86 v1(268.52,101.81) ; v1(124.18,153.87) 124.32,154.01 CM30.2 ; CG301.2 285.12,82.9 v1(285.44,83.22) ; DA6.1 v1(19.57,33.08) 18.77,33.08 17.19,31.5 JUSB1.11 ; v1(276.99,32.81) 276.32,32.81 CE87.2 ; CL14.2 230.76,147.99 v1(230.76,147.51) ; CH48.2 195.03,43.26 v1(195.03,42.77) ; v1(118.18,6.05) JHDD.33 ; v1(58.52,48.8) 58.32,48.6 PR105.1 ; RM29.2 165.21,161.86 v1(165.74,161.86) ; CG270.2 v1(285.39,99.24) ; v1(161.72,160.13) 162.49,160.13 163.52,159.1 CM19.2 ; v1(125.96,114.56) 125.61,114.2 PC5003.2 ; v1(235.34,14.07) 234.93,14.07 234.42,13.56 JSSD3.77 ; v1(187.02,10.26) 187.17,10.1 JTP.18 ; v1(274.5,129.77) RG128.2 ; C2525.2 v1(60.7,16.95) ; v1(127.07,7.2) JHDD.34 ; v1(221.62,145.53) CG153.2 ; v1(115.78,6.05) JHDD.32 ; v1(261.37,141.09) CG207.2 ; v1(252.06,145.42) CG196.2 ; v1(261.37,143.75) CG216.2 ; CV67.2 216.73,150.67 217.42,150.67 217.42,150.68 v1(217.43,150.68) ; v1(285.03,44.77) 285.38,45.12 RE164.2 RE163.2 ; v1(162.76,147.67) 163.06,147.37 PH504.1 ; JSSD2.76 v1(274.41,25.36) ; v1(55.13,41.52) PC111.2 ; v1(35.03,1.78) 35.12,1.87 35.12,4.02 CA255.2 ; v1(210.65,112.68) 210.85,112.88 RG1.2 ; CG281.2 v1(285.37,91.73) ; PR5018.2 v1(123.25,123.23) ; CU37.2 11.89,55.96 v1(11.57,56.28) ; RM38.2 165.43,163.41 165.68,163.41 166.21,163.41 v1(166.27,163.48) ; RV193.1 v1(214.96,150.02) ; CG296.2 v1(285.37,73.31) ; v1(130.89,148.5) PC529.2 ; v1(226.45,6.87) 226.13,6.55 JKB.31 ; CE61.2 v1(219.6,165.21) ; v1(273.04,30.32) 273.47,29.89 JTRONR.13 ; PR6065.2 291.47,51.91 v1(291.66,51.72) ; v1(213.05,114.01) 212.47,114.59 CG41.2 ; PC523.2 118.63,142.02 119.71,140.94 v1(119.77,140.94) ; v1(285.39,97.45) 285.38,97.44 CG280.2 ; CX2.2 214.56,161.96 v1(214.68,162.07) RV203.2 ; v1(202.99,12.71) v4(202.24,13.46) 200.96,13.46 RH585.1 ; v1(224.74,168.87) 224.41,169.2 223.53,169.2 ; v1(131.29,144.21) 131.42,144.34 131.42,145.26 131.81,145.65 PC522.2 ; v1(195.02,14.83) 193.63,14.83 C2.2 ; CV1056.2 v1(208.66,156.94) ; JWLAN.69 v1(319.92,36.29) ; v1(222.72,150.11) 223.14,150.11 CL41.2 ; JKBBL.22 v1(158.67,8.35) ; PC820.2 225.41,35.19 v1(225.27,35.33) ; v1(22.45,17.11) DA5.1 ; CG293.2 v1(285.37,74.26) ; v1(139.68,147.53) PH500.1 ; CG260.2 v1(285.39,109.82) ; PR107.2 48.51,46.5 48.15,46.14 v1(48.15,45.49) ; CL15.2 229.24,148.05 228.96,147.76 v1(228.96,147.51) ; v1(194.76,157.89) 195.27,157.89 195.4,158.02 CT99.2 ; CM16.2 CM17.2 ; v1(202.32,78.58) 202.32,78.49 201.94,78.11 PC1302.2 PC1308.2 ; JTRONL.13 44.11,51.05 v1(43.32,51.85) ; CG256.2 v1(285.39,101.12) ; v1(220.06,145.57) CG146.2 ; v1(49.97,47.16) PR106.1 ; v1(61.43,6.06) JKB3.7 ; CA13.2 CA12.2 ; PC6541.2 243.49,74.58 v1(241.78,76.3) ; CG125.2 v1(202.32,82.48) ; CG276.2 v1(285.37,87.09) ; UE2.4 v1(104.19,14.75) ; v1(28.27,41.94) CA5.2 ; CG273.2 v1(285.37,89.44) ; JRTC1.4 v1(288.89,32.12) ; v1(285.39,117.76) CG241.2 ; v1(285.39,119.35) CG234.2 ; RM21.1 v1(171.26,150.83) ; C2498.2 v1(184.13,54.36) ; v1(37.43,14.26) CA64.2 ; CA37.2 v1(39.19,33.61) ; v1(127.12,102.26) C3.2 ; v1(211.77,128.89) RG96.2 ; v1(66.94,7.93) JKB3.10 ; v1(188.48,46.45) R185.1
  vias: v1(2.96,69.8) v1(3.7,51.9) v1(3.69,30.64) v1(4.02,71.63) v1(4.02,67.97) v1(4.46,50.8) v1(5.52,52.63) v1(5.52,48.97) v1(6.12,71.63) v1(6.12,67.97) v1(7.18,69.8) v1(7.62,52.63) v1(7.62,48.97) v1(7.77,72.67) v1(8.68,50.8) v1(8.7,45.13) v1(11.25,30.66) v1(12.33,47.66) v1(12.96,47.66) v1(13.28,39.05) v1(13.66,47.66) v1(14.36,47.66) v1(14.95,70.11) v1(14.99,61.06) v1(16.14,63.34) v1(16.14,61.44) v1(16.52,57.06) v1(17.14,62.81) v1(17.3,53.44) v1(17.3,52.38) v1(17.3,51.31) v1(18.17,56.29) v1(18.44,53.44) v1(18.44,52.38) v1(18.44,51.31) v1(19.66,11.5) v1(19.96,4.2) v1(20.86,13.59) v1(20.86,9.41) v1(21.02,6.03) v1(21.02,2.37) v1(21.59,0.43) v1(22.15,57.07) v1(22.33,44.58) v1(23.12,6.03) v1(23.12,2.37) v1(23.28,13.59) v1(23.28,9.41) v1(23.69,43.28) v1(23.69,42.64) v1(24.18,4.2) v1(24.33,43.28) v1(24.33,42.64) v1(24.48,11.5) v1(24.9,37.75) v1(25.96,54) v1(25.98,46.64) v1(26.42,39.28) v1(27.02,55.83) v1(27.02,52.17) v1(29.12,55.83) v1(29.12,52.17) v1(29.21,0.43) v1(29.73,56.55) v1(30.15,32.58) v1(30.15,30.51) v1(30.15,28.44) v1(30.18,54) v1(30.78,42.49) v1(31.38,42.5) v1(31.98,11.88) v1(31.98,10.51) v1(31.98,9.12) v1(31.98,7.74) v1(32.22,32.58) v1(32.22,30.51) v1(32.22,28.44) v1(33.36,11.88) v1(33.36,10.51) v1(33.36,9.12) v1(33.36,7.74) v1(34.29,32.58) v1(34.29,30.51) v1(34.29,28.44) v1(34.74,11.88) v1(34.74,10.51) v1(34.74,9.12) v1(34.74,7.74) v1(36.12,11.88) v1(36.12,10.51) v1(36.12,9.12) v1(36.12,7.74) v1(36.76,53.57) v1(36.83,0.43) v1(37.6,19.78) v1(37.6,19.15) v1(38.24,19.78) v1(38.24,19.15) v1(38.68,50.58) v1(38.87,19.78) v1(38.87,19.15) v1(39.38,50.58) v1(42.17,27.91) v1(42.17,27.27) v1(42.17,26.64) v1(42.81,27.91) v1(42.81,27.27) v1(42.81,26.64) v1(42.98,4.93) v1(43.66,40.82) v1(44.35,52.95) v1(44.32,40.85) v1(47.57,32.48) v1(47.89,32.99) v1(48.27,34.65) v1(48.23,34.07) v1(48.23,33.48) v1(48.33,32.48) v1(48.8,34.89) v1(48.8,34.26) v1(48.82,33.63) v1(48.8,32.93) v1(49.31,35.85) v1(49.31,35.21) v1(49.31,34.58) v1(49.31,33.94) v1(49.31,33.24) v1(49.31,32.61) v1(49.86,36.23) v1(49.86,35.59) v1(49.86,34.96) v1(49.86,34.32) v1(49.86,33.62) v1(49.86,32.99) v1(50.6,4.93) v1(51.82,51.06) v1(53.24,45.68) v1(53.86,46.3) v1(53.86,45.05) v1(54.49,45.68) v1(56.22,10.15) v1(56.22,9.57) v1(56.37,23.3) v1(56.37,21.16) v1(57.44,22.23) v1(58.07,3.43) v1(58.51,23.3) v1(58.51,21.16) v1(59.16,20.57) v1(59.44,51.06) v1(59.75,20.57) v1(61.48,25.37) v1(61.48,24.73) v1(62.11,25.62) v1(62.11,24.99) v1(62.75,25.62) v1(62.75,24.99) v1(63.38,25.62) v1(63.38,24.99) v1(63.38,24.35) v1(65.11,26.27) v1(65.73,26.26) v1(65.69,3.43) v1(66.49,26.26) v1(66.87,5.37) v1(66.87,4.6) v1(67.08,51.57) v1(67.19,26.26) v1(67.83,26.27) v1(67.95,50.45) v1(67.95,49.82) v1(68.59,50.45) v1(68.59,49.82) v1(69.22,50.45) v1(69.22,49.82) v1(69.86,50.45) v1(69.86,49.82) v1(70.49,50.45) v1(70.49,49.82) v1(71.19,50.45) v1(71.19,49.82) v1(71.83,50.45) v1(71.83,49.82) v1(72.46,50.45) v1(72.46,49.82) v1(73.04,5.43) v1(73.1,50.45) v1(73.1,49.82) v1(73.73,50.45) v1(73.73,49.82) v1(74.37,50.45) v1(74.37,49.82) v1(74.7,51.57) v1(75,50.45) v1(75,49.82) v1(75.64,50.45) v1(75.64,49.82) v1(76.44,18.5) v1(76.7,19.07) v1(76.82,17.93) v1(77.08,18.5) v1(77.33,19.07) v1(77.46,17.93) v1(77.71,18.5) v1(77.97,19.07) v1(78.1,17.93) v1(78.35,18.5) v1(78.6,19.07) v1(78.73,17.93) v1(78.98,18.5) v1(79.24,19.07) v1(79.37,17.93) v1(79.62,18.5) v1(80.66,5.43) v1(80.84,20.16) v1(81.48,20.16) v1(82.32,51.57) v1(84.59,33.12) v1(84.97,33.62) v1(85.29,33.12) v1(85.67,33.62) v1(85.99,33.12) v1(86.37,33.62) v1(86.69,33.12) v1(87.07,33.62) v1(88.27,49.82) v1(88.28,5.43) v1(88.91,49.82) v1(89.8,53.04) v1(90.37,25.75) v1(90.37,25.11) v1(90.37,24.48) v1(90.76,56.9) v1(91,25.75) v1(91,25.11) v1(91,24.48) v1(91.64,41.56) v1(91.64,25.75) v1(91.64,25.11) v1(91.64,24.48) v1(91.82,58.73) v1(91.82,55.07) v1(92.05,44) v1(92.25,41.56) v1(92.27,25.75) v1(92.27,25.11) v1(92.27,24.48) v1(92.53,60.15) v1(92.67,44.62) v1(92.67,43.38) v1(92.97,25.75) v1(92.97,25.11) v1(92.97,24.48) v1(93.29,44) v1(93.92,58.73) v1(93.92,55.07) v1(93.99,32.73) v1(93.99,32.1) v1(93.99,31.46) v1(94.31,34.51) v1(94.31,33.88) v1(94.31,33.24) v1(94.62,32.73) v1(94.62,32.1) v1(94.62,31.46) v1(94.94,34.51) v1(94.94,33.88) v1(94.94,33.24) v1(94.98,56.9) v1(95.26,32.73) v1(95.26,32.1) v1(95.26,31.46) v1(95.9,5.37) v1(98.69,41.24) v1(98.69,40.55) v1(99.05,64.09) v1(99.67,71.69) v1(99.96,6.5) v1(100.88,46.42) v1(101.02,8.33) v1(101.02,4.67) v1(103.12,8.33) v1(103.12,4.67) v1(103.27,3.43) v1(104.09,53.69) v1(104.18,6.5) v1(104.48,77.6) v1(104.52,13.27) v1(108.29,84.2) v1(110.89,3.43) v1(110.99,91.32) v1(112.06,44.76) v1(112.06,43.49) v1(112.51,98.79) v1(112.68,57.17) v1(112.68,55.9) v1(112.68,54.63) v1(112.85,159.74) v1(112.85,152.12) v1(112.85,144.5) v1(112.85,136.88) v1(112.85,129.26) v1(112.85,121.64) v1(112.85,114.02) v1(112.85,106.4) v1(114.01,44.69) v1(114.01,42.79) v1(114.07,57.49) v1(114.07,55.59) v1(115.34,57.17) v1(115.34,55.9) v1(115.34,54.63) v1(115.34,44.37) v1(115.34,43.1) v1(115.34,41.83) v1(117.38,57.17) v1(117.38,55.9) v1(117.38,54.63) v1(117.55,120.49) v1(117.63,44.37) v1(117.63,43.1) v1(117.63,41.83) v1(117.99,116.43) v1(117.99,115.83) v1(118.18,106.01) v1(118.51,3.43) v1(118.82,106.01) v1(119.04,41.52) v1(119.19,54.32) v1(119.38,163.67) v1(120.59,57.17) v1(120.59,55.9) v1(120.59,44.37) v1(120.59,43.1) v1(120.91,106.33) v1(120.91,105.7) v1(120.91,105.06) v1(120.91,104.43) v1(121.36,120.87) v1(121.36,120.28) v1(121.36,119.69) v1(121.34,119.1) v1(121.56,116.79) v1(121.67,114.14) v1(122.05,113.64) v1(122.06,113) v1(122.95,57.17) v1(122.95,55.9) v1(122.95,44.37) v1(122.95,43.1) v1(124.51,143.05) v1(124.51,141.08) v1(124.51,139.12) v1(124.63,44.69) v1(124.63,42.79) v1(124.69,57.49) v1(124.69,55.59) v1(124.78,106.4) v1(124.78,105.76) v1(124.78,105.13) v1(124.78,104.49) v1(125.23,134.53) v1(126.13,3.43) v1(126.43,134.53) v1(126.47,143.05) v1(126.47,141.08) v1(126.47,139.12) v1(126.51,57.17) v1(126.51,55.9) v1(126.51,54.63) v1(126.63,44.37) v1(126.63,43.1) v1(126.63,41.83) v1(126.89,162.37) v1(127.83,105.57) v1(128.34,157.7) v1(128.34,156.18) v1(128.28,106.01) v1(128.44,143.05) v1(128.44,141.08) v1(128.44,139.12) v1(129.02,57.17) v1(129.02,55.9) v1(129.02,54.63) v1(129.02,44.37) v1(129.02,43.1) v1(129.02,41.83) v1(130.1,157.7) v1(130.1,156.18) v1(130.1,154.66) v1(130.18,99.44) v1(130.29,56.22) v1(130.29,54.32) v1(130.51,93.31) v1(130.57,94.2) v1(130.8,43.42) v1(130.8,41.52) v1(130.88,98.16) v1(131.45,160.56) v1(131.86,157.7) v1(131.86,156.18) v1(131.86,154.66) v1(131.86,90.14) v1(132.03,40.51) v1(132.17,57.17) v1(132.17,55.9) v1(132.17,54.63) v1(132.17,44.37) v1(132.17,43.1) v1(132.17,41.83) v1(132.6,146.97) v1(132.99,91.5) v1(133.17,149.89) v1(133.18,161.04) v1(133.62,157.7) v1(133.62,156.18) v1(133.62,154.66) v1(133.75,3.43) v1(134.38,92.62) v1(134.51,162.37) v1(134.63,146.84) v1(135.01,149) v1(135.1,89.9) v1(135.08,88.1) v1(135.2,147.23) v1(135.38,157.7) v1(135.38,156.18) v1(135.38,154.66) v1(136.07,91.51) v1(136.1,161.78) v1(136.66,44.36) v1(136.66,43.04) v1(136.66,41.77) v1(136.66,40.5) v1(136.93,160.6) v1(137.09,89.81) v1(137.36,147.42) v1(137.62,57.45) v1(137.61,56.16) v1(137.61,54.7) v1(137.61,53.36) v1(138.13,44.32) v1(138.12,43.03) v1(138.4,91.09) v1(138.57,104) v1(139.08,113.31) v1(139.3,115.33) v1(139.34,109.82) v1(139.72,113.31) v1(139.72,44.25) v1(139.72,42.95) v1(139.72,41.58) v1(139.85,57.05) v1(139.85,55.75) v1(140.06,115.34) v1(140.03,90.96) v1(139.98,89.13) v1(140.16,106.58) v1(140.16,105.31) v1(140.41,104) v1(141.05,104) v1(141.37,3.43) v1(141.55,180.52) v1(141.55,172.65) v1(141.55,165.28) v1(141.56,113.31) v1(141.64,115.34) v1(141.62,109.82) v1(141.59,44.39) v1(141.59,43.01) v1(141.61,41.79) v1(141.72,57.19) v1(141.69,55.81) v1(141.73,54.59) v1(142.19,113.31) v1(142.29,144.86) v1(142.29,144.16) v1(142.36,131.05) v1(142.36,130.42) v1(142.46,171.5) v1(142.4,115.35) v1(142.45,106.65) v1(142.45,105.38) v1(142.77,146.87) v1(142.83,104) v1(143,131.05) v1(143.07,88.42) v1(143.07,87.15) v1(143.14,145.73) v1(143.46,104) v1(143.52,173.33) v1(143.52,169.67) v1(143.57,123.62) v1(143.79,145.73) v1(143.97,115.34) v1(144.03,113.31) v1(143.97,109.82) v1(144.04,57.23) v1(144.04,55.96) v1(144.04,54.72) v1(143.98,44.43) v1(143.98,43.16) v1(143.98,41.92) v1(144.21,123.62) v1(144.44,145.73) v1(144.45,91.96) v1(144.43,89.36) v1(144.67,113.31) v1(144.67,106.65) v1(144.67,105.38) v1(144.84,123.62) v1(144.79,115.34) v1(145.09,145.73) v1(145.43,104) v1(145.48,123.62) v1(145.62,173.33) v1(145.62,169.67) v1(145.62,56.22) v1(145.62,54.95) v1(145.62,53.04) v1(145.62,45.07) v1(145.62,43.16) v1(145.62,41.89) v1(145.73,145.73) v1(146.07,104) v1(146.16,87.49) v1(146.16,85.58) v1(146.44,159.86) v1(146.44,158.72) v1(146.4,115.34) v1(146.45,113.31) v1(146.38,109.82) v1(146.56,149.13) v1(146.57,143.35) v1(146.57,142.76) v1(146.57,142.18) v1(146.57,141.59) v1(146.57,141.01) v1(146.57,140.43) v1(146.68,171.5) v1(147.02,106.65) v1(147.02,105.38) v1(147.07,159.86) v1(147.07,158.72) v1(147.17,144.02) v1(147.16,143.35) v1(147.16,142.76) v1(147.16,142.18) v1(147.16,141.59) v1(147.16,141.01) v1(147.16,140.43) v1(147.13,115.35) v1(147.15,113.34) v1(147.2,149.13) v1(147.3,90.22) v1(147.3,88.25) v1(147.46,11.84) v1(147.46,11.21) v1(147.49,139.84) v1(147.52,139.22) v1(147.75,144.02) v1(147.74,143.35) v1(147.74,142.76) v1(147.74,142.18) v1(147.74,141.59) v1(147.74,141.01) v1(147.74,140.43) v1(147.84,104.04) v1(148.13,139.84) v1(148.15,139.22) v1(148.21,184.22) v1(148.22,11.84) v1(148.22,11.21) v1(148.34,140.41) v1(148.38,144) v1(148.37,143.33) v1(148.37,142.75) v1(148.37,142.17) v1(148.37,141.58) v1(148.37,141) v1(148.44,104.04) v1(148.47,44.94) v1(148.47,43.41) v1(148.47,41.89) v1(148.73,115.34) v1(148.86,109.82) v1(148.86,57.74) v1(148.86,56.21) v1(148.86,54.69) v1(148.86,53.16) v1(148.99,113.38) v1(148.99,3.43) v1(149.36,162.66) v1(149.37,106.65) v1(149.37,105.38) v1(149.42,163.35) v1(149.37,79.47) v1(149.37,78.23) v1(149.37,76.96) v1(149.5,115.33) v1(149.58,113.38) v1(149.62,111.73) v1(149.74,159.1) v1(149.74,158.46) v1(150.26,104.04) v1(150.38,159.1) v1(150.38,158.46) v1(150.62,144.88) v1(150.62,144.19) v1(150.81,79.38) v1(150.81,78.79) v1(150.81,78.21) v1(150.81,77.63) v1(150.81,75.12) v1(150.81,74.54) v1(150.81,73.96) v1(150.81,73.37) v1(150.89,104.04) v1(150.91,55.96) v1(150.91,54.43) v1(151.06,92.42) v1(151.04,90.53) v1(150.99,44.94) v1(150.99,43.41) v1(150.99,41.89) v1(151.1,146.9) v1(151.1,115.34) v1(151.2,87.72) v1(151.21,85.92) v1(151.34,113.38) v1(151.27,110.96) v1(151.27,109.63) v1(151.27,108.36) v1(151.4,111.73) v1(151.47,145.75) v1(151.59,106.58) v1(151.59,105.31) v1(151.85,115.34) v1(152.04,113.38) v1(152.12,145.75) v1(152.37,169.2) v1(152.29,91.69) v1(152.3,89.86) v1(152.4,87.97) v1(152.77,145.75) v1(152.85,56.21) v1(152.85,54.69) v1(152.85,44.94) v1(152.85,43.41) v1(152.85,41.89) v1(153.42,145.75) v1(153.44,115.3) v1(153.61,41.25) v1(154.07,145.75) v1(154.13,113.76) v1(154.19,169.26) v1(154.25,115.34) v1(154.34,142.49) v1(154.4,143.1) v1(154.38,108.49) v1(154.45,103.66) v1(154.57,139.16) v1(154.76,149.07) v1(154.75,141.59) v1(154.75,141.01) v1(154.75,140.43) v1(154.69,138.59) v1(154.74,137.96) v1(154.77,110.39) v1(154.82,171.04) v1(154.86,142.18) v1(154.82,130.65) v1(154.82,130.02) v1(154.84,91.84) v1(154.82,90.53) v1(154.84,89.22) v1(154.84,87.99) v1(154.89,143.42) v1(154.9,142.79) v1(155.33,149.26) v1(155.33,141.59) v1(155.33,141.01) v1(155.33,140.43) v1(155.33,138.59) v1(155.32,138) v1(155.45,142.18) v1(155.46,130.02) v1(155.49,143.44) v1(155.49,142.79) v1(155.48,130.67) v1(155.61,163.91) v1(155.71,160.43) v1(155.71,159.8) v1(155.82,183.77) v1(155.96,169.2) v1(155.92,141.59) v1(155.92,141.01) v1(155.92,140.43) v1(155.94,139.81) v1(155.94,139.16) v1(155.94,138.56) v1(155.93,137.94) v1(156.03,161.64) v1(156.03,161) v1(156.03,142.18) v1(155.97,113.76) v1(156.07,143.44) v1(156.23,108.49) v1(156.23,103.66) v1(156.35,160.43) v1(156.35,159.8) v1(156.34,57.22) v1(156.34,55.95) v1(156.34,54.68) v1(156.46,44.42) v1(156.46,43.15) v1(156.46,41.88) v1(156.47,173.01) v1(156.5,141.58) v1(156.5,141) v1(156.49,140.16) v1(156.49,139.53) v1(156.5,138.89) v1(156.5,138.23) v1(156.6,171.16) v1(156.61,115.35) v1(156.61,113.76) v1(156.61,3.43) v1(156.86,108.49) v1(156.86,103.66) v1(156.99,110.39) v1(157.3,91.3) v1(157.84,44.73) v1(157.84,42.83) v1(158.09,57.6) v1(158.09,55.63) v1(158.25,173.01) v1(158.18,115.34) v1(158.26,89.56) v1(158.31,141.62) v1(158.31,140.93) v1(158.39,113.76) v1(158.58,110.39) v1(158.64,108.49) v1(158.64,103.66) v1(158.79,143.63) v1(158.95,160.69) v1(158.96,115.34) v1(159.02,113.76) v1(159.16,142.49) v1(159.14,88.07) v1(159.27,108.49) v1(159.27,103.66) v1(159.63,44.43) v1(159.63,43.16) v1(159.63,41.89) v1(159.7,57.23) v1(159.7,55.96) v1(159.7,54.69) v1(159.8,142.49) v1(159.86,90.94) v1(160.45,142.49) v1(160.52,115.34) v1(160.73,110.39) v1(160.79,128.11) v1(160.8,113.76) v1(160.98,169.58) v1(160.97,168.31) v1(161.05,108.49) v1(161.05,103.66) v1(161.1,142.49) v1(161.21,89.59) v1(161.33,115.35) v1(161.43,128.11) v1(161.43,113.76) v1(161.65,103.66) v1(161.66,57.3) v1(161.66,56.03) v1(161.66,54.76) v1(161.66,44.5) v1(161.66,43.23) v1(161.66,41.96) v1(161.75,142.49) v1(161.69,108.49) v1(162.06,128.11) v1(162.07,110.39) v1(162.33,140.07) v1(162.33,139.49) v1(162.33,138.9) v1(162.33,138.32) v1(162.33,137.73) v1(162.54,145.92) v1(162.51,88.29) v1(162.7,128.11) v1(162.92,140.07) v1(162.92,139.49) v1(162.92,138.9) v1(162.92,138.32) v1(162.92,137.73) v1(162.93,115.35) v1(163.13,145.92) v1(163.21,113.76) v1(163.27,91.28) v1(163.44,183.77) v1(163.47,108.49) v1(163.44,103.66) v1(163.5,140.07) v1(163.5,139.49) v1(163.5,138.9) v1(163.5,138.32) v1(163.5,137.73) v1(163.51,56.34) v1(163.51,54.44) v1(163.51,43.54) v1(163.51,41.64) v1(163.66,115.36) v1(163.72,113.25) v1(163.72,112.67) v1(164.04,103.66) v1(164.14,140.06) v1(164.14,139.47) v1(164.14,138.89) v1(164.14,138.31) v1(164.14,137.72) v1(164.23,105.88) v1(164.23,3.43) v1(164.44,175.65) v1(164.55,90.03) v1(164.76,141.23) v1(164.76,140.64) v1(164.72,140.06) v1(164.72,139.47) v1(164.72,138.89) v1(164.72,138.31) v1(164.72,137.72) v1(165.12,105.88) v1(165.34,57.23) v1(165.34,55.96) v1(165.34,54.69) v1(165.34,44.43) v1(165.34,43.16) v1(165.34,41.89) v1(165.88,103.66) v1(166,88.61) v1(166.16,176.02) v1(166.23,91.46) v1(166.45,111.47) v1(166.45,110.89) v1(166.64,141.57) v1(166.64,140.88) v1(167.12,143.58) v1(167.25,57.3) v1(167.25,56.03) v1(167.25,54.76) v1(167.18,44.5) v1(167.18,43.23) v1(167.18,41.96) v1(167.49,142.44) v1(168.14,142.44) v1(168.75,91.46) v1(168.78,142.44) v1(169.02,57.61) v1(169.02,55.71) v1(169.02,44.81) v1(169.02,42.91) v1(169.3,127.92) v1(169.3,127.29) v1(169.43,142.44) v1(169.93,127.92) v1(169.93,127.29) v1(170.08,142.44) v1(170.63,174.47) v1(170.8,57.23) v1(170.8,55.96) v1(170.8,44.43) v1(170.8,43.16) v1(170.88,139.88) v1(170.88,139.3) v1(170.88,138.71) v1(170.88,138.13) v1(170.88,137.54) v1(170.96,79.34) v1(170.96,78.76) v1(170.96,77.79) v1(170.96,77.21) v1(170.97,75.53) v1(170.97,74.95) v1(170.97,74.36) v1(170.97,73.78) v1(171.06,183.77) v1(171.04,145.96) v1(171.46,139.88) v1(171.46,139.3) v1(171.46,138.71) v1(171.46,138.13) v1(171.46,137.54) v1(171.48,141.13) v1(171.51,140.48) v1(171.65,174.4) v1(171.85,3.43) v1(172.05,139.88) v1(172.05,139.3) v1(172.05,138.71) v1(172.05,138.13) v1(172.05,137.54) v1(172.13,141.13) v1(172.1,140.48) v1(172.28,142.01) v1(172.75,141.08) v1(172.76,140.5) v1(172.68,139.87) v1(172.68,139.28) v1(172.68,138.7) v1(172.68,138.11) v1(172.68,137.53) v1(172.81,141.69) v1(172.92,174.4) v1(173.15,57.23) v1(173.15,55.96) v1(173.15,54.69) v1(173.15,44.43) v1(173.15,43.16) v1(173.15,41.89) v1(174.38,173.45) v1(174.7,105.89) v1(174.74,56.28) v1(174.74,54.38) v1(174.74,43.48) v1(174.74,41.57) v1(175.01,173.45) v1(174.98,141.59) v1(174.98,140.9) v1(175.08,125.44) v1(175.46,143.61) v1(175.47,104.09) v1(175.59,170.95) v1(175.71,125.44) v1(175.83,142.46) v1(175.85,96.93) v1(175.78,94.96) v1(176.04,102.58) v1(176.01,101.1) v1(176.28,108.24) v1(176.35,105.44) v1(176.44,118.55) v1(176.48,142.46) v1(176.53,105.99) v1(176.71,57.23) v1(176.71,55.96) v1(176.71,54.69) v1(176.77,163.16) v1(176.83,44.43) v1(176.83,43.16) v1(176.83,41.89) v1(177.13,142.46) v1(177.56,6.5) v1(177.75,102.58) v1(177.73,101.11) v1(177.78,142.46) v1(177.87,36.48) v1(178.05,161.86) v1(178.04,119.09) v1(178,104.93) v1(178.38,173.2) v1(178.42,142.46) v1(178.52,185.32) v1(178.55,108.22) v1(178.62,8.33) v1(178.62,4.67) v1(178.76,173.64) v1(178.76,119.21) v1(178.95,171.04) v1(179.27,145.89) v1(179.26,140.08) v1(179.26,139.5) v1(179.26,138.91) v1(179.26,138.33) v1(179.26,137.75) v1(179.26,137.16) v1(179.27,39.02) v1(179.27,37.69) v1(179.49,135.42) v1(179.47,3.43) v1(179.59,171.04) v1(179.86,141.92) v1(179.86,141.34) v1(179.86,140.76) v1(179.85,140.08) v1(179.85,139.5) v1(179.85,138.91) v1(179.85,138.33) v1(179.85,137.75) v1(179.85,137.16) v1(179.9,145.89) v1(180,168.36) v1(180.12,135.4) v1(180.2,173.77) v1(180.43,140.08) v1(180.43,139.5) v1(180.43,138.91) v1(180.43,138.33) v1(180.43,137.75) v1(180.43,137.16) v1(180.43,136.58) v1(180.43,135.99) v1(180.73,135.41) v1(180.72,8.33) v1(180.72,4.67) v1(180.93,52.93) v1(181.01,138.32) v1(181.01,137.73) v1(181.01,137.15) v1(181.01,136.57) v1(181.01,135.98) v1(181.11,180.1) v1(181.3,166.41) v1(181.3,165.76) v1(181.49,139.11) v1(181.81,138.59) v1(181.85,137.95) v1(181.78,6.5) v1(181.95,168.34) v1(181.95,165.76) v1(181.95,164.46) v1(182,173.77) v1(182.05,139.96) v1(182.17,181.93) v1(182.17,178.27) v1(182.38,47.4) v1(182.6,162.51) v1(183.02,142.07) v1(183.25,161.85) v1(183.26,141.01) v1(183.9,161.19) v1(184.05,141.01) v1(184.27,181.93) v1(184.27,178.27) v1(184.54,128.05) v1(184.85,141.01) v1(184.85,139.96) v1(184.92,128.49) v1(185.33,180.1) v1(185.37,128.94) v1(185.43,138.34) v1(185.53,172.51) v1(185.75,129.38) v1(186,141.07) v1(186,140.43) v1(186,139.8) v1(186.06,137.57) v1(186.06,136.98) v1(186.32,119.22) v1(186.32,117.03) v1(186.32,114.85) v1(186.32,112.66) v1(186.36,21.44) v1(186.36,18.45) v1(187.09,3.43) v1(187.32,172.5) v1(187.38,184.93) v1(187.59,119.22) v1(187.59,117.03) v1(187.59,114.85) v1(187.85,19.94) v1(188.86,117.03) v1(188.86,114.85) v1(188.86,112.66) v1(189.24,172.78) v1(189.24,171.03) v1(189.35,21.44) v1(189.63,36.02) v1(189.95,27.03) v1(190.06,166.53) v1(190.13,94.08) v1(190.13,30) v1(190.18,165.87) v1(190.54,29.5) v1(190.55,27.03) v1(190.87,30.07) v1(191.65,163.48) v1(191.78,164.62) v1(191.78,24.86) v1(192.13,22.69) v1(192.25,130.5) v1(192.26,128.51) v1(192.25,126.51) v1(193.72,161.64) v1(194.14,103.26) v1(194.18,101.1) v1(194.18,99.45) v1(194.64,40.23) v1(194.65,39.65) v1(194.71,3.43) v1(194.96,17.22) v1(194.96,16.63) v1(195.05,98.04) v1(195.22,105.1) v1(195.25,95.83) v1(195.66,100) v1(195.76,55.6) v1(195.75,37.26) v1(195.73,34.38) v1(195.79,31.92) v1(195.82,29.65) v1(195.78,27.41) v1(195.84,24.94) v1(195.85,23.03) v1(195.91,103.76) v1(196.1,165.64) v1(196.07,101.14) v1(196.22,78.39) v1(196.3,38.9) v1(196.36,26.38) v1(196.29,24.01) v1(196.5,98.72) v1(196.69,102.5) v1(196.74,95.76) v1(196.82,57.43) v1(196.82,53.77) v1(196.88,24.1) v1(197.22,97.99) v1(197.63,99.96) v1(197.76,18.83) v1(198.04,94.75) v1(198.02,36.26) v1(197.98,32.06) v1(198.02,31.15) v1(198.87,77.01) v1(198.92,57.43) v1(198.92,53.77) v1(198.97,37.68) v1(199.03,35.84) v1(199.05,34.83) v1(199.14,170.21) v1(199.14,27.4) v1(199.2,161.17) v1(199.35,97.94) v1(199.66,95.51) v1(199.83,164.03) v1(199.86,38.36) v1(199.98,55.6) v1(200.03,37) v1(200.01,34.83) v1(200.11,180.1) v1(200.81,27.52) v1(200.88,183.17) v1(201.05,169.9) v1(201.07,34.85) v1(201,23.3) v1(200.99,22.49) v1(201.17,181.93) v1(201.17,178.27) v1(201.56,161.04) v1(201.91,38.4) v1(202.03,164.05) v1(202.05,32.55) v1(202,20.92) v1(202.12,162.84) v1(202.14,162.26) v1(202.14,161.67) v1(202.14,161.09) v1(202.15,35.72) v1(202.13,34.91) v1(202.07,24.53) v1(202.33,3.43) v1(202.56,48.5) v1(203.27,181.93) v1(203.27,178.27) v1(203.81,50.68) v1(203.81,46.32) v1(204.33,180.1) v1(204.36,38.46) v1(204.36,34.91) v1(204.36,20.97) v1(204.38,37.18) v1(204.38,36.48) v1(204.38,35.54) v1(205.68,23.22) v1(206.26,75.76) v1(206.33,50.68) v1(206.33,46.32) v1(206.73,33.22) v1(206.76,23.83) v1(207.58,48.5) v1(207.8,33.92) v1(207.87,24.53) v1(207.84,23.79) v1(208.44,181.94) v1(209.33,34.77) v1(209.32,34.04) v1(209.32,33.15) v1(209.32,32.38) v1(209.68,174.42) v1(209.95,3.43) v1(210.01,33.91) v1(209.97,33.18) v1(210.13,20.74) v1(210.27,23.9) v1(210.33,23.08) v1(210.96,73.63) v1(210.98,33.74) v1(211.21,91.54) v1(211.27,88.49) v1(211.46,69.69) v1(211.59,73.63) v1(212.1,69.69) v1(212.16,22.36) v1(212.23,73.63) v1(212.17,23.05) v1(212.53,24.1) v1(212.73,69.69) v1(213.91,36.13) v1(214.61,164.34) v1(215.03,39.9) v1(215.11,79.45) v1(215.64,39.92) v1(216.42,164.34) v1(217.6,78.9) v1(217.57,3.43) v1(217.92,61.72) v1(217.92,61.08) v1(218.56,156.58) v1(218.55,61.72) v1(218.55,61.08) v1(218.93,170.58) v1(219.19,61.72) v1(219.19,61.08) v1(220.06,158.08) v1(219.97,73.63) v1(219.97,70.96) v1(219.97,70.33) v1(220.54,92.62) v1(222.67,144.4) v1(222.78,56.91) v1(222.78,56.24) v1(222.78,55.57) v1(222.78,54.89) v1(223.21,73.63) v1(223.21,70.96) v1(223.21,70.33) v1(223.38,56.91) v1(223.54,79.53) v1(224.53,143.83) v1(224.75,56.91) v1(224.7,56.24) v1(224.7,55.57) v1(224.72,50.87) v1(224.72,50.24) v1(224.8,183.72) v1(224.8,176.1) v1(224.82,79.45) v1(225.18,55.9) v1(225.19,3.43) v1(225.31,50.87) v1(225.31,50.24) v1(225.59,78.87) v1(225.76,55.9) v1(226.01,80.83) v1(226.35,55.9) v1(226.54,78.42) v1(226.93,55.9) v1(227.17,78.42) v1(227.41,56.91) v1(227.41,56.24) v1(227.41,55.57) v1(227.41,54.89) v1(227.81,78.42) v1(228.17,54.32) v1(228.44,78.42) v1(228.48,181.86) v1(228.81,58.05) v1(228.81,57.44) v1(228.81,56.84) v1(228.81,56.21) v1(228.81,55.57) v1(228.81,54.94) v1(228.81,54.32) v1(228.91,164.81) v1(229.02,28.81) v1(229.31,50.81) v1(229.31,50.18) v1(229.75,154.46) v1(229.94,70.71) v1(229.94,70.01) v1(229.94,69.37) v1(229.91,50.81) v1(229.91,50.18) v1(230.72,123.48) v1(230.74,122.32) v1(231.47,55.92) v1(231.47,55.24) v1(231.47,54.57) v1(231.47,53.9) v1(231.8,175) v1(232.08,55.92) v1(232.81,3.43) v1(233.18,70.64) v1(233.18,70.01) v1(233.18,69.37) v1(233.44,55.92) v1(233.39,55.24) v1(233.39,54.57) v1(233.41,49.88) v1(233.41,49.24) v1(233.5,38.07) v1(233.87,54.91) v1(234.01,49.88) v1(234.01,49.24) v1(234.16,79) v1(234.26,38.07) v1(234.32,124.81) v1(234.32,122.9) v1(234.32,121.51) v1(234.39,163.8) v1(234.46,54.91) v1(234.67,154.84) v1(234.67,153.42) v1(234.67,152) v1(235.04,54.91) v1(235.62,54.91) v1(236.09,154.84) v1(236.09,153.42) v1(236.09,152) v1(236.1,55.92) v1(236.1,55.24) v1(236.1,54.57) v1(236.1,53.9) v1(236.57,9.06) v1(236.67,123.03) v1(236.74,53.31) v1(236.81,7.96) v1(237.37,57.06) v1(237.37,56.42) v1(237.37,53.31) v1(237.51,154.84) v1(237.51,153.42) v1(237.51,152) v1(237.5,55.85) v1(237.5,55.21) v1(237.5,54.58) v1(237.5,53.94) v1(237.58,35.72) v1(238.01,49.82) v1(238.01,49.18) v1(238.2,35.72) v1(238.79,8.99) v1(238.83,7.93) v1(239.42,174.87) v1(239.91,71.41) v1(239.91,70.71) v1(239.91,70.01) v1(239.91,69.37) v1(240,164.76) v1(240.04,55.92) v1(240.04,55.24) v1(240.04,54.57) v1(240.04,53.9) v1(240.14,166.5) v1(240.32,103.1) v1(240.43,3.43) v1(240.48,124.81) v1(240.48,122.84) v1(240.65,55.92) v1(240.66,7.96) v1(241.31,121.44) v1(241.96,55.24) v1(241.96,54.57) v1(242.01,55.92) v1(241.98,49.88) v1(241.98,49.24) v1(242.44,54.91) v1(242.58,49.88) v1(242.58,49.24) v1(242.9,28.8) v1(242.9,28.1) v1(243.03,54.91) v1(243.15,70.01) v1(243.15,69.37) v1(243.3,181.69) v1(243.53,28.8) v1(243.53,28.1) v1(243.61,54.91) v1(243.66,8.55) v1(244.2,54.91) v1(244.29,121.76) v1(244.48,180.32) v1(244.67,55.92) v1(244.67,55.24) v1(244.67,54.57) v1(244.67,53.9) v1(245.31,53.31) v1(245.44,8.55) v1(245.94,57.06) v1(245.94,56.42) v1(245.94,53.31) v1(245.88,28.8) v1(245.88,28.1) v1(246.07,55.85) v1(246.07,55.21) v1(246.07,54.58) v1(246.07,53.94) v1(246.52,28.8) v1(246.52,28.1) v1(246.58,49.82) v1(246.58,49.18) v1(247.15,28.8) v1(247.15,28.1) v1(247.14,21.59) v1(247.14,20.4) v1(247.1,8.58) v1(247.18,49.82) v1(247.18,49.18) v1(247.91,125.13) v1(247.89,120.32) v1(248.05,3.43) v1(248.11,21) v1(248.61,55.91) v1(248.61,55.24) v1(248.61,54.57) v1(248.61,53.89) v1(248.87,8.99) v1(248.89,10.87) v1(249.08,21.59) v1(249.08,20.4) v1(249.16,7.86) v1(249.22,55.91) v1(250.14,71.34) v1(250.53,55.24) v1(250.53,54.57) v1(250.58,55.91) v1(251.01,54.9) v1(251.25,49.87) v1(251.25,49.24) v1(251.41,125) v1(251.6,54.9) v1(251.84,49.87) v1(251.84,49.24) v1(251.85,20.35) v1(252,10.85) v1(252.18,54.9) v1(252.23,20.8) v1(252.76,54.9) v1(252.68,20.42) v1(252.97,121.38) v1(253.24,55.91) v1(253.24,55.24) v1(253.24,54.57) v1(253.24,53.89) v1(253.27,84.2) v1(253.37,71.34) v1(253.59,20.64) v1(254.01,71.34) v1(254.03,20.17) v1(254.47,122.88) v1(254.43,39.15) v1(254.43,38.51) v1(254.51,57.05) v1(254.51,56.41) v1(254.52,4.86) v1(254.61,71.34) v1(254.64,55.84) v1(254.64,55.21) v1(254.64,54.57) v1(254.64,53.94) v1(254.62,20.16) v1(254.78,5.38) v1(255.02,39.15) v1(255.02,38.51) v1(255.07,85.4) v1(255.1,4.87) v1(255.24,71.34) v1(255.22,54.57) v1(255.22,53.94) v1(255.22,22.13) v1(255.23,20.81) v1(255.2,20.15) v1(255.28,21.48) v1(255.66,39.15) v1(255.66,38.51) v1(255.67,3.43) v1(255.85,49.81) v1(255.85,49.18) v1(255.79,20.16) v1(255.88,21.47) v1(255.89,20.83) v1(256.25,85.4) v1(256.29,39.15) v1(256.29,38.51) v1(256.49,21.51) v1(256.49,20.89) v1(256.8,58.13) v1(256.8,57.5) v1(257.16,90.16) v1(257.09,21.52) v1(257.18,78.26) v1(257.37,154.27) v1(257.37,153.64) v1(257.37,153) v1(257.37,152.37) v1(257.43,110.91) v1(257.44,58.13) v1(257.44,57.5) v1(257.93,92.6) v1(257.95,78.26) v1(258.07,58.13) v1(258.07,57.5) v1(258.54,78.26) v1(258.9,106.85) v1(259.15,78.26) v1(259.75,78.26) v1(259.85,107.82) v1(259.96,6.5) v1(260.26,60.26) v1(260.3,85.12) v1(260.35,78.26) v1(260.93,78.26) v1(260.89,60.26) v1(261.04,100.13) v1(261.02,8.33) v1(261.02,4.67) v1(261.53,78.26) v1(261.53,60.26) v1(261.5,29.18) v1(261.95,175.7) v1(261.88,28.73) v1(262.12,78.26) v1(262.2,164.81) v1(262.2,164.18) v1(262.2,163.54) v1(262.2,162.91) v1(262.5,101.53) v1(262.77,171.22) v1(262.77,170.53) v1(262.77,169.83) v1(262.77,169.2) v1(263,87.25) v1(263.11,181.69) v1(263.12,8.33) v1(263.12,4.67) v1(263.34,21.05) v1(263.29,3.43) v1(263.41,171.22) v1(263.41,170.53) v1(263.41,169.83) v1(263.41,169.2) v1(263.44,87.66) v1(263.49,183.17) v1(263.47,78.26) v1(263.91,88) v1(264.04,170.53) v1(264.04,169.83) v1(264.04,169.2) v1(264.18,6.5) v1(264.36,22.83) v1(264.49,16.61) v1(264.74,170.53) v1(264.93,16.99) v1(265.18,160.24) v1(265.18,158.97) v1(265.24,6.5) v1(265.31,169.2) v1(265.48,17.28) v1(265.86,163.28) v1(265.85,162.66) v1(265.87,161.93) v1(265.88,71.22) v1(265.99,175.97) v1(266.39,163.54) v1(266.39,162.91) v1(266.39,162.27) v1(266.39,161.64) v1(266.56,150.5) v1(266.75,8.74) v1(266.75,4.26) v1(267.03,163.54) v1(267.03,162.91) v1(267.03,162.27) v1(267.03,161.64) v1(267.01,19.25) v1(267.66,162.91) v1(267.66,162.27) v1(267.66,161.64) v1(267.66,71.03) v1(267.66,44.74) v1(267.66,44.15) v1(267.66,43.57) v1(267.66,42.98) v1(267.81,152.68) v1(267.81,148.32) v1(268.23,60.04) v1(268.23,59.34) v1(268.23,58.64) v1(268.3,44.74) v1(268.3,44.15) v1(268.3,43.57) v1(268.3,42.98) v1(268.68,54.89) v1(268.68,54.21) v1(268.68,53.54) v1(268.68,52.87) v1(268.87,60.04) v1(268.87,59.34) v1(268.87,58.64) v1(268.93,16.49) v1(269.19,8.74) v1(269.19,4.26) v1(269.29,54.89) v1(269.4,14.55) v1(270.11,71.85) v1(270.33,152.68) v1(270.33,148.32) v1(270.46,47.83) v1(270.52,30.45) v1(270.65,54.89) v1(270.6,54.21) v1(270.6,53.54) v1(270.62,6.5) v1(270.84,30.96) v1(270.91,3.43) v1(271.08,53.88) v1(271.09,47.83) v1(271.15,30.45) v1(271.18,71.09) v1(271.34,47.3) v1(271.58,150.5) v1(271.67,53.88) v1(271.73,47.83) v1(271.77,99.76) v1(272.18,167.2) v1(272.17,71.09) v1(272.25,53.88) v1(272.36,47.83) v1(272.83,167.19) v1(272.84,53.88) v1(273,47.83) v1(273.25,173.67) v1(273.31,54.89) v1(273.31,54.21) v1(273.31,53.54) v1(273.31,52.87) v1(273.74,166.1) v1(273.82,99.76) v1(273.8,71.85) v1(273.95,52.28) v1(274.06,170.6) v1(274.34,166.08) v1(274.58,56.02) v1(274.58,55.39) v1(274.58,52.28) v1(274.71,54.82) v1(274.71,54.18) v1(274.71,53.55) v1(274.71,52.91) v1(275.12,172.43) v1(275.12,168.77) v1(275.54,165.77) v1(275.6,48.83) v1(276.2,48.8) v1(276.87,48.8) v1(277.02,157.62) v1(277.22,172.43) v1(277.22,168.77) v1(277.5,48.8) v1(277.64,158.24) v1(277.64,157) v1(278.26,157.62) v1(278.28,170.6) v1(278.53,3.43) v1(280.87,173.67) v1(283.23,60.2) v1(284.27,58.86) v1(284.27,56.74) v1(284.27,54.62) v1(284.59,167.75) v1(286.15,3.43) v1(286.39,58.86) v1(286.39,56.74) v1(286.39,54.62) v1(286.99,161.5) v1(286.99,153.88) v1(286.99,146.26) v1(286.99,138.64) v1(286.99,131.02) v1(286.99,123.4) v1(286.99,115.78) v1(287.01,108.16) v1(287.98,100.6) v1(288.51,58.86) v1(288.51,56.74) v1(288.51,54.62) v1(289.96,44.8) v1(289.96,41.8) v1(290.12,93.29) v1(291.46,43.3) v1(293.4,86.41) v1(293.77,3.43) v1(295.76,76.25) v1(296.82,78.08) v1(296.82,74.42) v1(297.73,80.14) v1(298.55,78.25) v1(298.92,74.42) v1(299.98,76.25) v1(300.94,73.23) v1(300.94,65.61) v1(301.39,3.43) v1(306.11,9.4) v1(306.71,9.36) v1(307.31,51.82) v1(307.31,49.84) v1(307.55,61.82) v1(308.3,50.83) v1(309.01,3.43) v1(309.29,51.82) v1(309.29,49.84) v1(315.17,61.82) v1(316.63,3.43) v1(321.23,22.1) v1(321.99,58.42) v1(322.63,23.34) v1(322.87,21.68) v1(322.78,19.84) v1(324.25,3.43) v1(324.89,51.37) v1(328.75,36.71) v1(328.74,35.4) v1(330.3,43.69) v1(330.3,41.71) v1(331.29,42.7) v1(331.96,35.9) v1(331.87,3.43) v1(332.28,43.69) v1(332.28,41.71) v1(332.51,51.37) v1(337.99,46.08) v1(337.99,38.46) v1(337.99,30.84) v1(337.99,23.22) v1(337.99,15.6) v1(337.99,7.98) v4(23.1,42.74) v4(55.71,21.24) v4(80.97,19.53) v4(85.92,31.34) v4(88.21,48.48) v4(94.56,30.58) v4(175.27,140.3) v4(187.33,129.06) v4(225.31,57.69) v4(229.8,48.33) v4(235.7,48.27) v4(246.07,48.29) v4(251.68,57) v4(252.65,48.14) v4(255.33,48.1) v4(255.34,18.76) v4(258.15,23.16) v4(261.31,79.15) v4(263.79,85.38) v4(264.49,162.72) v4(269.31,31.59)
