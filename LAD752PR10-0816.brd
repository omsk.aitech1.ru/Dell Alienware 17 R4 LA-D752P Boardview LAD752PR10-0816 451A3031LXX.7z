# Allegro board LAD752PR10-0816.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
B+_BIAS: length 316.8
  TOP w0.508: R179.2 191.91,20.05 191.4,19.54 v1(191.4,19.08)
  IN2 w0.508: v1(324.49,10.7) 322.14,10.7 319.92,8.48 315.96,8.48 315.05,7.56 309.86,7.56 309.63,7.33 306.23,7.33 306,7.56 291.98,7.56 291.07,8.48 288.34,8.48 287.66,9.15 276.62,9.15 274.06,11.72 271.88,11.72 271.31,11.15 270.34,11.15 269.9,11.59 268.94,11.59 268.5,11.15 266.75,11.15 266.18,11.72 258.37,11.72 258.17,11.52 242.62,11.52 241.85,10.74 241.38,10.74 240.6,11.52 233.4,11.52 232.77,10.89 231.74,10.89 231.4,10.54 227.03,10.54 225.55,12.03 216.35,12.03 213.91,9.59 208,9.59 206.45,8.03 193.51,8.03 192.27,9.27 191.56,9.27 v1(190.51,8.22) 188.16,8.22 182.22,14.16 111.09,14.16 109.11,12.19 86.52,12.19 85.11,10.77 73.54,10.77 72.64,9.87 70.2,9.87 69.58,9.25 v1(67.31,9.25)
  IN2 w1.524: 41.14,7.64 43.06,9.56 53.64,9.56 56,7.19 65.11,7.19 65.58,7.66 ; 36.08,6.57 31.56,6.57 31.46,6.67 30.4,6.67 29.6,5.87 29.6,5.43
  IN4 w0.508: v1(191.4,19.08) 190.83,18.51 190.83,14.32 191.4,13.75 191.4,10.89 191.02,10.51 191.02,8.73 v1(190.51,8.22)
  vias: v1(27.38,2.51) v1(27.38,1.87) v1(27.89,2.19) v1(65.91,9.25) v1(66.61,9.25) v4(66.56,11.59)
B+_VCCIO: length 0.8
  BOTTOM w0.107: v2(118.84,115.96) 118.96,116.07 118.96,116.71
BATDRV_CHG: length 29.1
  TOP w0.203: PU700.18 57.44,19.36 v1(57.41,19.34)
  TOP w0.254: PR733.2 78.79,27.21 78.79,24.07 v1(78.37,23.65)
  IN3 w0.254: v1(57.41,19.34) 57.6,19.34 58.28,18.66 61.76,18.66 62.18,19.08 75.45,19.08 78.37,22 v1(78.37,23.65)
BATLOW#: length 9.4
  TOP w0.089: UT1.F2 176.37,167.54 176.14,167.31 175.75,167.31 175.7,167.26 175.51,167.26 175.5,167.25 175.47,167.25
  TOP w0.107: 175.47,167.25 175.41,167.25 175.14,166.98 175.14,166.18 174.55,165.59 173.33,165.59 172.73,164.99 172.73,164.9 v2(172.73,164.9) 172.73,164.89 172.73,163.16 172.62,163.05 171.47,163.05 171.36,162.95 171.36,162.9 RT31.2 RT14.1
BATSRC_CHG: length 31.1
  TOP w0.203: PU700.17 57.04,19.61 56.96,19.53 56.96,19.51 56.71,19.27 v1(56.71,19.15)
  TOP w0.254: PR734.2 78.3,27.92 v2(78.3,26.13) v1(78.3,24.29)
  IN3 w0.254: v1(78.3,24.29) 77.8,23.78 77.8,22.13 75.13,19.46 61.86,19.46 61.44,19.04 58.47,19.04 57.67,19.84 57.22,19.84 56.71,19.34 v1(56.71,19.15)
BATT+: length 1.4
  BOTTOM w0.107: PR712.4 v2(79.83,19.91)
BATT++: length 31.6
  TOP w0.107: PC8.1 v4(83.08,21.49) ; v1(85.35,20.48) v4(86.39,20.48)
  IN4 w0.508: v1(59.89,19.91) 59.89,19.4 60.65,18.64 64.21,18.64 64.91,19.34 71.19,19.34 72.84,20.99 84.21,20.99 v1(84.72,20.48)
  BOTTOM w0.508: v1(59.89,19.91) 59.89,19.78 59.32,19.21 59.32,18.83 58.86,18.37 PD700.2
  vias: v4(84.54,19.81)
BATT_CHG_LED: length 30
  TOP w0.432: RE23.2 325.26,39.14 QE1.6
  TOP w0.457: UE1.25 v1(313.5,16.33)
  TOP w0.508: RE23.2 324.7,38.08 324.56,37.94 v1(323.73,37.94)
  IN3 w0.508: v1(323.73,37.94) 323.73,36.91 320.25,33.43 320.25,30 316.33,26.08 316.33,18.94 315.13,17.75 314.68,17.75 313.5,16.57 v1(313.5,16.33)
BATT_CHG_LED#: length 49.9
  TOP w0.127: v2(324.1,42.04) 324.1,41.69 324.6,41.19 QE1.2
  TOP w0.254: v1(303.03,9.43) 303.14,9.32 UE5.90
  TOP w0.432: QE1.2 324.6,40.25 v1(324.68,40.16)
  IN3 w0.508: v1(303.03,9.43) 303.03,10.1 304.34,11.4 314.96,11.4 315.48,11.92 315.48,15.13 318.9,18.55 318.9,26.24 325.32,32.66 325.32,39.52 v1(324.68,40.16)
BATT_LOW_LED: length 43.9
  TOP w0.432: QE3.6 326.48,43.67 326.72,43.91 327.36,43.91 327.82,44.37 v2(327.82,45.4) 327.78,45.43 327.11,45.43 v1(327.1,45.44) 326.42,46.12 RE21.2
  TOP w0.457: UE1.22 315.4,16.9 v1(314.84,16.35)
  IN3 w0.508: v1(314.84,16.35) 314.94,16.35 317.18,18.59 317.18,25.73 321.1,29.65 321.1,33.07 324.59,36.56 324.59,39.36 324,39.95 324,42.15 323.29,42.86 323.29,44.67 323.65,45.03 325.81,45.03 326.21,45.44 v1(327.1,45.44)
BATT_LOW_LED#: length 56.7
  TOP w0.109: v1(324.59,44.06) 324.59,45.67 v2(324.07,46.18)
  TOP w0.203: UE5.93 304.34,9.4 v1(304.36,9.43)
  TOP w0.432: QE3.2 325.83,44.49 325.4,44.06 v1(324.59,44.06)
  IN3 w0.508: v1(324.59,44.06) 325.17,44.06 326.59,42.64 326.59,32.14 320.17,25.71 320.17,18.02 319.29,17.15 319.29,16 316.75,13.45 316.75,11.39 315.49,10.13 304.87,10.13 304.36,9.63 v1(304.36,9.43)
BATT_PRS: length 7.8
  TOP w0.254: v1(82.82,9.69) 82.43,9.69 81.28,10.83 v2(80.97,10.83) PR22.1
  BOTTOM w0.508: v1(82.82,9.69) PBATT1.7
BBS_BIT0: length 2.2
  TOP w0.089: v2(211.97,24.54) 212.23,24.8 v1(212.23,24.99)
  TOP w0.107: RH130.2 211.6,25.61 v1(212.23,24.99)
  BOTTOM w0.089: v1(212.23,24.99) 212.12,25.09 UH1.AT29
BEEP#: length 315.1
  TOP w0.107: v1(36.21,51.16) 36.71,50.66 v2(36.71,49.88) 36.71,39.56 39.86,36.41 39.86,34.48 41.62,32.72 41.62,31.46 41.65,31.43 41.65,25.03 41.08,24.46 DA1.2 ; v1(296.18,26.78) 296.18,25.24 296.74,24.68 UE5.23
  IN2 w0.091: v1(36.21,51.16) 37.56,49.82 46.34,49.82 47.14,49.01 55.11,49.01 55.39,49.29 59.37,49.29 59.37,49.29 66.33,49.29 66.88,48.75 81.5,48.75 81.88,49.13 87.34,49.13 87.45,49.01 97.61,49.01 97.8,48.82 107.39,48.82 109.76,51.2 147.48,51.2 147.87,50.82 149.42,50.82 150.18,51.58 171.67,51.58 172.3,50.96 172.3,49.98 173.08,49.19 174.11,49.19 174.42,48.89 174.42,48.62 175.14,47.9 176.52,47.9 176.83,47.59 178.83,47.59 181.25,50.01 183.25,50.01 185.08,51.83 192.51,51.83 196.27,48.07 199.6,48.07 203.47,51.94 206.5,51.94 208.51,49.93 208.51,47.56 209.62,46.45 214.17,46.45 214.53,46.09 216.13,46.09 217.03,45.19 227.14,45.19 228.21,44.13 258.54,44.13 258.54,44.13 263.48,44.13 274.15,33.46 278.18,33.46 279.49,32.14 281.57,32.14 286.01,27.7 295.16,27.7 296.09,26.78 v1(296.18,26.78)
BKOFF#: length 275.8
  TOP w0.107: v1(171.52,157.89) 170.88,158.54 DV1.2 ; v1(305.76,12.86) 305.92,13.01 UE5.105
  IN2 w0.091: v1(171.52,157.89) 172.54,156.88 172.54,155.93 174.34,154.12 176.57,154.12 176.99,154.54 183.98,154.54 185.08,155.64 188.01,155.64 191.99,151.66 191.99,149.98 197.74,144.24 197.74,111.94 194.34,108.54 194.34,104.06 193.24,102.97 193.24,95.91 195.53,93.63 195.53,91.47 199.48,87.52 199.48,80.56 199.72,80.32 199.72,75.92 198.98,75.19 198.98,74.11 199.25,73.84 199.25,70.41 199.46,70.2 199.46,67.71 200.58,66.59 203.96,66.59 204.65,65.9 206.38,65.9 207.54,64.74 212.69,64.74 213.76,65.81 223.65,65.81 224.17,66.33 224.3,66.33 224.45,66.48 249.35,66.48 249.54,66.29 266.95,66.29 267.1,66.44 273.83,66.44 279.48,60.79 279.48,47.74 282.02,45.2 293.9,45.2 293.95,45.16 295.96,45.16 296,45.2 v1(298.44,45.2)
  BOTTOM w0.107: v1(305.76,12.86) 305.19,13.43 302.09,13.43 300.75,14.76 299.79,14.76 298.87,15.69 298.87,25.98 299.81,26.93 299.81,30.29 298.21,31.89 298.21,36.03 298.55,36.37 v2(298.55,44.09) 298.55,45.09 v1(298.44,45.2)
BOARD_ID: length 27.1
  BOTTOM w0.089: UH1.AL44 209.73,17.79 209.58,17.65 209.58,17.02 209.76,16.85 210.89,16.85 212.23,15.51 212.59,15.16
  BOTTOM w0.107: 212.59,15.16 212.61,15.13 212.61,13.1 211.71,12.2 210.61,12.2 208.84,10.43 204.21,10.43 203.08,9.3 199.89,9.3 v2(197.96,11.23) 196.98,12.22 196.98,12.23 196.82,12.39 RH22.1 RH21.1
BOOT_1.2V: length 1.4
  BOTTOM w0.107: v2(89.42,45.12) 89.61,44.93 PR200.2
BST_1.2V: length 1.3
  BOTTOM w0.107: PR200.1 v2(86.94,43.78)
BST_3V: length 3.6
  BOTTOM w0.107: v2(56.21,41.43) 56.21,42.23 56.6,42.63 56.6,43.36 57.22,43.99 PR108.2
BST_5V: length 1.6
  BOTTOM w0.107: v2(51.34,43.16) 50.74,43.76 PR109.1
BST_+1VALWP: length 1.2
  TOP w0.107: PR302.1 v2(245.34,21.27)
BST_VCCIO: length 3
  BOTTOM w0.107: PR5010.1 117.6,114.14 117.6,112.38 v2(117.76,112.21)
BT_OFF#: length 149.8
  TOP w0.107: v1(317.39,37.09) 316.41,36.11 315.77,36.11 315.45,36.43 RN17.2
  IN4 w0.097: v1(213.71,16.43) 213.71,16.43 213.71,16.43 213.89,16.61 218.19,16.61 218.8,16 226.89,16 227.63,16.73 235.97,16.73 237.6,15.11 239.97,15.11 240.27,14.81 241.79,14.81 243.58,13.01 246,13.01 246.52,12.49 250.37,12.49 250.54,12.32 264.71,12.32 267.98,15.59 291.99,15.59 293.03,14.54 294.11,14.54 295.82,12.83 301.97,12.83 302.7,13.57 309.76,13.57 310.39,12.93 316.26,12.93 318.31,10.87 318.66,10.87 v1(319.07,11.28)
  BOTTOM w0.089: UH1.AV43 212.96,18.69 213.2,18.45 213.2,17.77 213,17.57 213,17.21 213.71,16.5 v1(213.71,16.43) 213.71,16.43 213.71,16.1 214.25,15.56 214.25,15.16
  BOTTOM w0.107: v1(319.07,11.28) 318.72,11.63 318.72,16.27 319.73,17.29 319.73,25.8 321.7,27.77 v2(321.7,29.33) 321.7,35.46 320.07,37.09 v1(317.39,37.09) ; RH517.2 214.25,15.16
BT_OFF#_R: length 8.7
  TOP w0.107: v2(317.57,38.13) v1(316.92,38.13) RN16.2 CN25.1 RN17.1
  BOTTOM w0.107: v1(316.92,38.13) 316.67,38.39 314.83,38.39 313.57,39.64 JWLAN.46
BUSPOWER#: length 7.1
  BOTTOM w0.076: UT4.F10 202.66,162.61 202.86,162.82 203.55,162.82
  BOTTOM w0.107: 203.55,162.82 203.6,162.77 203.95,162.77 204.4,163.21 204.72,163.21 205.43,163.93 207.45,163.93 207.62,163.76 RT74.2 v2(207.62,162.27)
CALDERA_ PWRGD: length 322.8
  TOP w0.107: v1(330.21,46.83) 331.29,46.83 v2(331.67,46.45) 331.92,46.2 331.92,45.49 331.54,45.11 UE6.15
  IN2 w0.091: v1(152.67,175.48) 153.15,175 160.89,175 162.22,173.67 162.22,166.84 163.65,165.41 163.65,161.22 164.07,160.8 164.07,155.5 167.72,151.85 167.72,150.73 168.11,150.34 168.95,150.34 170.17,149.11 186.37,149.11 191.29,144.2 191.29,127.8 185.22,121.72 185.22,111.47 184.55,110.8 184.55,100.63 185.92,99.26 185.92,95.12 187.96,93.08 187.96,73.27 188.34,72.89 188.34,71.27 188.86,70.74 189.54,70.74 197.91,62.38 207.2,62.38 209.25,60.33 210.37,60.33 211.74,58.96 211.74,54.68 212.88,53.54 212.88,52.45 215.96,49.37 226.23,49.37 227.34,48.25 266.99,48.25 272.25,43 272.25,41.25 273.98,39.52 284.94,39.52 286.33,38.13 288.09,38.13 288.35,37.86 290.27,37.86 295.13,33 296.92,33 297.6,32.33 300.24,32.33 303.48,29.09 321.8,29.09 326.25,33.53 326.25,40.28 327.19,41.22 328.28,41.22 329.34,42.27 329.34,45.96 v1(330.21,46.83)
  BOTTOM w0.107: RM42.1 152.66,175.47 v1(152.67,175.48) JCDRA.2
CALDERA_ON: length 347.4
  TOP w0.107: UE5.108 305.93,14.21 v1(305.89,14.26)
  IN2 w0.091: v1(306.46,27.21) 301.69,27.21 298.46,30.44 293.6,30.44 288.21,35.84 284.75,35.84 284.26,36.33 273.43,36.33 264.11,45.66 229.38,45.66 228.31,46.72 217.66,46.72 216.77,47.62 215.17,47.62 211.13,51.65 211.13,52.56 209.93,53.77 209.93,55.09 206.83,58.2 201.22,58.2 199.44,59.98 197.32,59.98 192.43,64.87 191.27,64.87 186.24,69.9 186.24,72.01 185.99,72.26 185.99,92.17 183.31,94.85 183.31,98.35 181.1,100.55 181.1,117.25 182.72,118.87 182.72,121.86 189.51,128.66 189.51,143.15 185.32,147.34 177.44,147.34 176.64,146.54 173.29,146.54 172.49,147.34 168.93,147.34 167.9,148.38 167.35,148.38 164.43,151.3 158.57,151.3 156.95,152.92 140.39,152.92 138.03,150.56 130.85,150.56 130.69,150.4 v1(128.97,150.4)
  IN3 w0.091: v1(128.97,150.4) 129.61,151.05 129.61,151.35 130.5,152.24 134.66,152.24 137.23,154.81 137.23,155.73 138.63,157.13 138.63,159.06 139.07,159.51 143.45,159.51 145.42,161.48 145.42,162.95 145.14,163.23 145.14,167.08 148.8,170.73 148.8,170.74 148.85,170.78 148.85,172.36 150,173.51 150,175.27 v1(149.97,175.29)
  BOTTOM w0.107: JCDRA.1 151.87,176.24 151.36,175.74 150.25,175.74 149.97,175.46 v1(149.97,175.29) 149.98,175.29 149.98,175.25 150.26,174.96 UM7.2 150.26,171.61 RM41.2 ; v1(306.46,27.21) 305.74,26.49 305.74,24.61 307.03,23.32 307.03,15.4 v1(305.89,14.26)
CALDERA_PRSNT#: length 373
  TOP w0.107: UE1.28 v1(313.5,13.93) ; UE6.5 332.04,40.3 333.22,39.12 333.22,36.08 331.92,34.78 326.95,34.78 v2(326.64,34.46) 325.23,33.05 323.92,33.05 v1(323.35,32.48)
  IN2 w0.091: v1(323.35,32.48) 320.18,29.31 303.57,29.31 300.33,32.54 297.69,32.54 297.02,33.22 295.22,33.22 290.36,38.08 288.44,38.08 288.18,38.35 286.42,38.35 285.03,39.73 274.07,39.73 272.46,41.34 272.46,43.09 267.08,48.47 227.43,48.47 226.32,49.58 216.05,49.58 213.1,52.54 213.1,53.63 211.96,54.77 211.96,59.05 210.46,60.55 209.34,60.55 207.29,62.59 198,62.59 189.63,70.96 188.95,70.96 188.56,71.36 188.56,72.98 188.18,73.36 188.18,93.17 186.14,95.21 186.14,99.35 184.77,100.72 184.77,110.71 185.44,111.38 185.44,121.63 191.51,127.7 191.51,144.29 186.46,149.33 170.27,149.33 168.81,150.79 168.81,151.07 164.29,155.59 164.29,160.89 163.87,161.31 163.87,165.5 162.44,166.93 162.44,173.76 160.8,175.4 v1(158.98,175.4)
  IN3 w0.091: v1(158.98,175.4) 154.32,175.4 152.88,176.84 149.14,176.84 148.19,175.89 148.19,171.06 144.29,167.16 144.29,165.7 143.42,164.83 143.42,164.06 142.76,163.4 142.76,161.88 142.45,161.58 v1(141.61,161.58) ; v1(313.5,13.93) 313.67,13.93 318.47,18.73 318.47,26.41 323.35,31.29 v1(323.35,32.48)
  BOTTOM w0.107: JCDRA.21 160.62,176.67 160.73,176.56 160.73,176.09 160.04,175.4 v1(158.98,175.4) 158.98,174.8 RM5.2 ; v1(141.61,161.58) 141.61,155.73 140.46,154.58 RM61.1
CALDERA_RST#: length 318.4
  TOP w0.107: UE6.16 331.04,45.12 331.42,45.5 v1(331.42,45.58)
  IN3 w0.091: v1(163.71,171.48) 163.71,171.16 163.87,171.01 165.42,171.01 165.76,170.67 165.76,167.96 166.53,167.19 168.5,167.19 169.4,166.29 170.13,166.29 170.55,166.72 173.97,166.72 175.14,167.89 175.14,171.14 176.18,172.18 184.67,172.18 185.05,171.8 186.13,171.8 187.4,170.53 190.84,170.53 191.42,171.12 192.77,171.12 193.42,170.47 197.52,170.47 198,169.98 198,167.93 198.27,167.66 198.27,164.89 195.72,162.34 195.72,161.51 193.87,159.67 193.87,151.08 195.65,149.3 195.65,110.35 200.06,105.94 200.06,102.43 203.41,99.08 203.41,92.94 201.27,90.81 198.1,90.81 196.99,89.69 v1(195.12,89.69)
  IN4 w0.097: v1(331.42,45.58) 330.88,45.04 330.59,45.04 329.57,44.02 329.57,42.51 328.88,41.82 327.86,41.82 327.1,42.58 323.73,42.58 323.1,43.21 323.1,44.48 322.54,45.04 320.7,45.04 318.88,46.85 317.23,46.85 310.81,53.28 296.32,53.28 294.52,55.09 292.44,55.09 292.07,54.71 292.07,49.47 291.61,49.01 286.82,49.01 286.52,49.31 284.17,49.31 282.9,50.58 282.9,56.99 281.82,58.07 280.93,58.07 280.42,57.56 275.98,57.56 273.68,59.86 270.57,59.86 269.52,60.91 229.33,60.91 224.41,65.82 213.2,65.82 210.16,68.87 206.42,68.87 204.8,70.49 204.8,71.66 198.64,77.82 198.64,85.95 195.12,89.46 v1(195.12,89.69)
  BOTTOM w0.107: v1(163.71,171.48) 162.62,171.48 v2(162.41,171.69) 162.23,171.87 RM6.2 161.82,172.7 161.82,172.7 161.61,172.7 161.48,172.58 UM3.1
CAPS: length 42
  BOTTOM w0.107: RE639.1 242.58,17.11 240.29,19.4 240.29,21.43 239.91,21.81 238.96,21.81 238.66,21.51 238.66,18.66 234.63,14.64 233.32,14.64 229.33,10.65 226.42,10.65 v2(226.09,10.32) 225.74,9.97 225.74,9.23 225.36,8.85 223.82,8.85 223.11,9.56 222.7,9.56 222.47,9.32 JKB.3
CAPS_LED: length 67
  TOP w0.107: v1(276.7,11.34) 276.7,12.27 274.32,14.66 272.89,14.66 272.06,13.83 v2(271.6,13.83) 268.65,13.83 v1(268.07,13.25) ; v1(304.24,4.48) 304.24,6.62 303.54,7.32 UE5.91
  IN1 w0.097: v1(276.7,11.34) 285.24,11.34 289.19,7.4 296.62,7.4 298.47,5.54 303.17,5.54 v1(304.24,4.48)
  IN4 w0.097: v1(255.17,14.55) 255.35,14.73 263.19,14.73 v1(264.42,15.97)
  BOTTOM w0.107: RE640.1 257.95,16.42 258.2,16.16 258.2,14.62 257.37,13.8 255.92,13.8 v1(255.17,14.55) ; v1(268.07,13.25) 268.07,13.25 267.64,12.81 267.08,12.81 264.42,15.48 v1(264.42,15.97)
CDR_BTN#: length 296.2
  TOP w0.107: UE5.120 306.19,19.01 305.25,18.07 v1(305.25,17.81)
  IN2 w0.091: v1(299.41,36.29) 293.02,42.68 285.74,42.68 285.04,43.38 281.93,43.38 278.17,47.14 278.17,51.97 276.42,53.71 276.42,61.51 272.81,65.13 267.64,65.13 267.49,64.98 249,64.98 248.81,65.17 225,65.17 222.69,62.86 207.96,62.86 207.68,63.14 202.29,63.14 201.05,64.37 198.91,64.37 196.43,66.85 195.6,66.85 192.15,70.3 192.15,70.93 189.86,73.22 189.86,92.85 188.79,93.92 188.79,97.8 189.32,98.33 189.32,106.35 189.39,106.42 189.39,110.65 193.41,114.68 193.41,128.63 192.87,129.17 192.87,144.16 186.82,150.21 172.15,150.21 171.88,150.48 171.88,150.78 170.07,152.58 168.84,152.58 168.74,152.69 165.38,156.04 165.38,161.35 164.96,161.76 164.96,163.76 165.68,164.48 165.68,168.88 165.49,169.08 165.49,171.19 166.09,171.79 166.09,173.17 165.83,173.42 v1(164.85,173.42)
  BOTTOM w0.107: v1(305.25,17.81) 304.11,16.68 299.49,16.68 299.1,17.07 299.1,25.88 300.05,26.83 300.05,30.39 298.45,31.99 298.45,35.83 298.9,36.29 v1(299.41,36.29) ; JCDRA.26 162.62,176.58 163.49,175.71 163.49,175.11 163.14,174.75 RM17.2 163.79,174.49 v1(164.85,173.42)
CDR_ON_ELC: length 303.3
  TOP w0.107: UE1.27 313.79,14.73 314.14,15.08 v1(314.14,15.77)
  IN2 w0.091: v1(151.84,173.01) 152.98,174.15 159.6,174.15 160.33,173.42 160.33,172.28 160.62,172 160.62,171 161.96,169.65 161.96,166.75 163.43,165.28 163.43,161.13 163.85,160.71 163.85,155.41 167.5,151.76 167.5,150.64 168.02,150.12 168.86,150.12 170.08,148.9 186.28,148.9 191.07,144.1 191.07,127.89 185,121.81 185,111.56 183.73,110.29 183.73,101.14 185.7,99.16 185.7,95.03 187.75,92.99 187.75,73.17 188.12,72.8 188.12,71.18 188.77,70.52 189.45,70.52 197.82,62.16 207.11,62.16 209.16,60.11 210.28,60.11 211.52,58.87 211.52,54.59 212.66,53.45 212.66,52.36 215.87,49.15 226.14,49.15 227.25,48.03 266.9,48.03 272.03,42.91 272.03,41.16 273.89,39.3 284.85,39.3 286.24,37.91 287.99,37.91 293.12,32.78 296.83,32.78 297.64,31.97 300.28,31.97 303.39,28.87 312.34,28.87 v1(312.74,28.46)
  BOTTOM w0.107: v1(314.14,15.77) 313.32,15.77 312.75,16.34 312.75,28.32 312.74,28.33 v1(312.74,28.46) ; v1(151.84,173.01) 151.02,173.01 150.91,172.9 UM7.4
CDR_TXRX_GOOD: length 359.5
  TOP w0.107: v1(330.21,45.63) 330.04,45.45 UE6.18
  IN2 w0.091: v1(128.91,151.1) 129.23,150.78 137.94,150.78 140.3,153.14 157.04,153.14 158.66,151.52 164.52,151.52 167.44,148.59 167.99,148.59 169.02,147.56 172.59,147.56 173.39,146.76 176.55,146.76 177.35,147.56 185.42,147.56 189.73,143.24 189.73,128.57 182.94,121.77 182.94,118.78 181.32,117.16 181.32,100.64 183.52,98.44 183.52,94.94 186.21,92.26 186.21,72.35 186.46,72.1 186.46,70.47 188.29,68.64 188.96,68.64 197.41,60.19 199.53,60.19 201.31,58.41 206.92,58.41 210.15,55.19 210.15,53.86 211.35,52.66 211.35,51.74 215.26,47.84 216.86,47.84 217.75,46.94 228.4,46.94 229.47,45.88 264.2,45.88 272.75,37.32 283.57,37.32 284.84,36.06 288.3,36.06 293.69,30.66 298.55,30.66 301.6,27.61 321,27.61 326.69,33.3 326.69,40.1 327.37,40.78 328.6,40.78 329.83,42.01 329.83,45.24 v1(330.21,45.63)
  IN3 w0.091: v1(128.91,151.1) 130.28,152.46 134.57,152.46 137.01,154.9 137.01,155.82 138.38,157.19 138.38,159.16 138.94,159.73 143.36,159.73 145.2,161.57 145.2,162.85 144.93,163.13 144.93,167.17 148.63,170.87 148.63,172.72 v1(149.55,173.64)
  BOTTOM w0.107: UM7.1 149.61,173.7 v1(149.55,173.64)
CDRA_LED RED: length 21.3
  IN4 w0.097: v1(155.79,162.76) 156.5,162.76 157.36,163.62 157.36,165.16 160.57,168.37 160.57,168.47 161.39,169.29 161.39,170.53 161.27,170.65 161.27,172.44 161.49,172.66 161.91,172.66 163.64,174.39 163.64,175.91 163.5,176.05 v1(163.5,176.45)
  BOTTOM w0.107: v1(163.5,176.45) 163.5,176.68 163.42,176.75 JCDRA.28 ; v1(155.79,162.76) 154.65,162.76 154.19,163.23 QM3.1
CDRA_LED RED_MOS: length 289
  TOP w0.107: UE5.126 305.92,21.41 v1(304.73,20.23)
  IN2 w0.091: v1(306.46,28.47) 303.17,28.47 300.32,31.32 293.97,31.32 287.81,37.47 286.06,37.47 284.67,38.86 273.71,38.86 271.59,40.98 271.59,42.72 266.72,47.6 227.07,47.6 225.95,48.71 215.69,48.71 212.23,52.18 212.23,53.27 211.08,54.41 211.08,55.56 208.75,57.89 208.75,59.91 206.93,61.72 197.64,61.72 189.27,70.09 188.59,70.09 187.68,70.99 187.68,72.62 187.31,72.99 187.31,92.81 185.26,94.85 185.26,98.98 183.29,100.96 183.29,110.47 184.56,111.74 184.56,122 190.61,128.04 190.61,143.91 186.06,148.46 169.47,148.46 168.46,149.47 168.05,149.47 167.07,150.45 167.07,151.57 163.41,155.23 163.41,155.59 163.41,160.53 161.97,161.97 159.79,161.97 159.24,161.42 158.89,161.42 158.34,160.87 v1(158.34,160.28)
  IN3 w0.091: v1(148.92,165.32) 148.98,165.39 153.85,165.39 154.5,164.74 156.92,164.74 157.11,164.55 157.11,162.6 158.34,161.37 v1(158.34,160.28)
  BOTTOM w0.107: v1(304.73,20.23) 303.98,20.97 303.98,23.08 305.51,24.61 305.51,27.51 v1(306.46,28.47) ; QM2.5 149.36,165.77 v1(148.92,165.32)
CDRA_LED RED_R: length 4.5
  BOTTOM w0.107: QM3.3 155.15,165.34 154.69,164.88 154.06,164.88 152.87,163.68 RM93.2
CDRA_LED WHITE: length 31.2
  BOTTOM w0.107: JCDRA.27 163.02,178.6 162.82,178.79 150.87,178.79 148.87,176.79 148.87,173.75 149.13,173.49 149.13,169.61 v2(148.66,169.14) 146.41,166.88 145.21,166.88 144.73,166.4 144.73,165.34 144.38,164.99 QM1.1
CDRA_LED WHITE_MOS: length 274.2
  TOP w0.107: UE5.21 297.54,24.96 297.73,25.15 297.73,27.81 v2(297.63,27.91) 297.47,28.07 295.89,28.07 295.02,28.94 295.02,29.76 294.07,30.71 v1(294.07,31.78)
  IN2 w0.091: v1(158.2,162.08) 158.64,161.64 159.15,161.64 159.7,162.19 162.06,162.19 163.63,160.62 163.63,155.5 163.63,155.32 167.28,151.66 167.28,150.55 168.14,149.69 168.55,149.69 169.56,148.68 186.15,148.68 190.85,143.98 190.85,127.98 184.78,121.91 184.78,111.65 183.51,110.38 183.51,101.05 185.48,99.07 185.48,94.94 187.53,92.9 187.53,73.08 187.9,72.71 187.9,71.09 188.68,70.31 189.36,70.31 197.73,61.94 207.02,61.94 208.96,60 208.96,57.98 211.3,55.65 211.3,54.5 212.45,53.36 212.45,52.27 215.78,48.93 226.05,48.93 227.16,47.81 266.81,47.81 271.81,42.81 271.81,41.07 273.8,39.08 284.76,39.08 286.15,37.69 287.9,37.69 293.81,31.78 v1(294.07,31.78)
  IN3 w0.091: v1(149.93,168.5) 149.93,168.47 151.9,166.5 153.04,166.5 154.59,164.96 157.01,164.96 157.33,164.64 157.33,162.95 v1(158.2,162.08)
  BOTTOM w0.107: QM2.2 151.08,165.77 150.82,166.02 150.82,166.97 149.93,167.86 v1(149.93,168.5)
CDRA_LED WHITE_R: length 5.4
  BOTTOM w0.107: RM91.2 147.18,164.03 QM1.3 145.6,164.03 144.7,163.13 142.93,163.13 v2(142.78,163.28)
CDRA_RST#: length 3.7
  BOTTOM w0.107: JCDRA.22 161.02,175.87 v2(160.65,175.5) 159.82,174.67 UM3.4
CFG0: length 72.8
  TOP w0.107: v1(123.2,157.83) 123.2,157.66 JPCMC.1
  IN1 w0.097: v1(134.63,111.45) 134.63,111.4 133.79,110.56 133.22,110.56 132.72,110.07 132.72,108.54 131.66,107.47 130.31,107.47 129.55,108.22 129.55,112.24 127.86,113.93 127.86,120.74 127.11,121.49 127.11,122.81 126.71,123.21 126.71,124.53 124.94,126.3 118.74,126.3 115.47,129.57 115.47,148.92 117.87,151.32 117.99,151.32 118.69,152.02 120.91,152.02 122.3,153.41 122.3,156.74 123.2,157.64 v1(123.2,157.83)
  BOTTOM w0.076: v1(134.63,111.45) 134.31,111.13 CPU1.BN25
CFG1: length 59.5
  TOP w0.107: JPCMC.3 122.99,156.47 123.65,156.47 124.59,155.54 124.59,151.53 124.5,151.45 v1(124.5,151.1) 124.5,151 v2(124.98,150.53)
  IN1 w0.097: v1(134.63,112.24) 135.14,112.24 135.84,112.94 135.84,113.95 135.58,114.21 135.2,114.21 132.71,116.69 132.71,119.55 132.17,120.09 132.17,123.41 130.6,124.98 130.6,126.32 126.58,130.33 122.75,130.33 120.7,132.39 119.68,132.39 119.35,132.73 119.35,144.21 120.92,145.79 120.92,147.43 124.5,151.01 v1(124.5,151.1)
  BOTTOM w0.089: v1(134.63,112.24) 134.31,112.56 CPU1.BN27
CFG2: length 59.8
  TOP w0.089: v1(133.98,111.45) 133.77,111.66 RH184.1
  TOP w0.107: JPCMC.5 122.81,155.5 v1(123.21,155.11)
  IN1 w0.097: v1(133.98,111.45) 131.45,111.45 131.35,111.55 131.35,112.57 130.69,113.23 130.69,114.08 129.81,114.96 129.81,121.63 129.12,122.32 129.12,123.71 128.71,124.11 128.71,125.36 125.77,128.3 120.65,128.3 117.47,131.48 117.47,147.21 120.65,150.39 121.03,150.39 121.49,150.84 121.99,150.84 122.27,151.12 122.27,152.19 123.21,153.13 v1(123.21,155.11)
  BOTTOM w0.076: CPU1.BN26 134.31,111.78 v1(133.98,111.45)
CFG3: length 73.1
  TOP w0.107: JPCMC.7 122.42,154.68 122.75,154.35 122.75,152.81 121.2,151.26 121.2,149.85 121.47,149.59 v1(121.47,148.91) 121.44,148.91 121.4,148.87 118.59,148.87 117.02,150.44 115.87,150.44 114.94,149.51 114.25,149.51 113.74,150.02 113.74,156.18 115.38,157.82 JPCMC.23
  IN1 w0.097: v1(121.47,148.91) 121.47,148.87 120.48,147.88 120.48,145.91 118.95,144.38 118.95,132.09 121.1,129.93 126.42,129.93 130.2,126.15 130.2,124.82 131.77,123.25 131.77,119.6 132.53,118.84 132.53,115.67 134.63,113.57 v1(134.63,113.03)
  BOTTOM w0.089: CPU1.BN28 134.31,113.35 v1(134.63,113.03)
CFG4: length 67.6
  TOP w0.107: v1(121.9,153.57) 121.9,154.04 JPCMC.9
  IN1 w0.097: v1(121.9,153.57) 120.74,152.42 117.85,152.42 117.48,152.05 117.48,151.51 115.06,149.09 115.06,129.4 118.57,125.89 124.77,125.89 126.3,124.36 126.3,123.05 126.71,122.64 126.71,121.32 127.02,121.01 127.46,120.57 127.46,113.76 129.37,111.86 129.37,108.15 130.23,107.28 130.71,107.28 131.2,106.8 131.2,106.39 v1(130.95,106.14)
  BOTTOM w0.076: CPU1.BR20 133.01,106.84 132.91,106.75 132.2,106.75 132.01,106.94 131.37,106.94 131.2,106.77 131.2,106.39 v1(130.95,106.14) 130.57,106.14 129.87,105.44 RH185.1
CFG5: length 89.8
  TOP w0.089: v1(134.63,106.73) 134.63,107.03 v2(134.82,107.22)
  TOP w0.107: RH186.1 134.63,106.11 v1(134.63,106.73) ; JPCMC.11 121.07,152.87 120.62,152.42 119.82,152.42 119.67,152.27 119.67,151.27 119.12,150.72 117.9,150.72 117.36,151.26 114.62,151.26 v1(114.26,150.9)
  IN4 w0.097: v1(114.26,150.9) 114.72,150.45 114.72,100.21 118.29,96.64 126.46,96.64 128.83,99 128.83,99.77 130.12,101.06 130.12,102.58 130.87,103.34 132.4,103.34 134.63,105.57 v1(134.63,106.73)
  BOTTOM w0.076: CPU1.BM20 134.96,107.05 v1(134.63,106.73)
CFG6: length 64.1
  TOP w0.107: v1(120.04,152.82) 120.22,153 JPCMC.13
  IN1 w0.097: v1(120.04,152.82) 117.69,152.82 117.08,152.22 117.08,151.67 114.66,149.25 114.66,129.23 118.4,125.49 124.61,125.49 125.9,124.2 125.9,121.56 127.06,120.41 127.06,113.6 128.97,111.69 128.97,107.98 130.07,106.88 130.59,106.88 v1(130.76,106.71)
  BOTTOM w0.076: RH187.1 130.41,106.37 v1(130.76,106.71) 130.76,107.15 130.83,107.23 v2(130.88,107.23) 131,107.23 131.11,107.12 CPU1.BT20
CFG7: length 61.3
  TOP w0.107: v1(118.84,151.59) 118.84,152.79 119.32,153.28 JPCMC.15
  IN1 w0.097: v1(118.84,151.59) 118.84,150.85 115.87,147.88 115.87,129.73 118.9,126.7 125.11,126.7 127.11,124.7 127.11,123.38 127.51,122.97 127.51,121.66 128.8,120.37 128.8,113.56 129.74,112.62 129.74,109.12 v1(130.95,107.91)
  BOTTOM w0.076: CPU1.BP20 133.36,107.42 133.13,107.42 132.93,107.62 132.1,107.62 131.98,107.49 131.37,107.49 v1(130.95,107.91) 130.43,107.91 129.87,107.35 RH188.1
CFG8: length 64
  TOP w0.107: v1(123.52,157.19) 123.2,156.88 122.62,156.88 JPCMC.2
  IN1 w0.097: v1(130.88,109.32) 130.18,110.01 130.18,113.63 129.44,114.37 129.44,120.86 128.32,121.99 128.32,123.38 127.91,123.78 127.91,125.03 125.44,127.5 119.23,127.5 116.67,130.06 116.67,147.55 120.31,151.19 120.7,151.19 122.7,153.19 122.7,156.38 v1(123.52,157.19)
  BOTTOM w0.076: v1(130.88,109.32) 131.45,109.88 132.61,109.88 CPU1.BR23
CFG9: length 88.1
  TOP w0.107: JPCMC.4 122.83,156.07 123.62,155.28 123.62,151.43 123.08,150.9 123.08,149.84 121.7,148.46 118.42,148.46 118.38,148.5 118.15,148.5 v1(116.88,149.77)
  IN4 w0.097: v1(133.32,108.34) 133.28,108.34 132.62,107.68 132.62,105.08 131.61,104.08 129.83,104.08 129.61,103.86 129.43,103.86 127.93,102.36 127.93,101.85 124.32,98.24 118.95,98.24 116.32,100.87 116.32,149.2 v1(116.88,149.77)
  BOTTOM w0.089: CPU1.BR22 133.01,108.66 v1(133.32,108.34)
CFG10: length 59.9
  TOP w0.107: v1(121.78,151.25) 123.17,152.64 123.17,154.54 122.4,155.31 JPCMC.6
  IN1 w0.097: v1(131.45,109.38) 131.45,109.82 131.16,110.11 131.16,112.49 130.51,113.15 130.51,113.76 129.63,114.63 129.63,121.24 128.72,122.16 128.72,123.54 128.31,123.95 128.31,125.2 125.61,127.9 119.4,127.9 117.07,130.23 117.07,147.38 120.48,150.79 120.87,150.79 121.33,151.25 v1(121.78,151.25)
  BOTTOM w0.076: v1(131.45,109.38) 131.56,109.49 CPU1.BT23
CFG11: length 60.4
  TOP w0.107: JPCMC.8 121.88,154.63 122.31,154.21 122.31,152.94 120.96,151.59 v1(120.53,151.59)
  IN1 w0.097: v1(131.44,108.53) 131.03,108.93 130.75,108.93 130,109.68 130,112.93 129.2,113.73 129.2,120.54 127.91,121.82 127.91,123.21 127.51,123.62 127.51,124.86 125.27,127.1 119.07,127.1 116.27,129.9 116.27,147.71 120.15,151.59 v1(120.53,151.59)
  BOTTOM w0.089: v1(131.44,108.53) 132.18,108.53 CPU1.BT22
CFG12: length 90.3
  TOP w0.107: JPCMC.10 121.28,153.98 121.48,153.78 121.48,152.7 120.79,152 120.23,152 120.08,151.86 120.08,151.1 119.29,150.3 117.74,150.3 117.19,150.85 114.9,150.85 v1(114.26,150.21)
  IN4 w0.097: v1(114.26,150.21) 114.26,100.09 118.12,96.23 126.63,96.23 129.23,98.84 129.23,99.6 130.44,100.81 130.44,102.58 131,103.15 132.59,103.15 135.28,105.84 v1(135.28,106.73)
  BOTTOM w0.076: CPU1.BM19 134.96,106.41 v1(135.28,106.73)
CFG13: length 66.5
  TOP w0.107: JPCMC.12 120.63,153.75 120.63,153.08 v1(120.66,153.04)
  IN1 w0.097: v1(120.66,153.04) 120.26,153.45 117.75,153.45 116.68,152.38 116.68,151.84 114.26,149.42 114.26,129.07 118.24,125.09 124.44,125.09 125.5,124.03 125.5,121.4 126.66,120.24 126.66,113.43 128.57,111.52 128.57,107.69 130.71,105.55 v1(130.95,105.55)
  BOTTOM w0.076: v1(130.95,105.55) 131.34,105.94 132,105.94 132.1,105.84 132.63,105.84 133.01,106.21 CPU1.BR19
CFG14: length 85
  TOP w0.107: v1(114.36,151.67) 117.67,151.67 118.18,151.16 118.99,151.16 119.26,151.44 119.26,152.63 119.77,153.14 JPCMC.14
  IN4 w0.097: v1(114.36,151.67) 115.12,150.91 115.12,100.37 118.45,97.04 125.02,97.04 129.74,101.76 129.74,102.47 130.8,103.52 132.14,103.52 133.35,104.74 v1(133.35,106.69)
  BOTTOM w0.076: v1(133.35,106.69) 133.66,106.39 CPU1.BP19
CFG15: length 73.3
  TOP w0.107: JPCMC.16 118.91,153.75 118.91,153.45 118.69,153.23 118.51,153.23 118.09,152.81 v1(118.09,151.99)
  IN4 w0.097: v1(131.63,106.56) 131.89,106.3 131.89,105.31 131.7,105.12 128.85,105.12 123.18,99.45 119.45,99.45 117.52,101.37 117.52,119.22 117.99,119.69 117.99,121.23 117.52,121.7 117.52,147.77 118.09,148.34 v1(118.09,151.99)
  BOTTOM w0.089: v1(131.63,106.56) 131.87,106.56 132.09,106.34 CPU1.BT19
CFG16: length 80.4
  TOP w0.107: v1(115.58,154.21) 116.14,154.77 JPCMC.21
  IN4 w0.097: v1(133.33,109.88) 132.25,108.79 132.25,105.34 131.58,104.68 128.98,104.68 123.34,99.04 119.28,99.04 117.12,101.2 117.12,147.94 117.69,148.5 117.69,152.74 116.21,154.21 v1(115.58,154.21)
  BOTTOM w0.076: v1(133.33,109.88) 133.66,109.55 CPU1.BP23
CFG17: length 80.1
  TOP w0.107: v1(116.66,152.94) 116.78,153.05 117.75,153.05 118.34,153.64 JPCMC.17
  IN4 w0.097: v1(116.66,152.94) 117.29,152.32 117.29,148.67 116.72,148.11 116.72,101.04 119.12,98.64 124.16,98.64 127.53,102.01 127.53,102.6 129.2,104.26 131.48,104.26 132.43,105.21 132.43,108.31 133.98,109.86 v1(133.98,109.88)
  BOTTOM w0.076: v1(133.98,109.88) 134.31,109.55 CPU1.BN23
CFG18: length 83.5
  TOP w0.089: v2(135.12,108.92) 134.68,108.48 v1(134.68,108.3)
  TOP w0.107: v1(115.58,153.58) 116.36,154.36 117.36,154.36 JPCMC.20
  IN4 w0.097: v1(115.58,153.58) 115.52,153.51 115.52,100.54 118.62,97.44 124.66,97.44 128.73,101.51 128.73,102.02 130.42,103.71 131.88,103.71 132.99,104.82 132.99,107 133.85,107.86 134.24,107.86 v1(134.68,108.3)
  BOTTOM w0.076: v1(134.68,108.3) 134.68,108.32 CPU1.BN22
CFG19: length 81
  TOP w0.107: JPCMC.18 118.26,154.14 117.58,153.46 116.39,153.46 v1(116.28,153.58)
  IN4 w0.097: v1(133.96,108.34) 132.8,107.18 132.8,104.95 131.75,103.89 130.03,103.89 129.84,103.71 129.84,103.7 129.61,103.46 129.6,103.46 128.33,102.19 128.33,101.68 124.49,97.84 118.78,97.84 115.92,100.7 115.92,153.22 v1(116.28,153.58)
  BOTTOM w0.076: CPU1.BP22 133.66,108.63 v1(133.96,108.34)
CFG_RCOMP: length 3.1
  BOTTOM w0.076: CPU1.BT25 132.35,111.07 131.68,111.07 130.09,109.48 RH59.1
CHG_B+:
  vias: v1(62.37,29.5) v1(62.37,28.86) v1(62.87,29.81) v1(62.87,29.18) v1(62.87,28.54) v1(63.51,29.81) v1(63.51,29.18) v1(63.51,28.54) v1(64.14,29.81) v1(64.14,29.18) v1(64.14,28.54) v1(64.78,29.81) v1(64.78,29.18) v1(64.78,28.54) v2(68.59,30.13)
CLK_PCI_LPC: length 103.9
  TOP w0.099: v1(300.64,20.64) 301.3,21.3 301.3,22.62 301.14,22.79 UE5.12 301.14,24.91 RE89.2
  IN3 w0.099: v1(222.91,26.97) 223.74,26.97 224.5,26.22 224.5,21.87 225.56,20.81 227.95,20.81 228.6,20.16 230.1,20.16 230.42,20.48 231.47,20.48 232.96,18.99 241.13,18.99 241.93,18.19 246.02,18.19 246.27,18.45 249.89,18.45 251.39,19.95 252.78,19.95 253.18,20.35 253.18,21.5 254.22,22.54 257.99,22.54 259.51,24.06 263.17,24.06 266.34,27.22 279.37,27.22 280.65,25.94 285.65,25.94 286.7,24.88 287.01,24.88 289.14,22.76 300.18,22.76 301.06,21.88 301.06,21.06 v1(300.64,20.64)
  BOTTOM w0.099: RH89.1 220.95,29.49 221.93,29.49 221.96,29.52 222.81,29.52 223.08,29.25 223.08,27.15 v1(222.91,26.97)
CLK_PCIE_DGPU#_C: length 25
  IN4 w0.097: v1(159.52,160.37) 159.72,160.57 160.07,160.57 160.27,160.76 160.27,163.34 159.5,164.1 159.5,166.02 162.25,168.77 162.25,171.87 165.41,175.03 165.41,175.38 v1(165.68,175.65)
  BOTTOM w0.099: JCDRA.34 165.82,176.85 165.68,176.71 165.68,176.3 165.48,176.09 165.48,175.85 v1(165.68,175.65) ; v1(159.52,160.37) 159.71,160.56 160.2,160.56 160.41,160.77 160.41,161.07 161.61,162.27 161.79,162.27 CM99.2
CLK_PCIE_DGPU_C: length 24.7
  IN4 w0.097: v1(159.52,161) 159.79,160.74 160,160.74 160.09,160.84 160.09,163.26 159.33,164.03 159.33,166.09 162.08,168.84 162.08,171.94 165.24,175.1 165.24,175.51 v1(165.09,175.65)
  BOTTOM w0.099: JCDRA.33 165.42,176.82 165.49,176.76 165.49,176.38 165.28,176.17 165.28,175.84 v1(165.09,175.65) ; CM98.2 161.8,162.47 161.53,162.47 160.22,161.15 160.22,160.85 160.12,160.75 159.77,160.75 v1(159.52,161)
CLK_PCIE_N1: length 156.5
  IN1 w0.097: v1(323.49,34.17) 323.73,34.41 323.73,34.64 323.6,34.77 321.56,34.77 320.06,33.26 291.7,33.26 288.05,29.61 279.51,29.61 279.28,29.84 275.42,29.84 274.73,29.14 270.18,29.14 269.46,28.42 264.25,28.42 260.4,24.57 257.59,24.57 255.61,22.59 253.33,22.59 250.39,19.66 244.99,19.66 244.46,20.19 242.86,20.19 242.33,19.66 237.11,19.66 235.78,18.33 232.87,18.33 232.63,18.08 229.79,18.08 228.81,17.11 228,17.11 226.57,15.68 217.16,15.68 216.54,16.31 214.71,16.31 214.07,15.67 212.78,15.67 211.71,16.74 208.38,16.74 207.97,17.15 207.97,17.69 207.78,17.88 206.91,17.88 204.8,19.99 204.8,23.19 202.19,25.79 202.19,28.54 200.69,30.05 200.69,31.38 200.35,31.72 200.35,32.67 201.58,33.9 201.58,36.54 200.75,37.36 199.76,37.36 199.64,37.23 199.64,36.93 199.45,36.75 199.24,36.75 v1(199.03,36.54)
  BOTTOM w0.089: v1(199.03,36.54) 199.25,36.76 UH1.L7
  BOTTOM w0.099: JSSD1.53 324.92,35.11 324.77,34.95 323.9,34.95 323.69,34.74 323.69,34.37 v1(323.49,34.17)
CLK_PCIE_N2: length 117.6
  IN3 w0.099: v1(273.5,24.17) 273.69,24.37 273.69,24.53 273.59,24.63 269.78,24.63 268.8,23.65 268.8,22.55 268.1,21.84 266.83,21.84 265.79,20.8 265.19,20.8 264.83,20.45 259.84,20.45 257.08,17.68 253.71,17.68 251.77,15.75 246.79,15.75 246.62,15.92 241.37,15.92 240.89,15.44 239.93,15.44 239.86,15.37 238.05,15.37 236.87,16.55 223.52,16.55 222.77,17.3 218.32,17.3 217.31,18.32 216.85,18.32 216.85,18.32 216.42,18.32 215.8,17.71 212.95,17.71 212.73,17.49 212.73,17.09 212.45,16.81 209.6,16.81 207.99,18.41 206.03,18.41 205.88,18.26 204.14,18.26 203.4,18.99 203.4,20.08 202.12,21.37 201.3,21.37 200.34,22.32 200.34,26.42 199.65,27.1 199.65,31.5 199.46,31.69 199.46,35.01 199.26,35.21 198.72,35.21 198.41,35.52 198.41,37.78 197.99,38.2 197.41,38.2 v1(197.3,38.09)
  BOTTOM w0.089: UH1.D3 196.71,38.46 197.08,38.09 v1(197.3,38.09)
  BOTTOM w0.099: JSSD2.53 272.69,11.25 272.93,11.02 273.3,11.02 273.69,11.42 273.69,23.98 v1(273.5,24.17)
CLK_PCIE_N3: length 154
  TOP w0.094: UT1.T19 v1(184.55,163.16)
  IN1 w0.097: v1(184.55,163.16) 184.88,162.83 184.96,162.83 185.03,162.76 186.45,162.76 188.56,160.66 189.89,160.66 190.58,159.97 191.91,159.97 193.22,158.66 193.22,156.89 194.25,155.86 194.25,152.49 194.73,152.01 194.73,150.88 197.03,148.58 197.03,124.06 197.5,123.59 197.5,113.63 201.84,109.28 201.84,107.5 206.44,102.89 206.44,101.4 210.13,97.71 210.13,91.66 210.25,91.54 210.37,91.54 v1(210.64,91.8)
  IN3 w0.099: v1(197.96,36.8) 197.16,36.8 196.74,37.22 196.74,38.15 196.67,38.22 196.67,40.77 196.82,40.92 196.82,47.57 192.58,51.81 192.58,52.47 191.46,53.59 191.46,63.16 191.88,63.58 191.88,69.41 197.88,75.41 197.88,77.46 208.67,88.26 208.67,90.66 209.82,91.8 v1(210.64,91.8)
  BOTTOM w0.089: v1(197.96,36.8) 197.84,36.92 197.31,36.92 197.07,37.16 197.07,37.43 197.07,37.43 UH1.E5
CLK_PCIE_N4: length 160.4
  IN3 w0.099: v1(227.08,149.99) 226.86,149.77 226.86,149.41 224.92,147.47 203.68,147.47 199.13,142.92 199.13,115.17 203.82,110.48 203.82,103.96 208.1,99.68 208.1,92.11 202.13,86.14 201.42,86.14 199.08,83.8 199.08,79.4 191.4,71.72 191.4,63.78 190.98,63.36 190.98,52.95 192.1,51.83 192.1,51.47 196.33,47.23 196.33,41.02 195.58,40.27 195.58,38.14 195.91,37.81 196.19,37.81 v1(196.38,38)
  BOTTOM w0.099: UH1.D5 196.08,37.6 196.34,37.6 196.49,37.76 196.49,37.88 v1(196.38,38) ; UL1.32 232.91,152.02 232.82,152.11 232.81,152.11 232.8,152.12 231.46,152.12 231.34,152.24 v3(227.97,152.24) 227.34,152.24 226.89,151.79 226.89,150.19 v1(227.08,149.99)
CLK_PCIE_N5: length 135.5
  IN4 w0.097: v1(312.82,35.35) 312.62,35.55 312.37,35.55 312.16,35.33 312.16,34.69 310.72,33.26 288.9,33.26 287.17,31.53 280.11,31.53 279.51,32.12 275.4,32.12 274.98,32.54 265,32.54 262.84,34.7 234.46,34.7 232.82,36.35 232.82,36.64 229.03,40.43 229.03,41.53 227.16,43.4 224.4,43.4 223.58,42.58 219.72,42.58 218.89,43.4 214.61,43.4 214.16,43.85 211.4,43.85 211.2,44.04 207.43,44.04 207.07,43.68 203.23,43.68 202.35,42.8 198.24,42.8 195.32,39.87 195.32,37.18 195.61,36.89 196.09,36.89 v1(196.55,36.42)
  BOTTOM w0.089: v1(196.55,36.42) 196.34,36.21 UH1.D8
  BOTTOM w0.099: v1(312.82,35.35) 312.64,35.53 312.31,35.53 312.17,35.39 312.17,34.65 312.32,34.5 JWLAN.41
CLK_PCIE_N6: length 170.2
  IN1 w0.097: v1(191.69,104.83) 191.89,104.63 191.89,94.54 192.1,94.34 192.1,86.35 191.09,85.34 191.09,78.3 193.04,76.34 193.04,72.34 191.08,70.38 191.08,64.25 189.68,62.85 189.68,54.02 188.85,53.2 188.85,48.53 189.02,48.37 189.02,43.46 192.02,40.47 192.02,35.17 192.18,35.01 192.18,34.23 192.72,33.69 193.17,33.69 193.37,33.9 194.58,33.9 195.53,34.85 197.5,34.85 197.88,35.23 200.3,35.23 200.59,35.52 200.59,35.89 200.69,35.99 200.83,35.99 v1(200.99,35.82)
  BOTTOM w0.089: v1(200.99,35.82) 201.16,35.99 UH1.R8
  BOTTOM w0.099: UM4.3 169.89,154.73 170.06,154.91 170.06,155.04 170.27,155.25 171.73,155.25 172.29,154.69 172.29,151.12 173.32,150.09 179.03,150.09 180.17,148.94 187.41,148.94 190.77,145.59 190.77,138.33 197.75,131.35 197.75,119.79 202.82,114.72 202.82,110.25 199.48,106.91 194.71,106.91 193.24,105.44 191.42,105.44 191.14,105.17 191.14,104.45 191.35,104.24 191.74,104.24 191.84,104.33 191.84,104.68 v1(191.69,104.83)
CLK_PCIE_N7: length 61.9
  IN4 w0.097: v1(203.08,37.47) 203.08,37.45 203.33,37.2 203.49,37.2 203.58,37.29 203.58,38.62 204.4,39.44 207.02,39.44 207.12,39.54 210.79,39.54 211.69,40.45 214.62,40.45 214.68,40.51 215.95,40.51 216.48,39.98 218.06,39.98 218.81,39.23 219.35,39.23 220.02,39.9 223.25,39.9 223.45,39.7 224.02,39.7 224.82,38.89 225.67,38.89 230.39,34.17 230.39,28.66 232.23,26.82 232.23,25.37 235.42,22.18 239.06,22.18 239.58,21.66 239.58,21.33 v1(239.73,21.18)
  BOTTOM w0.099: v1(239.73,21.18) 239.53,20.98 239.53,19.04 241.68,16.89 241.68,15.44 240.87,14.63 240.87,14 241.02,13.85 JSSD3.53 ; v1(203.08,37.47) 203.05,37.45 202.71,37.45 UH1.U5
CLK_PCIE_P1: length 156.7
  IN1 w0.097: v1(324.07,34.17) 323.9,34.34 323.9,34.71 323.68,34.94 321.49,34.94 319.99,33.43 291.63,33.43 287.98,29.79 279.58,29.79 279.35,30.01 275.35,30.01 274.65,29.31 270.11,29.31 269.39,28.59 264.18,28.59 260.33,24.74 257.52,24.74 255.54,22.77 253.26,22.77 250.32,19.83 245.06,19.83 244.53,20.36 242.79,20.36 242.26,19.83 237.04,19.83 235.71,18.5 232.8,18.5 232.56,18.26 229.71,18.26 228.74,17.28 227.93,17.28 226.5,15.85 217.23,15.85 216.61,16.48 214.64,16.48 214,15.84 212.85,15.84 211.78,16.91 208.45,16.91 208.14,17.22 208.14,17.76 207.85,18.05 206.98,18.05 204.97,20.06 204.97,23.26 202.37,25.86 202.37,28.62 200.86,30.12 200.86,31.45 200.52,31.79 200.52,32.6 201.75,33.82 201.75,36.61 200.82,37.54 199.69,37.54 199.46,37.31 199.46,37.01 199.38,36.93 199.21,36.93 v1(199.03,37.11)
  BOTTOM w0.089: UH1.L5 199.5,37.26 199.35,37.11 v1(199.03,37.11)
  BOTTOM w0.099: v1(324.07,34.17) 323.88,34.37 323.88,34.66 323.98,34.76 324.77,34.76 324.92,34.61 JSSD1.55
CLK_PCIE_P2: length 117.8
  IN3 w0.099: v1(197.25,38.67) 197.34,38.67 197.63,38.38 198.07,38.38 198.59,37.86 198.59,35.6 198.79,35.4 199.34,35.4 199.65,35.09 199.65,31.77 199.84,31.58 199.84,27.18 200.53,26.49 200.53,22.4 201.37,21.55 202.2,21.55 203.59,20.16 203.59,19.07 204.21,18.45 205.8,18.45 205.95,18.59 208.07,18.59 209.67,16.99 212.37,16.99 212.55,17.17 212.55,17.57 212.87,17.89 215.73,17.89 216.34,18.51 216.77,18.51 217.38,18.51 218.4,17.49 222.85,17.49 223.6,16.73 236.95,16.73 238.13,15.56 239.79,15.56 239.85,15.62 240.81,15.62 241.29,16.11 246.7,16.11 246.87,15.94 251.7,15.94 253.63,17.87 257,17.87 259.77,20.63 264.76,20.63 265.11,20.99 265.71,20.99 266.75,22.03 268.02,22.03 268.62,22.63 268.62,23.73 269.71,24.82 273.67,24.82 273.87,24.61 273.87,24.38 v1(274.08,24.17)
  BOTTOM w0.089: UH1.F2 196.87,38.69 196.96,38.6 197.18,38.6 v1(197.25,38.67)
  BOTTOM w0.099: v1(274.08,24.17) 273.89,23.98 273.89,11.34 273.38,10.83 272.82,10.83 272.81,10.83 272.74,10.83 272.67,10.76 JSSD2.55
CLK_PCIE_P3: length 154
  TOP w0.089: UT1.V19 184.23,162.43
  TOP w0.094: v1(184.55,162.51) 184.31,162.51 184.23,162.43
  IN1 w0.097: v1(210.64,91.22) 210.49,91.37 210.18,91.37 209.96,91.59 209.96,97.64 206.27,101.32 206.27,102.82 201.66,107.43 201.66,109.21 197.32,113.55 197.32,123.52 196.86,123.98 196.86,148.51 194.56,150.81 194.56,151.94 194.08,152.42 194.08,155.78 193.05,156.81 193.05,158.59 191.84,159.8 190.51,159.8 189.82,160.49 188.49,160.49 186.38,162.59 184.96,162.59 184.89,162.66 184.7,162.66 v1(184.55,162.51)
  IN3 w0.099: v1(210.64,91.22) 210.24,91.62 209.9,91.62 208.86,90.58 208.86,88.18 198.07,77.39 198.07,75.33 192.07,69.33 192.07,63.5 191.64,63.08 191.64,53.66 192.76,52.54 192.76,51.89 197.01,47.65 197.01,40.84 196.86,40.7 196.86,38.3 196.93,38.23 196.93,37.3 197.24,36.99 197.61,36.99 v1(198.01,37.38)
  BOTTOM w0.089: v1(198.01,37.38) 198.01,37.38 197.97,37.38 197.7,37.11 197.39,37.11 197.26,37.24 197.26,37.5 197.6,37.84 UH1.G4
CLK_PCIE_P4: length 160.8
  IN3 w0.099: v1(226.5,149.99) 226.67,149.82 226.67,149.49 224.84,147.66 203.61,147.66 198.95,143 198.95,115.09 203.64,110.4 203.64,103.88 207.91,99.61 207.91,92.18 202.06,86.33 201.34,86.33 198.9,83.88 198.9,79.48 191.22,71.79 191.22,63.85 190.79,63.43 190.79,52.88 191.91,51.76 191.91,51.39 196.15,47.15 196.15,41.1 195.39,40.34 195.39,38.07 195.83,37.62 196.16,37.62 196.35,37.43 v1(196.35,37.24)
  BOTTOM w0.099: UL1.33 232.91,152.42 232.8,152.31 231.54,152.31 231.42,152.44 228.35,152.44 228.33,152.47 227.62,152.47 227.59,152.44 227.26,152.44 226.69,151.87 226.69,150.19 v1(226.5,149.99) ; v1(196.35,37.24) 196.76,37.24 UH1.E6
CLK_PCIE_P5: length 136.3
  IN4 w0.097: v1(195.96,36.3) 196.08,36.3 196.19,36.41 196.19,36.55 196.02,36.71 195.54,36.71 195.14,37.11 195.14,39.95 198.17,42.97 202.28,42.97 203.16,43.85 207,43.85 207.36,44.22 211.28,44.22 211.47,44.02 214.23,44.02 214.68,43.58 218.97,43.58 219.79,42.75 223.51,42.75 224.33,43.58 227.23,43.58 229.21,41.6 229.21,40.5 232.99,36.71 232.99,36.42 234.53,34.88 262.91,34.88 265.07,32.71 275.05,32.71 275.47,32.3 279.58,32.3 280.18,31.7 287.1,31.7 288.83,33.43 310.65,33.43 311.98,34.77 311.98,35.4 312.3,35.72 312.61,35.72 v1(312.82,35.93)
  BOTTOM w0.089: UH1.D7 196.14,36.47
  BOTTOM w0.099: 196.14,36.47 v1(195.96,36.3) ; v1(312.82,35.93) 312.61,35.72 312.23,35.72 311.98,35.47 311.98,34.65 311.82,34.5 JWLAN.39
CLK_PCIE_P6: length 170.1
  IN1 w0.097: v1(201.06,36.39) 200.83,36.16 200.62,36.16 200.41,35.96 200.41,35.59 200.22,35.4 197.81,35.4 197.43,35.02 195.46,35.02 194.51,34.07 193.3,34.07 193.09,33.86 192.79,33.86 192.35,34.3 192.35,35.08 192.19,35.25 192.19,40.54 189.19,43.54 189.19,48.44 189.02,48.61 189.02,53.12 189.85,53.95 189.85,62.78 191.25,64.18 191.25,70.31 193.22,72.27 193.22,76.42 191.26,78.37 191.26,85.27 192.27,86.28 192.27,94.41 192.07,94.61 192.07,104.63 v1(192.27,104.83)
  BOTTOM w0.089: v1(201.06,36.39) 201.42,36.75 UH1.R7
  BOTTOM w0.099: v1(192.27,104.83) 192.03,104.59 192.03,104.25 191.82,104.04 191.27,104.04 190.95,104.37 190.95,105.25 191.34,105.64 193.16,105.64 194.63,107.1 199.4,107.1 202.63,110.33 202.63,114.64 197.55,119.71 197.55,131.27 190.57,138.25 190.57,145.51 187.33,148.75 180.09,148.75 178.95,149.89 173.24,149.89 172.09,151.04 172.09,154.61 171.65,155.06 170.35,155.06 170.25,154.96 170.25,154.84 170.54,154.56 UM4.2
CLK_PCIE_P7: length 61.6
  IN4 w0.097: v1(203.08,36.9) 203.2,37.02 203.56,37.02 203.75,37.22 203.75,38.55 204.47,39.27 207.09,39.27 207.19,39.37 210.86,39.37 211.77,40.28 214.69,40.28 214.75,40.33 215.88,40.33 216.4,39.81 217.99,39.81 218.74,39.05 219.42,39.05 220.1,39.73 223.17,39.73 223.38,39.52 223.95,39.52 224.75,38.72 225.59,38.72 230.21,34.1 230.21,28.59 232.06,26.75 232.06,25.3 235.35,22 238.99,22 239.4,21.59 239.4,21.43 v1(239.15,21.18)
  BOTTOM w0.099: v1(203.08,36.9) 202.74,36.9 UH1.U7 ; JSSD3.55 240.53,13.85 240.68,14 240.68,14.71 241.49,15.52 241.49,16.81 239.34,18.96 239.34,20.99 v1(239.15,21.18)
CLK_PEG_GPU: length 74.9
  IN3 w0.099: v1(211.27,87.85) 211.46,87.66 211.46,87.41 210.77,86.71 208.07,86.71 202.77,81.41 202.77,80.3 199.78,77.32 199.78,76.37 192.55,69.13 192.55,53.44 193.24,52.74 193.24,52.09 197.51,47.82 197.51,39.7 199.4,37.81 199.4,36.25 199.61,36.04 199.78,36.04 199.98,35.85 v1(199.98,35.77)
  BOTTOM w0.099: v1(199.98,35.77) 200.04,35.83 UH1.N8 ; UG1.AR42 218.75,86.93 218.75,86.72 218.49,86.46 218.02,86.46 217.4,87.08 215.92,87.08 215.72,87.28 214.95,87.28 214.13,88.11 212.98,88.11 212.06,87.18 211.75,87.18 211.46,87.47 211.46,87.66 v1(211.27,87.85)
CLK_PEG_GPU#: length 74.6
  IN3 w0.099: v1(211.85,87.85) 211.65,87.65 211.65,87.33 210.84,86.52 208.14,86.52 202.95,81.33 202.95,80.22 199.97,77.24 199.97,76.3 192.73,69.06 192.73,53.52 193.43,52.82 193.43,52.17 197.7,47.9 197.7,39.78 199.59,37.89 199.59,36.33 199.69,36.23 199.91,36.23 v1(200.03,36.35)
  BOTTOM w0.089: UH1.N7 200.24,36.35 v1(200.03,36.35)
  BOTTOM w0.099: UG1.AR43 218.12,87.3 218.22,87.4 218.46,87.4 218.56,87.3 218.56,86.8 218.41,86.65 218.1,86.65 217.48,87.27 216,87.27 215.8,87.47 215.03,87.47 214.21,88.3 212.9,88.3 211.98,87.37 211.83,87.37 211.66,87.55 211.66,87.74 211.77,87.85 v1(211.85,87.85)
CLK_SMB: length 10.5
  TOP w0.107: PR19.1 82.15,11.5 82.15,11.12 82.48,10.79 v3(83.64,10.79) 84.64,10.79 85.23,10.21 85.23,9.38 v1(85.36,9.25)
  BOTTOM w0.107: PBATT1.5 85.82,10.24 85.71,10.13 85.42,10.13 85.19,9.9 85.19,9.42 v1(85.36,9.25)
CLKDET#: length 3.4
  TOP w0.089: v1(214.53,28.82) 215.47,28.82 v2(215.7,29.05) 215.7,29.99 215.38,30.31 RH558.1
  BOTTOM w0.089: v1(214.53,28.82) 214.71,28.82 UH1.BB22
CLKREQ#_DGPU: length 285.3
  TOP w0.107: v1(292.07,35.27) 292.56,35.27 294.48,33.35 294.48,30.63 295.25,29.86 295.25,29.06 295.91,28.4 297.61,28.4 297.96,28.05 297.96,25.51 298.34,25.13 UE5.19
  IN1 w0.089: 219.18,23.44 217.71,23.44 216.99,24.16 214.38,24.16 214.09,24.46 212.23,24.46 v1(211.8,24.04)
  IN1 w0.097: v1(292.07,35.27) 291.34,35.27 287.22,31.15 284.49,31.15 284.13,30.79 279.99,30.79 279.77,31.01 271.73,31.01 271.01,31.74 263.09,31.74 255.16,23.81 252.76,23.81 250.7,21.75 249.5,21.75 249.25,22 249.19,22 249.18,22 238.77,22 238.14,21.38 237.16,21.38 235.29,19.51 229.54,19.51 228.32,18.28 227.51,18.28 226.13,16.91 223.42,16.91 223.02,17.3 221.5,17.3 220.61,18.19 220.61,22.11 v1(219.27,23.44) 219.18,23.44
  IN2 w0.091: v1(169.18,158.55) 169.18,157.69 169.82,157.04 169.82,155.52 170.56,154.78 170.97,154.78 172.71,153.03 177.13,153.03 177.38,153.28 188.83,153.28 190.9,151.21 190.9,149.53 196.17,144.26 196.17,111.91 193.25,108.99 193.25,104.62 192.09,103.47 192.09,77.62 195.33,74.38 195.33,71.26 195.84,70.75 195.84,70.58 197,69.42 197.77,69.42 v1(198.29,69.95)
  IN3 w0.089: 201.77,42.08 201.77,41.82 204,39.6 204,32.28 204,32.28 204,27.34 204.31,27.03 208.78,27.03 211.78,24.04 v1(211.8,24.04)
  IN3 w0.091: v1(198.29,69.95) 198.29,66.23 196.18,64.12 196.18,62.11 196.9,61.39 198.68,61.39 201.78,58.3 201.78,50.8 201.08,50.11 201.08,42.89 201.77,42.2 201.77,42.08
  BOTTOM w0.089: v1(211.8,24.04) 211.8,23.88 UH1.AT33
  BOTTOM w0.127: v1(219.27,23.44) 219.3,23.47 RP5.5
  BOTTOM w0.381: v1(169.18,158.55) 169.24,158.61 UM4.17
CLKREQ#_GPU: length 103
  TOP w0.089: v1(229.58,83.15) 229.24,83.15 228.93,83.47 RG27.1
  IN1 w0.097: v1(218.28,27.07) 217.89,27.07 217.61,27.35 216.79,27.35 214.63,29.51 214.63,30.02 214,30.65 214,31.03 213.56,31.48 213.23,31.48 211.35,33.36 211.35,33.99 209.81,35.53 209.81,39.59 210.47,40.25 210.47,41.75 208.29,43.92 208.29,49.84 206.28,51.85 203.46,51.85 201.81,53.5 201.81,57.56 202.31,58.07 202.31,62.43 201.47,63.28 201.47,65.8 205.07,69.4 205.07,73.22 204.65,73.65 204.65,78.25 205.3,78.9 v1(205.59,78.9)
  IN4 w0.089: v1(229.58,83.15) 225.75,83.15 224.21,84.69 221.13,84.69 220.16,83.73 v1(217.18,83.73)
  BOTTOM w0.089: v1(217.18,83.73) 216.99,83.53 215.65,83.53 ; v1(218.28,27.07) 218.02,27.07 217.64,27.44 217.64,28.04 217.4,28.28 216.67,28.28 216.58,28.18 216.32,28.18 216.11,27.97 215.81,27.97 215.66,28.12 UH1.BC24
  BOTTOM w0.107: v1(205.59,78.9) 205.63,78.86 207.55,78.86 208.26,79.57 208.26,80.65 208.53,80.92 209.1,80.92 209.43,81.25 209.43,84.51 210.68,85.76 211.46,85.76 RG22.1 212.18,85.04 213.75,85.04 214.02,84.77 214.35,84.77 215.59,83.53 215.65,83.53 ; RP3.5 218.89,26.45 v1(218.28,27.07)
CLKREQ_PCIE#1: length 145.4
  TOP w0.089: v1(213.08,27.37) 213.81,28.1 216.24,28.1 216.79,27.55 217.28,27.55 218.17,26.66 219,26.66 219.18,26.84
  TOP w0.107: 219.18,26.84 v1(219.3,26.96)
  IN1 w0.097: v1(322.53,37.31) 322.33,37.5 302.59,37.5 302.27,37.18 291.72,37.18 289.25,34.7 289.25,34.13 286.94,31.82 284.21,31.82 283.85,31.46 280.33,31.46 279.39,32.41 278.11,32.41 277.16,31.46 271.91,31.46 271.19,32.18 262.91,32.18 254.98,24.26 252.58,24.26 250.52,22.2 249.69,22.2 249.43,22.45 238.58,22.45 237.96,21.82 236.98,21.82 235.11,19.95 234.3,19.95 233.54,20.72 229.93,20.72 227.94,18.73 227.32,18.73 225.95,17.35 224.05,17.35 223.24,18.16 223.24,23.39 222.58,24.06 222.19,24.06 v1(219.3,26.96)
  BOTTOM w0.089: v1(213.08,27.37) 213.38,27.67 213.49,27.67 UH1.AW24
  BOTTOM w0.107: v1(219.3,26.96) 219.3,26.95 RP3.6 ; JSSD1.52 332.58,35.36 331.8,34.58 327.74,34.58 326.4,33.24 323.41,33.24 322.53,34.13 v1(322.53,37.31)
CLKREQ_PCIE#2: length 102
  TOP w0.089: v1(211.78,27.37) 212.14,27.73 213.01,27.73 213.56,28.28 218.7,28.28 219.18,27.8
  TOP w0.107: 219.18,27.8 v1(219.33,27.65)
  IN1 w0.097: v1(272.15,32) 272.15,32 271.74,32.41 262.81,32.41 254.89,24.48 252.48,24.48 250.42,22.42 249.78,22.42 249.52,22.67 238.49,22.67 237.86,22.05 236.88,22.05 235.02,20.18 234.4,20.18 233.63,20.94 229.83,20.94 227.85,18.96 227.23,18.96 225.86,17.58 224.14,17.58 223.47,18.25 223.47,23.64 222.78,24.33 222.31,24.33 220.18,26.46 220.18,26.8 v1(219.33,27.65)
  BOTTOM w0.089: UH1.AT24 212.22,27.84 211.78,27.4 v1(211.78,27.37)
  BOTTOM w0.107: v1(272.15,32) 271.77,31.61 v2(271.77,29.69) 271.77,28.69 274.84,25.62 274.84,24.54 275.38,24 275.38,13.71 277.59,11.5 JSSD2.52
  BOTTOM w0.127: v1(219.33,27.65) 219.52,27.45 RP3.7
