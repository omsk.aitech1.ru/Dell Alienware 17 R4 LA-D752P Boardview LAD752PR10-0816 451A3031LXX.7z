# Allegro board LAD752PR10-0816.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
TP_LED_B#: length 228.3
  TOP w0.254: 213.64,155.41 214.23,156.01 215.09,156.01 215.27,155.83 UE3.14
  TOP w0.432: v1(118.88,34.11) 118.81,34.04 Q28.5
  TOP w0.508: v1(118.88,34.11) 118.33,34.11 118.12,33.9 117.64,33.9 117.09,33.36 R146.2 ; v1(183.57,29.11) 183.58,29.11 183.58,29.66 184.77,30.85 v4(184.77,39.02) 184.77,51.46 183.52,52.71 183.52,58.06 191.24,65.78 191.24,72.7 190.03,73.91 190.03,85.27 191.4,86.64 191.4,96.09 190.85,96.64 190.85,100.72 188.22,103.35 188.22,107.73 188.77,108.27 188.77,111.44 188.22,111.98 188.22,120.16 191.3,123.24 196,123.24 198.67,125.91 198.67,140.78 205.12,147.24 207.98,147.24 210.65,149.91 210.65,150.76 211.76,151.86 212.97,151.86 213.64,152.53 213.64,155.41
  IN3 w0.508: v1(183.57,29.11) 183.57,29.59 182.78,30.39 182.06,30.39 182.06,30.39 180.8,30.39 179.07,28.65 179.07,26.07 178.21,25.21 137.47,25.21 129.18,33.5 120.34,33.5 119.99,33.86 119.99,33.87 119.74,34.11 v1(118.88,34.11)
TP_LED_B#_DRV: length 4.9
  TOP w0.107: R144.2 117.53,31.07 117.94,31.49 118.62,31.49 118.81,31.3 Q28.2 118.81,30.07 118.91,29.96 v2(119.13,29.96) 119.35,29.96 119.46,30.07 Q28.3
TP_LED_B#_DRV#: length 101.8
  TOP w0.381: Q28.6 118.16,32.44 118.5,32.1 v1(118.5,31.97)
  TOP w0.508: v1(184.41,28.1) 184.42,28.09 184.42,25.75 183.47,24.8 v2(179.84,24.8) 178.78,24.8 178.11,24.12 129.35,24.12 v1(126.31,27.17)
  IN1 w0.508: v1(195.97,12.49) 196.63,13.16 196.63,13.97 195.91,14.7 195.91,14.89 195.4,15.4 192.15,15.4 189.86,17.69 188.21,17.69 185.31,20.59 185.31,22.14 185.07,22.38 185.07,27.45 v1(184.41,28.1)
  IN3 w0.508: v1(126.31,27.17) 126.9,27.17 127.41,27.68 127.41,28.84 126.9,29.35 120.43,29.35 118.5,31.27 v1(118.5,31.97)
  BOTTOM w0.305: v1(195.97,12.49) 195.82,12.34 JTP.3
TP_LED_EN: length 132.4
  TOP w0.203: UE5.25 v1(295.94,19.66)
  TOP w0.508: v1(200.85,9.83) 202.01,8.67 v2(203.08,8.67) 206.13,8.67 209.2,11.74 214.76,11.74 v1(216.61,9.89) ; v1(195.84,18.84) 195.84,18.83 196.09,18.58 Q2410.2
  IN2 w0.508: v1(286.27,6.26) 286.08,6.26 284.68,7.65 276.32,7.65 273.53,10.45 272.56,10.45 271.94,9.83 266.22,9.83 265.6,10.45 258.9,10.45 258.7,10.25 253.67,10.25 253.02,9.6 247.07,9.6 246.68,9.2 241.04,9.2 239.99,10.25 233.92,10.25 233.3,9.62 232.27,9.62 231.92,9.27 226.5,9.27 225.02,10.76 217.12,10.76 216.61,10.25 v1(216.61,9.89)
  IN3 w0.508: v1(200.85,9.83) 199.32,9.83 196.76,12.39 196.76,13.8 195.68,14.88 195.68,18.68 v1(195.84,18.84) ; v1(286.27,6.26) 286.9,5.62 287.79,5.62 288.74,6.57 288.74,8.97 288.17,9.54 288.17,17.05 290.79,19.66 v1(295.94,19.66)
TP_LED_G#: length 237.5
  TOP w0.254: UE3.11 215.25,157.33 215.21,157.37 213.84,157.37 213.55,157.08
  TOP w0.432: Q29.5 v1(114.61,33.52)
  TOP w0.508: R154.2 112.84,33.12 113.26,33.54 114.59,33.54 v1(114.61,33.52) ; 213.55,157.08 213,156.53 213,153.1 212.4,152.5 211.49,152.5 210.02,151.02 210.02,150.17 207.72,147.87 204.86,147.87 198.03,141.04 198.03,126.17 195.73,123.87 192.53,123.87 191.59,124.81 190.33,124.81 189.87,124.35 189.87,123.48 188.48,122.08 186.22,122.08 185.47,121.34 185.47,109.26 186.59,108.15 186.59,107.64 185.92,106.98 185.92,104.75 190.22,100.46 190.22,96.38 190.77,95.83 190.77,86.9 189.4,85.53 189.4,73.64 190.6,72.44 190.6,66.04 182.88,58.33 182.88,52.45 184.13,51.2 v2(184.13,33.69) 184.13,31.11 182.94,29.92 v1(182.94,29.1)
  IN3 w0.508: v1(182.94,29.1) 182.94,29.3 182.49,29.75 181.07,29.75 179.7,28.39 179.7,25.8 178.48,24.58 137.21,24.58 128.92,32.87 120.08,32.87 119.53,33.41 116.22,33.41 116.11,33.52 v1(114.61,33.52)
TP_LED_G#_DRV: length 4.6
  TOP w0.107: Q29.3 115.26,31.1 115.14,31.22 114.74,31.22 114.61,31.1 Q29.2 114.61,30.43 114.51,30.32 113.93,30.32 113.41,30.84 R150.2 111.91,30.84 v2(111.83,30.77)
TP_LED_G#_DRV#: length 99
  TOP w0.381: Q29.6 113.96,32.54 114.35,32.16 v1(114.56,32.16)
  TOP w0.508: v1(183.59,27.78) 182.52,27.78 180.81,26.07 178.26,26.07 177.58,25.39 130.03,25.39 v2(128.5,26.92) 126.7,28.71 v1(126.37,28.71)
  IN1 w0.508: v1(195.27,12.49) 195.27,13.03 193.54,14.76 191.88,14.76 189.6,17.05 186.89,17.05 185.59,18.34 185.59,19.41 184.67,20.33 184.67,21.88 184.43,22.12 184.43,27.07 183.72,27.78 v1(183.59,27.78)
  IN3 w0.508: v1(126.37,28.71) 116.36,28.71 114.87,30.21 114.87,31.86 v1(114.56,32.16)
  BOTTOM w0.305: v1(195.27,12.49) 195.27,12.2 195.32,12.15 JTP.4
TP_LED_R#: length 241
  TOP w0.254: UE3.10 214.85,157.83 214.28,158.4 213.78,158.4
  TOP w0.432: v1(108.59,33.69) 108.38,33.69 107.95,33.26 Q34.5
  TOP w0.508: v1(108.59,33.69) 109.16,33.69 109.6,33.25 R147.2 ; v1(182.3,29.04) 182.3,30.18 v2(182.98,30.86) 183.5,31.38 183.5,50.6 182.01,52.09 182.01,58.69 189.87,66.55 189.87,72.27 188.76,73.38 188.76,85.79 190.13,87.16 190.13,92.78 189.35,93.56 189.35,100.1 185.29,104.16 185.29,107.72 184.84,108.17 184.84,121.6 186.04,122.81 188.31,122.81 189.24,123.74 189.24,124.61 191.46,126.84 191.46,131.96 191.99,132.49 194.89,132.49 197.25,134.85 197.25,141.16 204.6,148.51 207.45,148.51 209.38,150.44 209.38,151.28 211,152.9 211,156.12 211.29,156.41 211.29,157.41 212.28,158.4 213.78,158.4
  IN3 w0.508: v1(182.3,29.04) 181.25,29.04 180.34,28.12 180.34,25.54 178.74,23.94 136.94,23.94 128.65,32.23 119.82,32.23 119.27,32.78 115.95,32.78 115.85,32.88 110.04,32.88 109.23,33.69 v1(108.59,33.69)
TP_LED_R#_DRV: length 4.1
  TOP w0.107: v2(110.63,31.46) 110.23,31.07 R145.2 109.01,30.48 108.75,30.48 108.6,30.64 Q34.3 108.6,31.21 108.42,31.4 108.13,31.4 107.95,31.21 Q34.2
TP_LED_R#_DRV#: length 108
  TOP w0.381: v1(107.3,33.56) Q34.6
  TOP w0.508: v1(183.46,27.15) 183.52,27.09 183.52,25.87 183.08,25.43 178.52,25.43 177.85,24.76 v2(154.19,24.76) 129.63,24.76 126.48,27.91 v1(126.25,27.91)
  IN1 w0.508: v1(194.64,12.49) 194.64,12.66 193.17,14.13 191.62,14.13 189.33,16.42 186.63,16.42 184.96,18.08 184.96,19.14 184.04,20.06 184.04,21.61 183.8,21.86 183.8,26.81 v1(183.46,27.15)
  IN3 w0.508: v1(126.25,27.91) 114.11,27.91 111.5,30.52 107.43,30.52 106.39,31.57 106.39,32.66 v1(107.3,33.56)
  BOTTOM w0.305: v1(194.64,12.49) 194.64,12.1 194.82,11.91 JTP.5
TRIP_+1VALWP: length 3.8
  TOP w0.107: v2(246.48,16.16) 246.64,16.33 246.64,17.57 PR303.2
  TOP w0.254: PR303.2 247.15,18.57 247.61,19.04 PU300.2
TRONL_LED_B_DRV#: length 314.1
  TOP w0.107: v1(297.05,29.01) v2(297.05,29.56) 297.05,29.68 295.18,31.55 295.18,35.17 295.41,35.4 295.41,43.95 293.07,46.29 292.22,46.29 v1(291.79,46.72)
  IN2 w0.091: v1(36.2,51.75) 37.88,50.07 46.39,50.07 47.23,49.23 55.02,49.23 55.3,49.51 66.42,49.51 66.97,48.97 81.41,48.97 81.79,49.35 87.43,49.35 87.54,49.23 97.7,49.23 97.9,49.04 107.29,49.04 109.67,51.42 147.57,51.42 147.96,51.04 149.33,51.04 150.09,51.8 172.56,51.8 174.63,49.72 174.63,48.72 175.23,48.12 176.61,48.12 176.92,47.81 178.74,47.81 181.16,50.23 183.16,50.23 184.98,52.05 192.6,52.05 196.36,48.29 199.51,48.29 203.38,52.16 206.59,52.16 208.73,50.02 208.73,47.65 209.71,46.67 214.26,46.67 214.62,46.31 216.22,46.31 217.12,45.41 227.23,45.41 228.3,44.34 258.51,44.34 258.51,44.35 263.57,44.35 274.24,33.67 279.03,33.67 279.29,33.42 283.3,33.42 288.79,27.92 295.96,27.92 v1(297.05,29.01)
  BOTTOM w0.107: UE8.5 291.71,46.64 v1(291.79,46.72) ; v1(36.2,51.75) 36.62,51.33 36.62,50.42 36.27,50.07 JTRONL.10 36.27,47.97 36.65,47.59 39.89,47.59 40.27,47.98 JTRONL.5
TRONL_LED_G_DRV#: length 306.7
  TOP w0.107: v1(296.47,29.01) 296.47,29.71 v2(295.46,30.72) 294.95,31.23 294.95,35.27 295.18,35.5 295.18,43.85 292.98,46.05 291.86,46.05 v1(291.2,46.7)
  IN2 w0.091: v1(296.47,29.01) 296.07,29.41 295.59,29.41 294.54,28.36 288.97,28.36 283.48,33.85 279.47,33.85 279.21,34.11 274.42,34.11 263.75,44.78 228.61,44.78 227.55,45.85 217.3,45.85 216.4,46.74 214.8,46.74 214.44,47.1 209.89,47.1 209.16,47.83 209.16,50.2 206.77,52.59 203.2,52.59 199.33,48.73 196.54,48.73 192.78,52.49 184.8,52.49 182.98,50.66 180.98,50.66 178.56,48.25 177.34,48.25 175.81,49.78 175.19,49.78 172.74,52.24 149.91,52.24 149.15,51.47 148.14,51.47 147.75,51.86 109.49,51.86 107.11,49.48 98.08,49.48 97.89,49.67 90.55,49.67 89.79,50.44 82.26,50.44 81.23,49.4 67.15,49.4 66.58,49.97 55.14,49.97 54.84,49.68 47.41,49.68 45.98,51.11 41.37,51.11 40.99,50.73 v1(40.97,50.73)
  BOTTOM w0.107: JTRONL.4 41.07,50.6 40.97,50.71 ; UE8.4 291.21,46.7 v1(291.2,46.7) ; JTRONL.9 37.07,50.68 37.73,51.34 40.33,51.34 40.97,50.71 ; 40.97,50.71 v1(40.97,50.73)
TRONL_LED_R_DRV#: length 304.9
  TOP w0.107: v1(295.88,29.01) 295.88,29.82 294.71,30.99 294.71,35.37 294.94,35.6 294.94,43.75 293.42,45.28 292.03,45.28 v2(291.79,45.52) v1(290.62,46.69)
  IN2 w0.091: v1(37.87,50.71) 38.14,50.98 39.93,50.98 40.59,50.32 41.49,50.32 v1(41.87,50.71) 46.07,50.71 47.32,49.45 54.93,49.45 55.23,49.75 66.49,49.75 67.06,49.18 81.32,49.18 82.35,50.22 89.7,50.22 90.46,49.45 97.8,49.45 97.99,49.26 107.2,49.26 109.58,51.64 147.66,51.64 148.05,51.25 149.24,51.25 150,52.02 172.65,52.02 175.1,49.56 175.71,49.56 177.25,48.03 178.65,48.03 181.07,50.45 183.07,50.45 184.89,52.27 192.69,52.27 196.45,48.51 199.42,48.51 203.29,52.38 206.68,52.38 208.95,50.11 208.95,47.74 209.8,46.89 214.35,46.89 214.71,46.53 216.31,46.53 217.21,45.63 227.32,45.63 228.39,44.57 263.66,44.57 274.33,33.89 279.12,33.89 279.38,33.63 283.39,33.63 288.88,28.14 294.63,28.14 295.5,29.01 v1(295.88,29.01)
  BOTTOM w0.107: v1(41.87,50.71) JTRONL.3 ; v1(290.62,46.69) 290.71,46.6 UE8.3 ; v1(37.87,50.71) JTRONL.8
TRONR_LED_B_DRV#: length 41.8
  TOP w0.107: v1(295.52,45.66) 296.35,44.84 296.35,44.84 296.99,44.2 296.99,42.64 297.01,42.62 297.01,39.81 296.86,39.66 296.86,35.57 296.3,35.01 v2(296.3,34.32) v1(296.3,31.72) ; v1(278.27,29.43) 279.06,28.63 279.51,28.63 v1(279.92,28.23)
  IN1 w0.097: v1(279.92,28.23) 280.48,28.78 288.4,28.78 290.93,31.31 295.9,31.31 v1(296.3,31.72)
  BOTTOM w0.107: v1(279.92,28.23) 281.06,28.23 281.97,29.13 JTRONR.10 ; v1(278.27,29.43) 277.97,29.73 JTRONR.5 ; v1(295.52,45.66) 294.91,45.05 UE8.9
TRONR_LED_G_DRV#: length 45.3
  TOP w0.107: v1(295.59,31.72) v2(295.59,32.67) 295.59,34.63 296.63,35.66 296.63,38.67 295.88,39.42 295.88,44.64 v1(292.85,47.67)
  IN1 w0.097: v1(279.33,28.23) 280.12,29.01 288.31,29.01 291.52,32.23 295.08,32.23 v1(295.59,31.72)
  BOTTOM w0.107: JTRONR.9 281.17,30.06 v1(279.33,28.23) 277.97,28.23 277.17,29.03 JTRONR.4 ; v1(292.85,47.67) 293.29,47.23 293.29,46.78 293.21,46.7 UE8.8
TRONR_LED_R_DRV#: length 39.4
  TOP w0.107: v1(295.82,36.48) v2(295.82,38.21) 295.82,38.57 295.65,38.74 295.65,44.07 293.2,46.52 292.57,46.52 v1(292.39,46.7)
  IN1 w0.097: v1(295.82,36.48) 295.6,36.7 291.88,36.7 289.7,34.52 289.7,33.95 287.13,31.38 284.39,31.38 284.03,31.01 280.09,31.01 279.42,31.68 v1(278.27,31.68)
  BOTTOM w0.107: JTRONR.3 276.37,31.47 276.57,31.68 v1(278.27,31.68) 280.15,31.68 280.37,31.46 JTRONR.8 ; v1(292.39,46.7) 292.21,46.52 UE8.6
TS_EN: length 309.6
  TOP w0.107: v1(168.12,179.23) JEDP.34 ; v1(329.51,46.83) 330.08,47.4 v2(330.59,47.4) 331.22,47.4 332.24,46.39 332.24,45.31 332.04,45.11 UE6.14
  IN2 w0.091: v1(168.12,179.23) 168.12,176.75 166.3,174.93 166.3,171.7 165.71,171.1 165.71,169.17 165.9,168.97 165.9,164.39 165.34,163.83 165.34,161.69 165.6,161.44 165.6,156.14 168.93,152.8 170.16,152.8 172.09,150.87 172.09,150.57 172.24,150.42 186.91,150.42 193.09,144.25 193.09,129.26 193.63,128.72 193.63,114.59 189.6,110.56 189.6,106.33 189.54,106.26 189.54,98.24 189.01,97.71 189.01,94.01 190.08,92.94 190.08,73.31 192.37,71.02 192.37,70.39 195.69,67.06 196.52,67.06 199,64.59 201.14,64.59 202.38,63.36 207.77,63.36 208.05,63.08 222.6,63.08 224.91,65.38 248.9,65.38 249.09,65.2 267.4,65.2 267.55,65.35 272.9,65.35 277.4,60.85 277.4,53.48 278.39,52.49 278.39,47.23 282.02,43.6 285.14,43.6 285.83,42.9 293.35,42.9 299.6,36.65 317.6,36.65 318.46,35.78 323.16,35.78 326.03,38.65 326.03,40.37 327.1,41.43 328.11,41.43 329.12,42.44 329.12,46.44 v1(329.51,46.83)
TYPEC_DET#: length 4.2
  TOP w0.107: UE10.18 v2(307.05,53.98) 307.05,54.79 QU1.1 305.7,55.23 RU26.2
UART_2_CCTS_DRTS: length 9.4
  BOTTOM w0.089: 212.86,15.16 212.86,15.29 v2(212.73,15.42) 211.12,17.03 210.6,17.03 210.51,17.12 210.51,17.72 210.73,17.93 UH1.AN44
  BOTTOM w0.107: 212.86,15.16 212.86,14.8 212.85,14.79 212.85,13.22 213.52,12.54 214.72,12.54 215.1,12.92 RC65.1
UART_2_CRXD_DTXD: length 17.7
  TOP w0.107: v1(210.93,17.39) 210.93,16.45 v2(210.64,16.16) 209.91,15.44 209.25,15.44 208.54,14.73 208.54,14.27 207.89,13.61 203.95,13.61 203.61,13.27 203.61,12.06 203.89,11.79 JWDB.3
  BOTTOM w0.089: v1(210.93,17.39) 210.93,17.67 211.04,17.79 UH1.AR45
  BOTTOM w0.107: v1(210.93,17.39) 210.93,17.39 211.03,17.28 211.36,17.28 213.31,15.34 RC62.1
UART_2_CTXD_DRXD: length 26.4
  TOP w0.107: RC63.1 208.66,16.86 210,16.86 210.46,17.31 210.46,18.04 210.77,18.36 210.77,20.87 210.96,21.05 212.07,21.05 v1(212.2,20.92) 211.72,20.44 v2(211.72,19.78) 211.72,18.7 211.3,18.28 211.3,16.4 210.14,15.24 209.38,15.24 208.78,14.64 208.78,14.17 207.98,13.38 204.05,13.38 203.84,13.18 203.84,12.16 204.12,11.88 204.12,11.46 204.69,10.9 JWDB.2
  BOTTOM w0.107: v1(212.2,20.92) 211.72,20.44 UH1.AR39
UG_3V: length 15.6
  TOP w0.107: v1(53.48,29.43) v2(54.11,29.43)
  IN4 w1.016: 52.9,30.7 52.9,35.4 58.16,40.65 58.16,42.09 57.16,43.09
  vias: v1(53.18,28.92) v1(55.95,44.42) v1(56.4,43.98)
UG_5V: length 8.9
  TOP w0.107: v1(51.76,43.81) 50.59,43.81 v2(50.15,43.38)
  IN4 w1.016: 46.61,37.94 46.61,39.02 50.87,43.28
  vias: v1(47.06,36.93) v1(47.06,36.29)
UG_+1VALWP: length 9
  IN4 w1.016: 247.09,24.96 247.09,26.26 247.91,27.08 253.69,27.08 254.2,26.58
  vias: v1(246.96,24.1) v1(247.41,23.66) v1(254.39,25.56) v1(255.02,25.56) v2(246.9,23.59)
USB2_COMP: length 4.7
  BOTTOM w0.102: UH1.AG3 207.75,38.42 207.48,38.7 207.48,39.17 207.41,39.23 207.41,40.22 207.28,40.35 207.28,40.79 207.03,41.05
  BOTTOM w0.305: RH109.1 206.28,41.76 206.51,41.53 v2(206.51,41.24) 206.71,41.05 207.03,41.05
USB3_A_TRX_DTX_N0: length 23.3
  TOP w0.089: UT1.A21 185.12,169.72 185.22,169.62 185.31,169.62 185.35,169.66 185.35,170.22 arc(185.36,170.27) 185.38,170.32 arc(185.46,170.5) 185.49,170.7 arc(185.49,170.71) 185.5,170.73 185.59,170.94 arc(185.59,170.95) 185.59,170.95 arc(185.75,171.07) 185.94,171.11 arc(186.11,171.09) 186.26,171.03 arc(186.3,171) 186.33,170.96 arc(186.35,170.94) 186.36,170.92 186.55,170.73 arc(186.64,170.67) 186.74,170.65 187.39,170.65 arc(187.66,170.75) 187.78,171.02 187.78,171.33 arc(187.67,171.6) 187.41,171.72 187.21,171.72 arc(186.93,171.77) 186.7,171.93 186.54,172.09 arc(186.49,172.15) 186.48,172.23 arc(186.53,172.37) 186.65,172.47 v1(186.72,172.5)
  BOTTOM w0.089: v1(186.72,172.5) 186.56,172.66 arc(186.52,172.72) 186.51,172.79 186.51,172.84 arc(186.54,173.06) 186.63,173.26 arc(186.73,173.35) 186.86,173.39 187.08,173.39 arc(187.45,173.52) 187.64,173.87 187.65,173.9 arc(187.65,173.93) 187.65,173.97 187.65,174.02 187.65,174.14 arc(187.65,174.16) 187.65,174.19 arc(187.69,174.28) 187.75,174.36 DT5.1 187.91,174.53 187.85,174.59 arc(187.76,174.72) 187.72,174.87 arc(187.72,174.88) 187.71,174.9 arc(187.71,174.9) 187.71,174.91 arc(187.71,174.97) 187.7,175.04 187.7,175.05 arc(187.7,175.07) 187.69,175.09 arc(187.68,175.13) 187.66,175.17 arc(187.64,175.2) 187.62,175.22 187.59,175.26 arc(187.39,175.41) 187.14,175.47 186.16,175.47 arc(186.12,175.47) 186.08,175.46 arc(186.01,175.44) 185.94,175.41 arc(185.94,175.41) 185.94,175.41 185.94,175.41 arc(185.72,175.36) 185.49,175.35 184.34,175.35 arc(184.25,175.41) 184.22,175.52 184.22,175.77 arc(184.3,175.96) 184.48,176.03 187.21,176.03 arc(187.55,176.1) 187.83,176.29 188.08,176.54 arc(188.32,176.7) 188.6,176.75 188.73,176.75 arc(188.95,176.79) 189.14,176.91 189.21,176.98 189.27,177.05 arc(189.49,177.38) 189.57,177.77 189.57,178.35 arc(189.59,178.45) 189.65,178.54 189.77,178.66 arc(189.8,178.68) 189.84,178.69 190.31,178.69 arc(190.41,178.71) 190.5,178.77 190.55,178.82 arc(190.61,178.91) 190.64,179.02 190.64,179.04 arc(190.64,179.08) 190.66,179.11 190.76,179.21 arc(190.82,179.3) 190.85,179.41 JUSBC1.B10
USB3_A_TRX_DTX_N1: length 31.4
  TOP w0.089: UT1.B15 182.36,169.39 182.5,169.53 arc(182.57,169.63) 182.59,169.74 182.59,169.97 arc(182.58,170.02) 182.54,170.07 182.22,170.4 arc(182.2,170.43) 182.19,170.46 182.19,171.11 arc(182.17,171.22) 182.11,171.31 181.5,171.92 arc(181.37,172.11) 181.33,172.33 181.33,173.2 arc(181.34,173.48) v1(181.38,173.77)
  BOTTOM w0.089: JUSBC1.A10 194.6,177.56 arc(194.61,177.48) 194.66,177.41 194.73,177.33 arc(194.76,177.3) 194.77,177.26 194.77,176.95 arc(194.79,176.8) 194.88,176.68 195.7,175.86 arc(195.81,175.7) 195.84,175.51 195.84,174.49 arc(195.82,174.37) 195.75,174.26 DT9.1 195.59,174.11 195.59,173.99 arc(195.64,173.84) 195.76,173.75 arc(195.77,173.74) 195.78,173.74 195.84,173.74 arc(195.88,173.74) 195.93,173.74 arc(196.05,173.62) 196.1,173.45 196.1,171.05 arc(195.99,170.51) 195.69,170.06 195.08,169.45 arc(194.85,169.28) 194.57,169.2 190.86,169.2 arc(190.83,169.2) 190.8,169.22 190.6,169.42 arc(190.36,169.58) 190.07,169.64 188.85,169.64 arc(188.4,169.73) 188.02,169.99 187.14,170.86 arc(186.39,171.37) 185.5,171.54 185.41,171.54 arc(185.24,171.58) 185.09,171.68 184.48,172.29 arc(184.24,172.45) 183.96,172.5 181.42,172.5 arc(181.24,172.55) 181.1,172.67 181.05,172.75 181.05,172.75 181.02,172.81 181.01,172.84 arc(181.01,172.84) 181.01,172.84 181,172.9 180.99,172.92 arc(180.99,172.96) 180.99,173 arc(180.99,173.01) 180.99,173.02 181,173.08 arc(181.03,173.19) 181.1,173.28 arc(181.13,173.31) 181.16,173.34 181.33,173.37 arc(181.43,173.42) 181.48,173.52 181.48,173.53 arc(181.45,173.66) v1(181.38,173.77)
USB3_A_TRX_DTX_P0: length 23.3
  TOP w0.089: v1(186.14,172.5) 186.2,172.44 arc(186.27,172.34) 186.29,172.21 arc(186.29,172.2) 186.29,172.18 arc(186.29,172.18) 186.29,172.18 arc(186.32,172.08) 186.38,171.98 186.4,171.96 arc(186.4,171.96) 186.4,171.95 186.56,171.79 186.56,171.8 186.57,171.79 arc(186.61,171.75) 186.65,171.71 arc(186.91,171.58) 187.21,171.53 187.41,171.53 arc(187.54,171.46) 187.59,171.33 187.59,171.02 arc(187.53,170.89) 187.4,170.84 187.4,170.84 186.74,170.84 arc(186.71,170.85) 186.68,170.87 186.5,171.05 arc(186.44,171.13) 186.36,171.19 arc(186.15,171.27) 185.94,171.3 arc(185.67,171.24) 185.45,171.07 arc(185.44,171.05) 185.43,171.04 185.39,170.97 185.4,170.95 185.33,170.8 arc(185.32,170.75) 185.31,170.7 arc(185.29,170.55) 185.23,170.41 184.95,170.13 arc(184.91,170.07) 184.9,170 184.9,169.72 arc(184.91,169.65) 184.95,169.58 185.09,169.44 arc(185.11,169.41) UT1.B21
  BOTTOM w0.089: v1(186.14,172.5) 186.26,172.62 arc(186.31,172.68) 186.32,172.76 186.32,172.84 arc(186.36,173.11) 186.47,173.36 arc(186.64,173.52) 186.86,173.57 187.08,173.57 arc(187.33,173.67) 187.45,173.9 187.46,173.92 arc(187.46,173.95) 187.46,173.97 187.46,174.02 arc(187.44,174.22) 187.35,174.41 arc(187.29,174.48) DT4.1 arc(187.37,174.67) 187.47,174.84 arc(187.48,174.87) 187.49,174.9 arc(187.51,174.98) 187.5,175.06 arc(187.5,175.06) 187.5,175.06 arc(187.49,175.07) 187.49,175.08 arc(187.48,175.09) 187.48,175.1 187.44,175.14 arc(187.31,175.24) 187.14,175.28 186.16,175.28 arc(186.14,175.28) 186.13,175.28 arc(186.07,175.26) 186.01,175.24 arc(186.01,175.24) 186,175.23 arc(186,175.23) 185.99,175.23 arc(185.75,175.18) 185.49,175.16 184.32,175.16 arc(184.11,175.29) 184.03,175.52 184.03,175.77 arc(184.16,176.09) 184.48,176.22 187.21,176.22 arc(187.47,176.27) 187.7,176.42 187.95,176.67 arc(188.25,176.87) 188.6,176.94 188.73,176.94 arc(188.88,176.97) 189.01,177.05 189.08,177.12 189.14,177.18 arc(189.32,177.45) 189.38,177.77 189.38,178.35 arc(189.42,178.53) 189.52,178.67 189.64,178.8 arc(189.73,178.86) 189.84,178.88 190.31,178.88 arc(190.34,178.89) 190.37,178.9 190.37,178.91 190.42,178.95 arc(190.44,178.98) 190.45,179.02 190.45,179.05 arc(190.44,179.1) 190.41,179.14 190.37,179.18 arc(190.35,179.21) 190.35,179.24 JUSBC1.B11
USB3_A_TRX_DTX_P1: length 31.4
  TOP w0.089: UT1.A15 182.37,169.83 182.37,169.79 arc(182.33,169.69) 182.23,169.65 arc(182.16,169.69) 182.13,169.76 182.13,170.19 arc(182.12,170.22) 182.1,170.25 182.04,170.31 arc(182.01,170.35) 182,170.4 182,171.11 arc(182,171.15) 181.98,171.18 181.37,171.79 arc(181.2,172.03) 181.14,172.33 181.14,173.2 arc(181.04,173.53) v1(180.78,173.77)
  BOTTOM w0.089: JUSBC1.A11 195.1,177.52 arc(195.08,177.46) 195.05,177.41 194.98,177.34 arc(194.96,177.31) 194.95,177.28 194.95,176.95 arc(194.97,176.87) 195.01,176.81 195.83,175.99 arc(195.98,175.77) 196.03,175.51 196.03,174.52 arc(196.05,174.41) 196.12,174.31 DT8.1 arc(196.3,174.05) 196.3,173.98 arc(196.3,173.96) 196.3,173.95 arc(196.29,173.9) 196.29,173.86 arc(196.29,173.83) 196.29,173.81 arc(196.29,173.8) 196.29,173.79 arc(196.29,173.78) 196.29,173.77 arc(196.29,173.77) 196.29,173.76 arc(196.29,173.75) 196.29,173.73 arc(196.29,173.73) 196.29,173.72 arc(196.29,173.72) 196.29,173.72 196.29,171.05 arc(196.16,170.44) 195.82,169.92 195.21,169.32 arc(194.93,169.11) 194.6,169.01 arc(194.52,169) 194.45,169.01 190.86,169.01 arc(190.76,169.03) 190.67,169.09 190.47,169.29 arc(190.29,169.41) 190.07,169.45 188.85,169.45 arc(188.33,169.56) 187.88,169.85 187.01,170.73 arc(186.31,171.19) 185.5,171.36 185.41,171.36 arc(185.16,171.4) 184.96,171.54 184.34,172.16 arc(184.17,172.27) 183.96,172.32 181.42,172.32 arc(181.15,172.38) 180.94,172.57 180.88,172.66 180.87,172.68 180.85,172.74 180.84,172.78 arc(180.84,172.78) 180.83,172.79 180.81,172.85 180.8,172.9 arc(180.8,172.94) 180.8,172.97 arc(180.8,173.01) 180.8,173.05 180.8,173.15 arc(180.8,173.16) 180.8,173.16 arc(180.8,173.17) 180.8,173.18 180.8,173.26 arc(180.8,173.29) 180.81,173.33 arc(180.81,173.38) 180.81,173.43 arc(180.81,173.44) 180.81,173.44 arc(180.81,173.44) 180.81,173.44 arc(180.81,173.47) 180.8,173.49 arc(180.8,173.5) 180.8,173.51 arc(180.8,173.64) v1(180.78,173.77)
USB3_A_TTX_C_DRX_N0: length 18
  TOP w0.089: v1(189.24,171.61) arc(188.95,171.81) 188.79,172.12 arc(188.77,172.19) 188.74,172.26 arc(188.72,172.28) 188.71,172.3 188.7,172.31 arc(188.67,172.34) 188.64,172.37 188.53,172.45 arc(188.53,172.46) 188.53,172.46 arc(188.37,172.6) 188.21,172.74 187.63,173.33 arc(187.49,173.42) 187.34,173.45 186.05,173.45 arc(185.61,173.57) 185.3,173.91 185.3,174.71 arc(185.17,175.03) 184.86,175.16 183.9,175.16 arc(183.69,175.07) 183.6,174.86 183.6,174.48 arc(183.6,174.47) 183.6,174.47 arc(183.71,174.28) 183.9,174.21 183.92,174.21 arc(184.27,174.06) 184.42,173.7 184.42,173.01 arc(184.47,172.82) CT42.1
  BOTTOM w0.089: JUSBC1.A3 191.1,177.56 arc(191.06,177.45) 190.96,177.38 arc(190.9,177.31) 190.88,177.21 190.86,177.14 arc(190.84,177.02) 190.84,176.9 190.84,176.85 190.82,176.76 arc(190.79,176.67) 190.73,176.6 190.73,176.6 arc(190.69,176.55) 190.66,176.5 arc(190.62,176.35) 190.61,176.19 arc(190.63,176.01) 190.74,175.87 DT3.1 arc(190.73,175.63) 190.7,175.42 arc(190.7,175.35) 190.68,175.29 arc(190.55,174.82) 190.51,174.34 190.51,172.43 arc(190.48,172.27) 190.4,172.13 arc(190.11,171.88) 189.74,171.78 arc(189.69,171.78) 189.63,171.77 arc(189.42,171.73) v1(189.24,171.61)
USB3_A_TTX_C_DRX_N1: length 25.9
  TOP w0.089: v1(194.69,178.82) arc(194.86,178.57) 194.92,178.28 194.92,177.7 arc(194.97,177.44) 195.12,177.23 195.64,176.7 arc(195.75,176.53) 195.79,176.33 195.79,174.53 arc(195.75,174.32) 195.63,174.15 DT7.1 arc(195.78,173.94) 195.84,173.7 195.84,173.05 arc(195.82,172.93) 195.75,172.83 195.63,172.71 arc(195.6,172.7) 195.57,172.69 194.75,172.69 arc(194.28,172.59) 193.88,172.33 193.38,171.83 arc(193.28,171.76) 193.15,171.74 191.84,171.74 arc(191.26,171.85) 190.76,172.18 190.53,172.41 arc(190.42,172.58) 190.38,172.77 190.38,172.88 arc(190.33,173.12) 190.19,173.33 190.06,173.47 arc(189.93,173.58) 189.79,173.66 arc(189.55,173.75) 189.3,173.78 189.3,173.77 189.06,173.77 arc(188.64,173.86) 188.29,174.1 186.51,175.87 arc(186.22,176.07) 185.87,176.14 183.85,176.14 arc(183.01,175.82) 182.58,175.03 182.57,174.99 arc(182.56,174.47) 182.69,173.97 arc(182.69,173.97) 182.69,173.97 arc(182.69,173.96) 182.7,173.94 arc(182.71,173.87) 182.73,173.79 182.76,173.65 182.79,173.39 arc(182.73,173.02) CT40.1
  BOTTOM w0.089: JUSBC1.B3 194.35,179.31 arc(194.36,179.24) 194.4,179.17 194.41,179.17 arc(194.46,179.13) 194.52,179.12 arc(194.58,179.11) 194.63,179.08 194.65,179.06 arc(194.68,179.01) 194.69,178.95 v1(194.69,178.82)
USB3_A_TTX_C_DRX_P0: length 18
  TOP w0.089: v1(189.24,172.2) arc(188.99,172.35) 188.75,172.52 188.65,172.6 arc(188.53,172.7) 188.41,172.81 arc(188.38,172.84) 188.35,172.88 187.76,173.46 arc(187.57,173.59) 187.34,173.64 186.05,173.64 arc(185.73,173.72) 185.49,173.96 185.49,174.71 arc(185.31,175.17) 184.86,175.35 183.9,175.35 arc(183.56,175.21) 183.41,174.86 183.41,174.48 arc(183.41,174.47) 183.42,174.45 arc(183.42,174.45) 183.42,174.44 arc(183.42,174.44) 183.42,174.44 arc(183.58,174.14) 183.9,174.02 183.92,174.02 arc(184.14,173.93) 184.23,173.7 184.23,173.01 arc(184.18,172.82) CT41.1
  BOTTOM w0.089: JUSBC1.A2 190.6,177.53 arc(190.6,177.49) 190.63,177.45 190.66,177.42 arc(190.67,177.4) 190.68,177.39 arc(190.68,177.38) 190.69,177.38 arc(190.69,177.38) 190.69,177.37 arc(190.69,177.37) 190.69,177.37 arc(190.69,177.36) 190.69,177.36 arc(190.69,177.36) 190.69,177.36 190.69,177.28 arc(190.69,177.26) 190.69,177.24 190.67,177.17 arc(190.66,177.05) 190.65,176.94 190.65,176.94 arc(190.65,176.92) 190.65,176.9 190.65,176.87 190.64,176.8 arc(190.62,176.76) 190.6,176.73 190.6,176.73 190.55,176.68 arc(190.46,176.54) 190.43,176.38 arc(190.42,176.32) 190.41,176.27 arc(190.4,176.24) 190.4,176.2 arc(190.4,176.19) 190.4,176.19 190.4,176.18 arc(190.4,176.18) 190.4,176.17 arc(190.39,176.16) 190.39,176.16 arc(190.27,175.98) DT2.1 arc(190.41,175.73) 190.51,175.44 arc(190.51,175.4) 190.5,175.36 arc(190.37,174.86) 190.32,174.34 190.32,172.43 arc(190.3,172.33) 190.25,172.24 190.25,172.24 arc(190.04,172.06) 189.77,171.99 189.62,171.98 arc(189.61,171.98) 189.6,171.98 189.51,171.98 arc(189.46,171.99) 189.42,172.01 189.24,172.19 v1(189.24,172.2)
USB3_A_TTX_C_DRX_P1: length 26
  TOP w0.089: v1(195.28,178.8) arc(195.15,178.61) 195.11,178.38 195.11,177.7 arc(195.14,177.52) 195.25,177.36 195.77,176.84 arc(195.93,176.6) 195.98,176.33 195.98,174.54 arc(196,174.42) 196.07,174.33 DT6.1 arc(196.09,173.95) 196.03,173.7 196.03,173.05 arc(195.99,172.86) 195.89,172.7 195.77,172.58 arc(195.68,172.52) 195.57,172.5 194.75,172.5 arc(194.35,172.42) 194.01,172.19 193.51,171.7 arc(193.35,171.59) 193.15,171.55 191.84,171.55 arc(191.18,171.68) 190.63,172.05 190.4,172.28 arc(190.25,172.51) 190.19,172.77 190.19,172.88 arc(190.16,173.05) 190.06,173.2 189.92,173.34 arc(189.82,173.42) 189.71,173.49 arc(189.51,173.56) 189.3,173.59 189.07,173.59 arc(188.57,173.68) 188.15,173.96 186.38,175.74 arc(186.15,175.89) 185.87,175.95 183.85,175.95 arc(183.13,175.68) 182.77,175 182.76,174.96 arc(182.75,174.49) 182.86,174.04 arc(182.87,174.04) 182.87,174.03 arc(182.89,173.93) 182.91,173.83 182.94,173.69 arc(182.97,173.54) 182.97,173.39 arc(183.02,173.02) CT39.1
  BOTTOM w0.089: v1(195.28,178.8) 195.28,178.81 194.91,179.18 arc(194.86,179.25) 194.85,179.33 JUSBC1.B2
USB3_A_TTX_DRX_N0: length 2.9
  TOP w0.089: UT1.B19 184.3,169.48 arc(184.4,169.62) 184.43,169.79 184.43,170.04 arc(184.42,170.08) 184.4,170.12 arc(184.37,170.16) 184.35,170.22 184.35,170.29 arc(184.37,170.38) 184.38,170.47 184.38,170.93 arc(184.38,170.93) 184.38,170.94 arc(184.42,171.21) 184.44,171.48 184.44,171.49 arc(184.44,171.51) 184.44,171.54 arc(184.49,171.83) CT42.2
USB3_A_TTX_DRX_N1: length 3
  TOP w0.089: UT1.B17 183.26,169.38 183.18,169.46 arc(183.09,169.59) 183.06,169.75 183.06,170.9 arc(183.03,171.01) 182.97,171.11 182.87,171.21 arc(182.81,171.3) 182.79,171.41 182.79,171.74 arc(182.73,171.94) CT40.2
USB3_A_TTX_DRX_P0: length 2.9
  TOP w0.089: UT1.A19 184.2,169.8 arc(184.19,169.75) 184.16,169.7 184.03,169.7 184,169.73 arc(183.98,169.77) 183.96,169.82 183.96,170 arc(183.98,170.06) 184.01,170.11 184.09,170.19 184.12,170.23 arc(184.13,170.25) 184.14,170.26 arc(184.16,170.3) 184.17,170.34 arc(184.19,170.41) 184.19,170.47 184.19,170.66 184.19,170.66 184.19,170.91 arc(184.19,170.94) 184.19,170.98 arc(184.24,171.23) 184.25,171.48 184.25,171.76 arc(184.2,171.96) CT41.2
USB3_A_TTX_DRX_P1: length 3
  TOP w0.089: UT1.A17 183.28,169.75 arc(183.31,169.69) 183.37,169.66 183.42,169.66 183.46,169.7 arc(183.5,169.76) 183.51,169.82 183.51,169.97 arc(183.5,170.04) 183.46,170.09 183.33,170.23 arc(183.27,170.32) 183.25,170.42 183.25,170.9 arc(183.21,171.09) 183.1,171.25 183,171.35 arc(182.98,171.37) 182.98,171.41 182.98,171.74 arc(183.02,171.94) CT39.2
USB3_CC1: length 20.9
  TOP w0.107: JUSBC2.A5 v1(8.38,60.92)
  IN4 w0.097: v1(13.04,61.69) 13.28,61.45 13.28,58.07 12.77,57.56 12.77,54.63 14.61,52.79 14.61,51.77 v1(15.44,50.94) ; v1(8.38,60.92) 8.64,60.92 9.66,61.94 10.23,61.94 11.57,63.28 v1(11.95,63.28)
  BOTTOM w0.107: UU7.11 15.63,51.13 v1(15.44,50.94) ; v1(11.95,63.28) 12.07,63.28 12.53,62.82 DU20.2 v1(13.04,61.69)
USB3_CC2: length 28.2
  TOP w0.107: v1(6.71,59.46) 6.61,59.46 6.39,59.68 JUSBC2.B5
  IN4 w0.097: v1(15.07,52.13) 15.07,53.14 13.03,55.19 13.03,57.12 13.72,57.82 v1(13.72,61.69) ; v1(6.71,59.46) 6.92,59.46 7.5,60.04 7.5,61.88 7.82,62.2 10.11,62.2 13.04,65.13 v1(13.04,65.82)
  BOTTOM w0.107: v1(13.72,61.69) 14.04,62.01 14.04,64.23 13.52,64.75 DU20.3 v1(13.04,65.82) ; UU7.13 v1(15.07,52.13)
USB3_CRX_L_DTX_N1: length 10
  TOP w0.099: LU5.2 21.32,37.48 21.17,37.62 20.86,37.62 20.73,37.49 DU2.1 DU2.9 19.08,37.49 18.95,37.62 18.28,37.62 18.17,37.52 v3(18.17,37.02) 18.17,35.9 18.08,35.81 18.08,35.76 17.67,35.35 17.62,35.35 17.43,35.16 16.15,35.16 15.44,34.45 15.15,34.45 15.05,34.35 JUSB1.5
USB3_CRX_L_DTX_N2: length 7.4
  TOP w0.099: JUSBC2.B10 6.31,62.17 6.46,62.33 6.67,62.33 6.88,62.54 6.88,63.06 7.42,63.59 8.17,63.59 8.51,63.94 v3(8.75,63.94) 9.14,63.94 9.25,64.05 9.37,64.05 9.53,63.89 DU12.7 DU12.4 11.01,63.89 11.17,64.05 11.31,64.05 11.36,63.99 11.61,63.99 11.77,63.84 LU8.2
USB3_CRX_L_DTX_N5: length 5.8
  TOP w0.099: JUSBC2.A10 8,58.42 8.16,58.26 8.41,58.26 8.8,58.65 8.8,59.12 9.43,59.76 DU13.1 DU13.9 11.14,59.76 11.27,59.62 11.72,59.62 11.88,59.78 LU11.3
USB3_CRX_L_DTX_P1: length 10
  TOP w0.099: JUSB1.6 15.05,34.74 15.15,34.64 15.36,34.64 16.07,35.35 17.35,35.35 v3(17.71,35.72) 17.98,35.98 17.98,36.71 17.95,36.74 17.95,37.31 17.98,37.34 17.98,37.6 18.2,37.81 18.93,37.81 19.1,37.99 DU2.8 DU2.2 20.73,37.99 20.9,37.81 21.15,37.81 21.31,37.98 LU5.3
USB3_CRX_L_DTX_P2: length 7.4
  TOP w0.099: JUSBC2.B11 6.3,62.68 6.45,62.52 6.59,62.52 6.69,62.62 6.69,63.14 7.34,63.78 8.07,63.78 8.45,64.16 9.05,64.16 9.13,64.25 9.37,64.25 9.52,64.39 DU12.6 DU12.5 11.04,64.39 11.19,64.24 11.39,64.24 11.44,64.19 11.59,64.19 11.74,64.34 LU8.3
USB3_CRX_L_DTX_P5: length 5.7
  TOP w0.099: LU11.2 11.88,59.28 11.73,59.43 11.31,59.43 11.14,59.26 DU13.8 DU13.2 9.2,59.26 8.99,59.04 8.99,58.52 v3(8.76,58.29) 8.54,58.07 8.11,58.07 7.97,57.92 JUSBC2.A11
USB3_CTX_C_DRX_N1: length 1.5
  TOP w0.099: LU4.1 23.4,39 23.54,39.14 23.83,39.14 CU13.1
USB3_CTX_C_DRX_N2: length 1.5
  TOP w0.099: CU30.1 14.18,62.39 13.79,62.39 13.65,62.25 LU7.1
USB3_CTX_C_DRX_N5: length 1.5
  TOP w0.099: CU38.1 14.74,58.44 14.44,58.14 14.16,58.14 13.98,58.32 LU10.4
USB3_CTX_C_DRX_P1: length 1.5
  TOP w0.099: CU12.1 23.83,39.36 23.54,39.36 23.4,39.5 LU4.4
USB3_CTX_C_DRX_P2: length 1.5
  TOP w0.099: CU31.1 14.63,62.85 14.36,62.58 14.36,62.58 13.79,62.58 13.61,62.75 LU7.4
USB3_CTX_C_DRX_P5: length 1.5
  TOP w0.099: LU10.1 13.98,57.82 14.1,57.94 14.38,57.94 CU39.1
USB3_CTX_C_L_DRX_N1: length 8.6
  TOP w0.099: LU4.2 21.25,39 21.13,39.12 20.86,39.12 20.73,38.99 DU2.4 DU2.7 19.02,38.99 18.85,39.15 v3(18.35,39.15) 17.99,39.15 17.48,39.66 17.48,39.8 16.86,40.42 16.06,40.42 15.31,41.16 15.18,41.16 15.05,41.03 JUSB1.8
USB3_CTX_C_L_DRX_N2: length 5
  TOP w0.099: LU7.2 11.83,62.25 11.67,62.41 11.47,62.41 11.33,62.55 11.18,62.55 11.02,62.39 DU12.1 DU12.9 9.52,62.39 9.36,62.55 8.97,62.55 v3(8.78,62.35) 8.56,62.13 8.26,62.13 8.05,61.92 JUSBC2.A3
USB3_CTX_C_L_DRX_N5: length 9
  TOP w0.099: JUSBC2.B3 6.2,58.68 6.4,58.48 6.52,58.48 6.89,58.11 6.89,57.29 7.13,57.06 8.05,57.06 8.34,56.77 8.94,56.77 9.09,56.92 9.09,57.28 8.96,57.4 8.96,57.85 9.17,58.06 9.28,58.06 9.48,58.26 DU13.4 DU13.7 11.14,58.26 11.29,58.1 11.66,58.1 11.88,58.32 LU10.3
USB3_CTX_C_L_DRX_P1: length 8.7
  TOP w0.099: JUSB1.9 15.05,41.52 15.18,41.39 15.36,41.39 16.14,40.61 16.99,40.61 v3(17.31,40.29) 17.67,39.93 17.67,39.74 18.04,39.38 18.64,39.38 18.67,39.35 18.94,39.35 19.08,39.49 DU2.6 DU2.5 20.73,39.49 20.87,39.34 21.09,39.34 21.25,39.5 LU4.3
USB3_CTX_C_L_DRX_P2: length 5
  TOP w0.099: JUSBC2.A2 8.14,62.42 8.24,62.32 8.43,62.32 8.84,62.74 9.36,62.74 9.52,62.89 DU12.8 DU12.2 11.01,62.89 11.17,62.74 11.41,62.74 11.54,62.61 11.68,62.61 11.82,62.75 LU7.3
USB3_CTX_C_L_DRX_P5: length 8.9
  TOP w0.099: JUSBC2.B2 6.25,58.17 6.36,58.28 6.44,58.28 6.7,58.03 6.7,57.21 7.05,56.86 7.97,56.86 8.29,56.55 v3(8.73,56.55) 8.99,56.55 9.28,56.84 9.28,57.36 9.16,57.48 9.16,57.77 9.25,57.87 9.36,57.87 9.47,57.76 DU13.5 DU13.6 11.14,57.76 11.29,57.91 11.8,57.91 11.9,57.82 LU10.2
USB3_RUF1: length 11.8
  TOP w0.107: v1(8.36,59.47) 8.32,59.42 JUSBC2.A8
  BOTTOM w0.107: v1(8.36,59.47) 8.07,59.47 7.58,59.96 v2(7.58,62.52) 7.58,63.04 8.39,63.85 9.88,63.85 11.18,65.16 11.18,66.26 11.74,66.82 DU21.2
USB3_RUF2: length 11.8
  TOP w0.107: v1(6.71,61.21) 6.68,61.17 JUSBC2.B8
  BOTTOM w0.107: v1(6.71,61.21) 7.25,61.75 7.25,63.09 8.26,64.1 9.66,64.1 v2(10.49,64.93) 10.87,65.31 10.87,68.1 11.52,68.75 DU21.3
USB3RN1: length 205
  TOP w0.099: LU5.1 23.29,37.48 23.41,37.59 24.03,37.59 v1(24.2,37.42)
  IN4 w0.097: v1(189.83,40.11) 189.76,40.11 189.52,39.87 189.27,39.87 180.65,31.25 171.45,31.25 165.86,25.66 123.22,25.66 120.17,28.72 110.57,28.72 110.28,29.01 108.64,29.01 104.64,33.01 104.64,35.33 104.4,35.57 104.4,43.72 99.34,48.78 96.85,48.78 96.45,49.19 84.44,49.19 84.18,48.93 67.26,48.93 66.54,49.65 55.58,49.65 55.13,49.2 45.87,49.2 44.7,48.03 35,48.03 31.97,45 27.4,45 23.38,40.98 23.38,37.69 23.57,37.5 24.13,37.5 v1(24.2,37.42)
  BOTTOM w0.089: 193.34,38.21 193.35,38.2 193.35,38.19 193.38,38.17 193.38,38.17 193.38,38.17 193.39,38.17 194.39,37.18 194.39,37.01 194.67,36.73 194.9,36.73 195.08,36.54 UH1.B7
  BOTTOM w0.099: v1(189.83,40.11) 190.04,39.89 191.66,39.89 193.34,38.21
USB3RN2: length 234.4
  TOP w0.099: LU8.1 13.59,63.84 13.72,63.97 14.17,63.97 14.39,64.2 14.39,64.83 14.55,64.99 15.1,64.99 15.17,64.93 15.17,64.93 v1(15.25,64.85)
  IN3 w0.099: v1(193.38,37.29) 193.23,37.13 192.84,37.13 192.61,36.9 192.61,35.96 193.5,35.07 193.5,34.02 191.59,32.11 191.59,29.98 189.77,28.16 188.86,28.16 186.45,25.75 186.45,25.5 182.62,21.67 181.16,21.67 180.49,21.01 173,21.01 171.02,19.02 146.88,19.02 145.65,17.79 109.06,17.79 107.35,19.49 97.51,19.49 96.47,20.54 87.38,20.54 80.85,27.07 76.54,27.07 75.38,28.23 75.38,31.95 75.89,32.46 75.89,42.94 72.2,46.64 66.24,46.64 64.89,47.99 58.76,47.99 58.18,48.56 56.13,48.56 55.76,48.19 50.16,48.19 49.43,47.46 41.96,47.46 40.73,48.7 35.49,48.7 34.84,49.35 26.7,49.35 25.07,50.98 21.55,50.98 21.51,50.93 20.41,50.93 19.59,51.76 19.59,52.08 18.69,52.99 16.71,52.99 14.97,54.73 14.97,57.02 15.5,57.55 15.5,60.17 15.08,60.59 14.58,60.59 14.35,60.81 14.35,64.8 14.61,65.06 15.05,65.06 v1(15.25,64.85)
  BOTTOM w0.089: 195.26,36.1 195.26,36.1 195.41,35.95 UH1.C8
  BOTTOM w0.099: 195.26,36.1 195.1,36.25 194.63,36.25 194.59,36.29 194.59,36.29 193.85,37.03 193.67,37.03 193.4,37.29 v1(193.38,37.29)
USB3RN3: length 174.5
  IN1 w0.097: v1(165.61,172.58) 165.42,172.39 165.19,172.39 165,172.2 165,171.73 165.13,171.6 165.13,167.56 163.78,166.22 163.78,161.73 166.88,158.63 167.09,158.63 169.04,156.67 169.73,156.67 169.83,156.57 169.83,155.92 170.44,155.3 176.2,155.3 177.09,154.41 187.75,154.41 189.51,152.65 189.51,151.29 190.53,150.27 190.53,149.14 192.36,147.3 192.36,132.54 192.75,132.16 192.75,122.23 193.21,121.78 193.21,112.98 192.66,112.44 192.66,111.27 195.7,108.23 195.7,107.45 201.18,101.97 201.18,89.51 198.89,87.22 198.89,78.83 197.77,77.71 197.77,75.36 196.39,73.99 196.39,72.19 193.21,69.01 193.21,62.06 192.97,61.82 192.97,61.41 191.16,59.6 191.16,53.41 190.66,52.91 190.66,48.85 190.5,48.69 190.5,44.08 194.08,40.49 194.08,38.3 194.46,37.92 194.46,36.24 194.21,35.98 194.08,35.98 193.85,36.21 v1(193.85,36.24)
  BOTTOM w0.089: UH1.B10 195.31,35.32
  BOTTOM w0.099: 195.31,35.32 194.91,35.72 194.62,35.72 194.34,36 194.09,36 v1(193.85,36.24) ; v1(165.61,172.58) 165.61,172.47 165.71,172.37 165.98,172.37 166.06,172.45 166.06,173.67 165.96,173.77 CI38.1
USB3RN3_C: length 3.5
  BOTTOM w0.099: CI38.2 166.04,175.05 166.04,175.23 166.72,175.91 166.72,176.56 166.62,176.66 JCDRA.36
USB3RN4: length 161.7
  TOP w0.099: JIO.26 324.8,22.36 324.7,22.45 324.7,22.56 324.6,22.66 324.07,22.66 323.73,22.32 323.73,21.97 v1(324.04,21.67)
  IN4 w0.097: v1(196.91,34.22) 196.91,34.88 197.41,35.38 201.11,35.38 201.58,35.85 201.58,37.12 202.46,38.01 202.46,41.13 203,41.67 205.22,41.67 205.65,42.1 207.27,42.1 207.96,42.79 210.39,42.79 210.82,42.35 210.82,41.88 211.42,41.29 214.11,41.29 214.3,41.48 215.46,41.48 216.12,42.15 218.31,42.15 219.13,41.33 224.12,41.33 224.71,41.91 226.29,41.91 227.3,40.9 227.3,40.35 228.75,38.91 228.75,38.58 232.23,35.1 232.23,32.15 234.56,29.82 234.79,29.82 246.19,18.42 257.11,18.42 266.96,28.27 274.44,28.27 276.3,30.13 281.81,30.13 282.15,29.79 288.16,29.79 289.59,31.21 315.03,31.21 321.66,24.59 321.66,23.51 322.42,22.75 323.84,22.75 324.04,22.55 v1(324.04,21.67)
  BOTTOM w0.089: v1(196.91,34.22) 196.91,34.56 UH1.E11
USB3RN5: length 227.8
  TOP w0.099: LU11.4 14.08,59.78 14.15,59.84 14.62,59.84 v1(14.77,59.99)
  IN3 w0.099: v1(14.77,59.99) 14.62,59.84 13.9,59.84 13.48,59.42 13.48,54.3 15.63,52.14 15.63,52.14 18.1,49.67 21.74,49.67 23.87,47.54 26.65,47.54 27.48,48.36 34.3,48.36 35.12,47.54 40.19,47.54 41.2,46.53 52.39,46.53 53.2,47.34 56.11,47.34 56.48,47.71 57.83,47.71 58.49,47.05 64.5,47.05 65.79,45.75 71.88,45.75 75.04,42.59 75.04,32.81 74.53,32.3 74.53,27.86 76.18,26.22 80.5,26.22 87.62,19.1 96.15,19.1 96.6,18.64 97.15,18.64 98.86,16.94 146,16.94 147.23,18.17 180.07,18.17 182.72,20.82 183.1,20.82 187.08,24.8 189.94,24.8 192.43,27.29 192.43,29.7 196.35,33.62 196.92,33.62 197.05,33.49 197.05,33.35 v1(196.85,33.14)
  BOTTOM w0.097: UH1.G13 197.34,33.64 v1(196.85,33.14)
USB3RP1: length 205
  TOP w0.099: v1(24.2,38.01) 24.04,37.84 23.42,37.84 23.28,37.98 LU5.4
  IN4 w0.097: v1(24.2,38.01) 23.87,37.67 23.65,37.67 23.55,37.77 23.55,40.91 27.47,44.83 32.05,44.83 35.07,47.86 44.77,47.86 45.94,49.02 55.2,49.02 55.66,49.48 66.47,49.48 67.19,48.76 84.25,48.76 84.51,49.02 96.38,49.02 96.78,48.61 99.27,48.61 104.23,43.65 104.23,35.5 104.47,35.26 104.47,32.93 108.57,28.84 110.21,28.84 110.5,28.54 120.1,28.54 123.15,25.49 165.93,25.49 171.52,31.08 180.72,31.08 189.34,39.7 189.9,39.7 190,39.6 190,39.46 v1(189.83,39.29)
  BOTTOM w0.089: 193.27,38.01 193.29,37.99 193.31,37.99 194.2,37.1 194.2,36.94 194.65,36.49 UH1.A7
  BOTTOM w0.099: 193.27,38.01 191.58,39.7 189.72,39.7 189.62,39.6 189.62,39.46 189.79,39.29 v1(189.83,39.29)
USB3RP2: length 234.6
  TOP w0.099: LU8.4 13.61,64.34 13.79,64.17 14.09,64.17 14.2,64.28 14.2,64.91 14.47,65.18 14.99,65.18 v1(15.25,65.44)
  IN3 w0.099: v1(193.38,36.69) 193.38,36.74 193.18,36.95 192.92,36.95 192.79,36.82 192.79,36.04 193.68,35.15 193.68,33.94 191.78,32.04 191.78,29.91 189.85,27.98 188.93,27.98 186.64,25.68 186.64,25.42 182.7,21.49 181.24,21.49 180.57,20.82 173.08,20.82 171.09,18.83 146.95,18.83 145.72,17.6 108.98,17.6 107.28,19.31 97.44,19.31 96.39,20.36 87.3,20.36 80.78,26.88 76.46,26.88 75.2,28.15 75.2,32.02 75.71,32.54 75.71,42.87 72.12,46.46 66.16,46.46 64.81,47.8 58.68,47.8 58.11,48.38 56.21,48.38 55.84,48 50.23,48 49.51,47.28 41.89,47.28 40.65,48.51 35.42,48.51 34.77,49.16 26.63,49.16 25,50.79 21.63,50.79 21.59,50.75 20.34,50.75 19.41,51.68 19.41,52.01 18.61,52.81 16.63,52.81 14.79,54.65 14.79,57.1 15.31,57.63 15.31,60.09 15,60.4 14.5,60.4 14.17,60.74 14.17,64.87 14.54,65.24 15.05,65.24 v1(15.25,65.44)
  BOTTOM w0.099: v1(193.38,36.69) 193.38,36.74 193.48,36.84 193.77,36.84 194.51,36.1 194.51,36.1 194.55,36.06 195.02,36.06 195.14,35.95 195.14,35.86 UH1.B8
USB3RP3: length 174.5
  IN1 w0.097: v1(165.62,171.93) 165.62,172 165.42,172.19 165.28,172.19 165.17,172.08 165.17,171.8 165.3,171.67 165.3,167.49 163.96,166.15 163.96,161.8 166.96,158.8 167.16,158.8 169.11,156.84 169.8,156.84 170,156.65 170,155.99 170.51,155.48 176.27,155.48 177.16,154.59 187.82,154.59 189.68,152.73 189.68,151.36 190.7,150.34 190.7,149.21 192.54,147.38 192.54,132.62 192.92,132.23 192.92,122.31 193.38,121.85 193.38,112.91 192.84,112.36 192.84,111.34 195.88,108.3 195.88,107.52 201.35,102.04 201.35,89.43 199.06,87.14 199.06,78.76 197.94,77.64 197.94,75.29 196.56,73.92 196.56,72.12 193.38,68.93 193.38,61.99 193.15,61.75 193.15,61.34 191.33,59.53 191.33,53.34 190.83,52.84 190.83,48.78 190.67,48.61 190.67,44.15 194.26,40.56 194.26,38.38 194.64,38 194.64,36.16 194.26,35.78 194.26,35.66 v1(194,35.4)
  BOTTOM w0.099: CI39.1 166.25,173.46 166.25,172.37 166.06,172.18 165.87,172.18 v1(165.62,171.93) ; v1(194,35.4) 193.8,35.4 193.7,35.5 193.7,35.69 193.82,35.81 194.26,35.81 194.6,35.47 194.74,35.47 UH1.A9
USB3RP3_C: length 3.5
  BOTTOM w0.099: JCDRA.37 167.02,176.66 166.92,176.56 166.92,175.83 166.24,175.15 166.24,175.01 CI39.2
USB3RP4: length 161.8
  TOP w0.099: JIO.27 323.99,22.85 323.54,22.4 323.54,21.76 v1(323.45,21.67)
  IN4 w0.097: v1(323.45,21.67) 323.86,22.08 323.86,22.48 323.77,22.57 322.34,22.57 321.48,23.44 321.48,24.52 314.96,31.04 289.66,31.04 288.24,29.62 282.08,29.62 281.74,29.96 276.37,29.96 274.51,28.1 267.03,28.1 257.18,18.25 246.12,18.25 234.72,29.65 234.49,29.65 232.06,32.08 232.06,35.02 228.58,38.5 228.58,38.84 227.13,40.28 227.13,40.83 226.22,41.74 224.78,41.74 224.19,41.15 219.06,41.15 218.24,41.98 216.2,41.98 215.53,41.31 214.38,41.31 214.18,41.11 211.35,41.11 210.65,41.81 210.65,42.28 210.31,42.62 208.03,42.62 207.34,41.93 205.72,41.93 205.29,41.5 203.07,41.5 202.64,41.06 202.64,37.94 201.75,37.05 201.75,35.78 201.18,35.21 197.48,35.21 197.08,34.8 197.08,34.57 197.27,34.37 197.27,34.23 197.33,34.17 v1(197.51,34.17)
  BOTTOM w0.089: v1(197.51,34.17) 197.66,34.17 197.75,34.26 197.75,34.51 197.62,34.64 UH1.G11
USB3RP5: length 227.9
  TOP w0.099: LU11.1 13.85,59.28 14.23,59.65 14.52,59.65 v1(14.77,59.4)
  IN3 w0.099: v1(197.39,33.14) 197.24,33.3 197.24,33.57 197,33.81 196.27,33.81 192.24,29.78 192.24,27.36 189.87,24.99 187.01,24.99 183.03,21.01 182.65,21.01 179.99,18.35 147.15,18.35 145.92,17.12 98.94,17.12 97.23,18.83 96.68,18.83 96.22,19.28 87.7,19.28 80.58,26.4 76.25,26.4 74.72,27.94 74.72,32.22 75.23,32.74 75.23,42.67 71.96,45.94 65.87,45.94 64.58,47.23 58.57,47.23 57.91,47.9 56.41,47.9 56.03,47.52 53.12,47.52 52.31,46.71 41.27,46.71 40.27,47.72 35.2,47.72 34.38,48.55 27.4,48.55 26.58,47.72 23.95,47.72 21.81,49.86 18.18,49.86 15.82,52.22 15.82,52.22 13.66,54.38 13.66,59.34 13.98,59.66 14.51,59.66 v1(14.77,59.4)
  BOTTOM w0.089: UH1.H13 197.9,33.59 197.46,33.14 v1(197.39,33.14)
USB3TN1: length 201.9
  TOP w0.099: v1(25.85,38.95) 25.65,39.15 25.42,39.15 CU13.2
  IN4 w0.097: v1(25.85,38.95) 25.65,39.15 25.1,39.15 24.86,39.39 24.86,40.62 28.59,44.35 32.24,44.35 35.27,47.38 45.56,47.38 46.72,48.55 57.55,48.55 57.95,48.15 62.03,48.15 62.15,48.03 64.75,48.03 64.94,48.21 84.62,48.21 84.88,47.96 87.66,47.96 87.85,48.15 94.7,48.15 95.46,47.39 99.35,47.39 103.59,43.14 103.59,35.44 103.99,35.04 103.99,32.74 108.37,28.36 109.85,28.36 111.3,26.91 121.06,26.91 122.95,25.01 166.13,25.01 171.72,30.6 181.18,30.6 189.08,38.5 190.01,38.5 v1(190.24,38.74)
  BOTTOM w0.089: UH1.C11 195.5,34.99 195.35,34.99 195.3,35.05 195.29,35.05 195.28,35.06 195.18,35.06 195.11,35.13 195.09,35.13 195.09,35.13 195.03,35.13 195.02,35.14 195.01,35.14
  BOTTOM w0.099: v1(190.24,38.74) 190.45,38.52 191.39,38.52 192.44,37.47 192.44,35.7 192.66,35.48 193.17,35.48 193.63,35.02 194.64,35.02 194.76,35.14 195.01,35.14
USB3TN2: length 222.3
  TOP w0.099: v1(16.16,62.06) 16.16,62.12 16.01,62.26 15.82,62.26 15.55,61.99 CU30.2
  IN3 w0.099: v1(16.16,62.06) 15.89,62.33 15.63,62.33 15.5,62.2 15.5,61.5 16.33,60.67 16.33,57.44 15.73,56.84 15.73,55.5 17.15,54.07 18.68,54.07 19.82,52.93 24.08,52.93 26.5,50.52 34.75,50.52 35.9,49.36 41.55,49.36 42.63,48.29 44.76,48.29 45.33,48.85 55.48,48.85 55.85,49.23 57.86,49.23 58.17,49.54 65.44,49.54 67.46,47.53 72.25,47.53 76.56,43.22 76.56,32.18 76.05,31.67 76.05,28.52 76.83,27.73 81.13,27.73 87.44,21.43 96.67,21.43 97.5,20.6 101.48,20.6 101.92,20.16 107.63,20.16 109,18.79 145.7,18.79 146.6,19.69 169.01,19.69 171.91,22.59 182.33,22.59 185.18,25.45 185.18,25.88 187.52,28.22 187.96,28.22 188.86,29.12 188.86,29.7 190.89,31.73 190.89,32.84 192.73,34.68 192.73,34.69 v1(192.92,34.88)
  BOTTOM w0.089: 193.27,34.59 193.28,34.59 193.28,34.58 193.35,34.58 193.36,34.57 194.79,34.57 195.04,34.32 195.14,34.32 UH1.B12
  BOTTOM w0.099: 193.27,34.59 193.22,34.59 v1(192.92,34.88)
USB3TN3: length 199.1
  IN3 w0.099: v1(189.81,36.67) 189.61,36.87 189.09,36.87 188.55,37.42 188.55,41.57 188.99,42.02 188.99,47.45 187.06,49.38 187.06,61.81 187.64,62.39 187.64,66.52 187.38,66.78 186.69,66.78 186.4,67.06 186.4,68.85 186.5,68.94 186.5,71.27 186.81,71.58 186.81,73.36 187.51,74.06 187.51,85.49 191.24,89.22 197.19,89.22 198.3,90.33 201.49,90.33 203.89,92.73 203.89,99.28 200.59,102.58 200.59,106.53 196.13,110.98 196.13,153.81 197.02,154.7 197.02,160.6 198.51,162.1 198.51,164.32 198.74,164.55 198.74,167.18 200.12,168.56 200.12,170.08 199.25,170.95 196.2,170.95 195.16,171.99 194.32,171.99 193.04,173.27 190.88,173.27 190.76,173.39 184.2,173.39 183.06,174.53 173.55,174.53 173.03,175.04 169.56,175.04 169.35,175.25 169.35,175.72 168.96,176.11 v1(168.95,176.11)
  BOTTOM w0.089: UH1.C13 195.51,33.63 195.38,33.77 194.54,33.77 194.49,33.82 193.6,33.82 193.41,33.63 193.35,33.63 193.35,33.63 193.29,33.63 193.29,33.62 193.27,33.62
  BOTTOM w0.099: v1(168.95,176.11) 169.11,176.27 169.11,176.69 169.02,176.78 JCDRA.42 ; v1(189.81,36.67) 189.66,36.67 189.56,36.77 189.56,36.93 189.78,37.15 191.15,37.15 191.65,36.65 191.65,34.4 191.65,34.24 191.69,34.2 191.69,34.2 192.27,33.62 192.27,33.62 193.27,33.62
USB3TN4: length 163.7
  TOP w0.099: JIO.29 324.8,23.85 324.7,23.95 324.7,24.06 324.6,24.16 323.88,24.16 323.68,23.97 323.68,23.67 v1(323.99,23.36)
  IN4 w0.097: v1(193.68,33.37) 193.68,34.18 194.69,35.19 196.34,35.19 197.13,35.98 197.13,37.31 198.08,38.27 198.08,39.55 200.73,42.2 204.74,42.2 205.3,42.75 207,42.75 207.69,43.44 210.91,43.44 211.35,43 214.15,43 214.36,42.8 218.58,42.8 219.4,41.98 223.85,41.98 224.59,42.71 226.44,42.71 227.95,41.2 227.95,40.65 231.59,37.01 231.59,36.65 233.99,34.25 233.99,33.64 234.85,32.78 235.35,32.78 235.89,32.23 235.89,29.72 246.07,19.54 257.31,19.54 267.14,29.37 274.39,29.37 275.9,30.88 288.23,30.88 289.96,32.61 315.16,32.61 322.97,24.8 323.41,24.8 323.99,24.23 v1(323.99,23.36)
  BOTTOM w0.089: v1(193.68,33.37) 193.68,32.99 193.89,32.78 194.38,32.78 UH1.A14
USB3TN5: length 219.5
  TOP w0.099: CU38.2 15.66,58.36 15.88,58.13 16.35,58.13 17.17,57.31 17.17,56.8 17.36,56.61 v1(17.48,56.61)
  IN3 w0.099: v1(17.48,56.61) 17.26,56.33 17.26,55.06 17.48,54.83 18.88,54.83 20.04,53.67 24.36,53.67 26.85,51.18 35.03,51.18 36.08,50.13 45.97,50.13 46.58,49.52 55.21,49.52 55.58,49.89 57.58,49.89 57.92,50.23 65.7,50.23 67.73,48.19 72.53,48.19 77.22,43.5 77.22,31.91 76.71,31.4 76.71,28.79 77.1,28.4 81.41,28.4 87.49,22.32 96.72,22.32 97.76,21.28 101.74,21.28 102.2,20.82 108.04,20.82 109.41,19.45 145.22,19.45 146.22,20.45 168.83,20.45 171.64,23.26 180.11,23.26 181.77,24.92 182.65,24.92 183.53,25.79 183.53,26.49 188.99,31.96 188.99,35.38 189.2,35.59 189.98,35.59 v1(190.17,35.78)
  BOTTOM w0.089: UH1.B14 195.45,33.16 195.45,33.22 195.37,33.3 195.09,33.3 195.02,33.22 195.02,33 194.62,32.6 193.78,32.6 193.78,32.6
  BOTTOM w0.099: 193.78,32.6 193.39,32.99 192.09,32.99 191.21,33.88 191.21,35.38 191,35.59 190.36,35.59 v1(190.17,35.78)
USB3TP1: length 201.9
  TOP w0.099: v1(25.85,39.53) 25.66,39.34 25.43,39.34 CU12.2
  IN4 w0.097: v1(190.24,37.93) 190.35,37.93 190.45,38.02 190.45,38.23 190.35,38.33 189.15,38.33 181.25,30.43 171.79,30.43 166.2,24.84 122.88,24.84 120.99,26.73 111.23,26.73 109.78,28.19 108.3,28.19 103.82,32.67 103.82,34.97 103.42,35.37 103.42,43.07 99.28,47.21 95.39,47.21 94.62,47.97 87.92,47.97 87.73,47.78 84.81,47.78 84.55,48.04 65.01,48.04 64.82,47.86 62.08,47.86 61.96,47.97 57.88,47.97 57.48,48.37 46.8,48.37 45.63,47.2 35.34,47.2 32.31,44.18 28.66,44.18 25.03,40.55 25.03,39.47 25.17,39.32 25.64,39.32 v1(25.85,39.53)
  BOTTOM w0.089: UH1.B11 195.04,34.95 195.01,34.95
  BOTTOM w0.099: v1(190.24,37.93) 190.21,37.93 190.04,38.09 190.04,38.23 190.14,38.33 191.31,38.33 192.25,37.39 192.25,35.62 192.58,35.29 193.09,35.29 193.55,34.83 194.89,34.83 195.01,34.95
USB3TP2: length 222.2
  TOP w0.099: CU31.2 15.55,62.79 15.88,62.46 15.97,62.46 v1(16.16,62.64)
  IN3 w0.099: v1(192.92,34.3) 192.84,34.39 192.7,34.39 191.08,32.76 191.08,31.65 189.04,29.62 189.04,29.05 188.03,28.04 187.6,28.04 185.37,25.8 185.37,25.37 182.41,22.41 171.99,22.41 169.08,19.5 146.68,19.5 145.78,18.6 108.92,18.6 107.55,19.97 101.84,19.97 101.4,20.41 97.42,20.41 96.59,21.24 87.36,21.24 81.05,27.55 76.75,27.55 75.86,28.44 75.86,31.75 76.37,32.26 76.37,43.14 72.18,47.34 67.38,47.34 65.36,49.36 58.25,49.36 57.93,49.04 55.93,49.04 55.56,48.67 45.41,48.67 44.84,48.1 42.55,48.1 41.47,49.18 35.83,49.18 34.67,50.33 26.42,50.33 24.01,52.74 19.74,52.74 18.6,53.89 17.08,53.89 15.54,55.42 15.54,56.91 16.14,57.51 16.14,60.6 15.32,61.42 15.32,62.28 15.55,62.51 16.03,62.51 v1(16.16,62.64)
  BOTTOM w0.089: UH1.A12 194.77,34.21 194.77,34.33 194.71,34.39 193.29,34.39 193.27,34.39
  BOTTOM w0.099: v1(192.92,34.3) 193.01,34.39 193.22,34.39 193.22,34.39 193.27,34.39
USB3TP3: length 199.1
  IN3 w0.099: v1(189.73,37.56) 189.89,37.39 189.89,37.25 189.7,37.06 189.17,37.06 188.73,37.5 188.73,41.5 189.18,41.94 189.18,47.53 187.25,49.46 187.25,61.73 187.83,62.31 187.83,66.6 187.46,66.96 186.76,66.96 186.59,67.14 186.59,68.77 186.68,68.87 186.68,71.19 187,71.51 187,73.29 187.7,73.98 187.7,85.41 191.32,89.03 197.26,89.03 198.37,90.14 201.56,90.14 204.07,92.65 204.07,99.36 200.77,102.66 200.77,106.61 196.32,111.06 196.32,153.73 197.2,154.62 197.2,160.52 198.7,162.02 198.7,164.24 198.93,164.47 198.93,167.1 200.31,168.48 200.31,170.15 199.33,171.13 196.28,171.13 195.23,172.18 194.4,172.18 193.12,173.45 190.96,173.45 190.84,173.57 184.28,173.57 183.14,174.72 173.62,174.72 173.11,175.23 169.64,175.23 169.54,175.33 v1(169.54,176.11)
  BOTTOM w0.089: UH1.D13 196.13,33.66 195.92,33.87 195.6,33.87 195.51,33.96 194.63,33.96 194.59,34 193.52,34 193.34,33.81 193.27,33.81
  BOTTOM w0.099: v1(189.73,37.56) 189.94,37.35 191.23,37.35 191.85,36.73 191.85,34.32 192.35,33.81 193.27,33.81 ; JCDRA.43 169.42,176.81 169.3,176.69 169.3,176.34 v1(169.54,176.11)
