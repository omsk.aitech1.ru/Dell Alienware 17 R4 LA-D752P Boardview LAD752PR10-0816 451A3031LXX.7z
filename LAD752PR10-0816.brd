# Allegro board LAD752PR10-0816.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SUSP#_R: length 7
  TOP w0.089: 175.47,168.27 175.47,168.27 175.57,168.27 175.6,168.24 176.16,168.24 UT1.D2
  TOP w0.127: RT30.2 172.27,166.19 v1(172.34,166.25) 172.34,166.52 173.55,167.74 174.39,167.74 174.93,168.27 175.47,168.27
  BOTTOM w0.107: RT15.1 172.11,166.02 v1(172.34,166.25) v2(172.92,166.25)
SVC: length 13.2
  TOP w0.254: PR6002.1 288.35,58.2 v2(290.61,58.2) 290.73,58.2 v1(291.04,57.89) 294.26,57.89 295.46,59.09 PR6006.2
  BOTTOM w0.203: PU8201.4 290.07,57.94 290.28,58.15 290.78,58.15 v1(291.04,57.89) 291.45,57.89 PR6011.2
SVD: length 11.4
  TOP w0.254: PR6004.2 v2(296.08,60.87) 295.42,60.87 294.22,59.66 291.35,59.66 291.28,59.6 v1(291.03,59.6) PR6001.1
  BOTTOM w0.203: PU8201.2 289.85,58.74 290.71,59.6 v1(291.03,59.6) 291.52,59.6 PR6007.2
SVI2_SVC: length 96
  IN4 w0.203: v1(294.39,58.71) 294,58.31 293.44,58.31 292.49,59.27 292.49,60.99 292.89,61.39 294.68,61.39 295.03,61.74 295.03,62.52 293.32,64.23 293.32,66.01 287.88,71.44 283.07,71.44 282.39,70.77 280.74,70.77 279.41,72.1 276.04,72.1 275.25,71.31 275.25,69.63 272.05,66.43 247.68,66.43 246.48,67.63 246.48,68.96 240.55,74.89 240.55,78.07 240.1,78.52 239.47,78.52 238.71,79.28 238.71,84.8 238.13,85.38 236.74,85.38 236.06,86.05 236.06,87.99 v1(236.82,88.75)
  BOTTOM w0.1: v1(236.82,88.75) 236.67,88.75 UG1.AM23
  BOTTOM w0.203: PR6011.1 293.82,57.63 v2(293.98,57.79) 294.39,58.2 v1(294.39,58.71)
SVI2_SVD: length 89.1
  IN4 w0.203: v1(236.82,87.15) 237.15,86.82 238.34,86.82 238.54,86.62 238.54,86.14 238.87,85.81 239.62,85.81 240,85.43 240,84.65 240.2,84.45 240.52,84.45 240.93,84.04 240.93,78.84 241.31,78.45 241.31,75.06 247.14,69.23 247.14,67.98 248.03,67.09 266.06,67.09 267.41,68.43 273.12,68.43 274.49,69.8 274.49,71.63 275.73,72.87 279.73,72.87 281.06,71.53 282.08,71.53 282.75,72.21 288.2,72.21 295.79,64.61 295.79,61.57 294.9,60.67 294.42,60.67 v1(293.89,60.14)
  BOTTOM w0.1: v1(236.82,87.15) 236.67,87.15 UG1.AP23
  BOTTOM w0.203: PR6007.1 293.15,59.4 v1(293.89,60.14)
SVI2_SVT: length 92.6
  IN4 w0.203: v1(236.82,87.95) 236.82,87.94 236.36,87.47 236.36,86.39 236.76,85.99 238.07,85.99 238.71,85.35 239.33,85.35 239.71,84.97 239.71,83.36 239.72,83.34 239.72,79.41 240.93,78.2 240.93,74.98 246.81,69.1 246.81,67.84 247.89,66.76 271.91,66.76 274.87,69.71 274.87,71.47 275.89,72.49 279.57,72.49 280.9,71.15 282.24,71.15 282.91,71.83 288.04,71.83 293.65,66.22 293.65,64.41 295.36,62.69 295.36,61.61 294.81,61.06 293.13,61.06 292.82,60.75 292.82,59.58 v1(293.63,58.77)
  BOTTOM w0.1: v1(236.82,87.95) 236.67,87.95 UG1.AN23
  BOTTOM w0.107: v1(293.63,58.77) v2(293.63,59.34)
  BOTTOM w0.203: PR6010.1 293.38,58.52 v1(293.63,58.77)
SW_1.2V: length 1.3
  IN4 w1.016: 89.73,41.43 89.73,40.1
  vias: v1(87.38,39.81) v1(87.38,39.21) v1(87.38,38.58) v1(87.38,37.94) v1(87.38,37.31) v1(87.7,36.8) v1(88.02,39.21) v1(88.02,38.58) v1(88.02,37.94) v1(88.02,37.31) v1(88.34,36.8) v1(88.65,38.58) v1(88.65,37.94) v1(88.65,37.31) v1(88.97,36.8) v1(89.16,37.62) v1(89.95,39.77) v1(90.28,42.36) v1(90.37,39.33) v1(90.76,42.72) v2(87.96,41.18)
SW_+1VALWP: length 1.8
  IN4 w1.016: 248.41,24.86 250.21,24.86
  vias: v1(248.04,24.06) v1(248.04,23.47) v1(250.39,29.62) v1(250.39,28.99) v1(250.39,28.35) v1(251.02,29.62) v1(251.02,28.99) v1(251.02,28.35) v1(251.09,25.11) v1(251.09,24.52) v1(251.66,29.62) v1(251.66,28.99) v1(251.66,28.35) v1(252.29,29.62) v1(252.29,28.99) v1(252.29,28.35) v1(252.93,29.62) v1(252.93,28.99) v1(252.93,28.35) v2(251.6,27.27)
SW_USB20_N1: length 16
  TOP w0.099: UU1.11 22.08,46.62 22.09,46.62 22.09,47.01 22.46,47.39 23.38,47.39 23.4,47.41 23.98,47.41 24.01,47.39 24.91,47.39 25.21,47.09 25.21,46.83 v1(25.4,46.64)
  BOTTOM w0.099: v1(25.4,46.64) 25.29,46.53 25.15,46.53 24.97,46.71 24.97,46.74 24.96,46.74 24.96,46.9 25.21,47.15 26.34,47.15 26.61,46.88 26.61,43.1 25.52,42.01 23.77,42.01 23.56,41.8 23.56,41.47 23.46,41.37 23.38,41.37 23.25,41.25 LU3.1
SW_USB20_P1: length 16
  TOP w0.099: v1(24.57,46.64) 24.66,46.56 24.81,46.56 25.01,46.75 25.01,46.77 25.01,46.77 25.01,47.01 24.83,47.19 v3(23.69,47.19) 22.54,47.19 22.28,46.93 22.28,46.71 22.34,46.65 22.5,46.65 22.58,46.57 UU1.10
  BOTTOM w0.099: v1(24.57,46.64) 24.76,46.83 24.76,46.97 25.13,47.34 26.42,47.34 26.81,46.96 26.81,43.02 25.6,41.82 23.85,41.82 23.75,41.72 LU3.4
SYNC_OUT: length 1.8
  TOP w0.107: UA4.38 30.01,8.81 29.72,9.1 29.57,9.1 v1(29.53,9.06)
  BOTTOM w0.107: v1(29.53,9.06) 29.52,9.05 29.16,9.05 TC24.1
SYS_PWROK: length 173.1
  TOP w0.107: v1(293.28,60.27) 293.28,61.68 294.87,63.27 298.76,63.27 298.76,63.27 299.09,63.27 303.47,58.89 303.47,49.48 300.16,46.17 300.16,45.76 299.62,45.22 299.62,43.57 298.61,42.56 298.61,40.81 297.41,39.61 297.41,31.68 297.72,31.37 v1(297.72,28.99) ; CE46.1 296.74,7.34 UE5.74 296.74,9.05 296.49,9.3 v1(296.49,9.81)
  IN3 w0.091: v1(296.49,9.81) 298.97,12.29 303.03,12.29 304.33,13.59 304.33,22.37 v1(297.72,28.99) 297,29.71 291.95,29.71 288.5,33.15 284.44,33.15 283.48,34.11 278.26,34.11 276.63,35.74 258.02,35.74 257.2,36.56 248.69,36.56 247.96,35.83 239.84,35.83 236.56,32.54 235.72,32.54 235.34,32.93 234.01,32.93 233.43,32.35 230.91,32.35 230.3,32.96 227.26,32.96 v1(227.11,33.1)
  IN4 w0.089: 219.18,34.7 216.86,34.7 215.72,35.85
  IN4 w0.097: v1(213.71,37.23) 214.18,37.23 215.56,35.85 215.72,35.85 ; 219.18,34.7 220.91,32.97 223.18,32.97 224.33,34.12 225.9,34.12 226.91,33.1 v1(227.11,33.1)
  BOTTOM w0.089: UH1.AY1 214.34,39.11 214.34,38.23 213.71,37.6 v1(213.71,37.23)
  BOTTOM w0.107: v1(293.28,60.27) 293.25,60.29 PR6008.1
SYS_RESET#: length 8.5
  BOTTOM w0.089: UH1.AW1 213.46,39.49 213.81,39.84 214.02,39.84 215.86,41.68 215.86,42.08
  BOTTOM w0.107: v2(212.99,42.77) 213.24,42.77 213.59,43.11 RH5.2 CH175.1 ; RH571.1 214.9,43.14 CH175.1 ; CH175.1 215.86,42.16 215.86,42.08
SYSON: length 356.2
  TOP w0.107: Q9.3 326.42,40.63 325.72,39.93 325.72,34.2 325.03,33.52 323.3,33.52 322.04,32.27 322.04,25.84 v1(321.54,25.34) ; v1(305.63,4.48) 305.63,5.43 CE42.1 304.99,6.83 305.14,6.98 UE5.95 ; U19.4 178.9,77.51 178.48,77.09 v1(178.37,77.09)
  IN2 w0.091: v1(321.54,25.34) 313.31,25.34 311.07,23.1 307.09,23.1 306.14,22.14 303,22.14 301.1,20.24 299.9,20.24 298.88,21.26 294.63,21.26 293.04,22.85 289.73,22.85 287.68,24.9 286.57,24.9 285.73,25.74 285.2,25.74 281.01,29.92 270.19,29.92 269.77,30.34 269.77,31.45 263.93,37.29 240.62,37.29 238.57,39.35 228.69,39.35 226.59,41.45 222.63,41.45 221.92,42.16 216.43,42.16 215.63,41.36 214.41,41.36 214.1,41.05 213.7,41.05 212.07,42.68 207.9,42.68 207.4,42.18 205.49,42.18 205.01,41.7 204.96,41.7 204.94,41.68 204.61,41.68 204.6,41.7 202.98,41.7 202.96,41.68 202.63,41.68 202.45,41.86 202.4,41.86 202.26,42 199.17,42 198.14,40.97 184.36,40.97 178.32,34.94 159.77,34.94 v1(159.33,35.38) 156.07,35.38 154.94,34.25 138.43,34.25 134.43,38.25 112.66,38.25 110.5,40.41 109.11,40.41 106.18,43.34 v1(97.42,43.34)
  IN3 w0.091: v1(305.63,4.48) 305.63,6.27 307.28,7.92 315.15,7.92 317.39,10.16 317.39,11.09 320.81,14.51 320.81,24.61 v1(321.54,25.34) ; v1(159.33,35.38) 159.33,35.85 156.79,38.39 156.79,40.67 157.17,41.05 157.17,45.12 156.81,45.48 156.81,51 158.95,53.14 158.95,60.93 175.12,77.09 v1(178.37,77.09)
  BOTTOM w0.107: PR208.2 97.16,43.59 v1(97.42,43.34)
TB_STAT#_CHG: length 9
  TOP w0.203: PR718.1 v1(56.14,19.27) 56.64,19.77 PU700.16
  TOP w0.254: PQ705.2 60.83,19.41 60.52,19.72 v1(60.52,19.91)
  IN3 w0.254: v1(60.52,19.91) 60.52,19.68 60.27,19.42 58.66,19.42 57.86,20.23 56.78,20.23 56.14,19.59 v1(56.14,19.27)
  BOTTOM w0.107: v1(56.14,19.27) 55.95,19.27 v2(55.69,19.01)
TBT_A_AUX_N: length 2.6
  TOP w0.089: v1(182.61,161.87) 182.28,161.53 UT1.W15
  BOTTOM w0.089: v1(182.61,161.87) 182.61,161.77 182.35,161.51 182.08,161.51 181.88,161.31 181.88,160.99 182.05,160.81 CT44.2
TBT_A_AUX_N_C: length 33.4
  IN3 w0.089: v1(182.37,156.26) 182.57,156.47 182.57,157.13 182.84,157.4 188.1,157.4 189.36,156.14 191.41,156.14 192.1,156.83 192.1,162.62 193.97,164.5 194.53,164.5 195.22,165.18 195.22,166.48 195.78,167.04 196.29,167.04 196.55,166.77 196.55,166.49 v1(196.77,166.28)
  BOTTOM w0.076: UT4.J2 198.66,164.12 198.46,164.32 197.95,164.32 197.48,164.79 197.48,164.87 196.62,165.73 196.62,166.12 v1(196.77,166.28)
  BOTTOM w0.089: CT44.1 182.26,159.47 182.26,158.65 182.23,158.63 182.23,158.05 182.26,158.02 182.26,157.69 182.52,157.42 182.52,156.41 v1(182.37,156.26) ; RT70.2 196.68,167.01 196.68,166.37 v1(196.77,166.28)
TBT_A_AUX_P: length 2.6
  TOP w0.089: UT1.Y15 182.35,160.81 182.52,160.81 182.61,160.9 v1(182.61,161.2)
  BOTTOM w0.089: v1(182.61,161.2) 182.5,161.32 182.15,161.32 182.07,161.23 182.07,161.06 182.38,160.75 182.53,160.75 182.62,160.66 CT43.2
TBT_A_AUX_P_C: length 33.5
  IN3 w0.089: v1(195.97,166.28) 195.97,166.17 196.07,166.07 196.27,166.07 196.37,166.17 196.37,166.7 196.21,166.86 195.85,166.86 195.4,166.4 195.4,165.11 194.61,164.32 194.05,164.32 192.28,162.54 192.28,156.76 191.48,155.96 189.28,155.96 188.03,157.22 182.91,157.22 182.75,157.06 182.75,156.46 v1(182.95,156.26)
  BOTTOM w0.076: 196.22,166.28 196.29,166.28 196.45,166.11 196.45,165.66 197.32,164.8 197.32,164.72 197.97,164.07 UT4.J1
  BOTTOM w0.089: RT73.1 196.48,167.21 196.48,166.78 v1(195.97,166.28) 196.22,166.28 ; CT43.1 182.44,159.49 v3(182.44,158.34) 182.44,157.77 182.71,157.5 182.71,156.5 v1(182.95,156.26)
TBT_A_USB20_L_NB: length 8.3
  IN4 w0.097: v1(193.28,175.19) 193.51,175.42 193.51,175.6 192.88,176.24 192.88,177.19 192.55,177.51 192.55,178.57 v1(192.35,178.77)
  BOTTOM w0.099: v1(193.28,175.19) 193.49,174.98 193.49,174.84 193.32,174.67 DT10.4 DT10.7 193.32,173.26 193.48,173.09 193.48,172.61 193.35,172.48 LT3.3 ; v1(192.35,178.77) 192.35,178.78 JUSBC1.B7
TBT_A_USB20_L_NT: length 6.5
  BOTTOM w0.099: LT2.2 192.27,172.39 192.15,172.51 192.15,172.99 192.32,173.16 DT10.8 DT10.2 192.32,174.68 192.16,174.84 192.16,175.2 v3(192.41,175.45) 192.93,175.98 192.93,176.4 192.97,176.44 192.97,177.02 192.93,177.05 192.93,177.39 193.1,177.55 JUSBC1.A7
TBT_A_USB20_L_PB: length 8.3
  IN4 w0.097: v1(193.87,175.19) 193.68,175.37 193.68,175.67 193.05,176.31 193.05,177.26 192.73,177.58 192.73,178.57 v1(192.94,178.78)
  BOTTOM w0.099: JUSBC1.B6 192.85,178.87 v1(192.94,178.78) ; v1(193.87,175.19) 193.68,175 193.68,174.78 193.81,174.65 DT10.5 DT10.6 193.81,173.26 193.67,173.12 193.67,172.64 193.85,172.46 LT3.2
TBT_A_USB20_L_PT: length 6.5
  BOTTOM w0.099: JUSBC1.A6 192.6,177.56 192.74,177.42 v3(192.74,176.73) 192.74,176.06 192.5,175.81 192.46,175.81 192.05,175.4 192.05,175.36 191.97,175.28 191.97,174.86 191.81,174.71 DT10.1 DT10.9 191.81,173.11 191.95,172.97 191.95,172.59 191.76,172.4 LT2.3
TBT_A_USB20_N: length 23.2
  TOP w0.089: UT1.D20 v1(184.55,168.36)
  IN4 w0.097: v1(184.55,168.36) 185.52,169.32 191.02,169.32 191.41,168.93 196.19,168.93 197.25,167.86 200.11,167.86 200.97,167.01 200.97,166.11 200.62,165.77 200.18,165.77 199.98,165.96 199.98,166.39 v1(199.81,166.57)
  BOTTOM w0.076: UT4.K5 199.91,164.96 199.91,165.05 199.91,165.05 199.91,165.42 200.01,165.53 200.01,165.82 199.92,165.92 199.92,166.46 v1(199.81,166.57)
TBT_A_USB20_NB: length 18.6
  IN4 w0.097: v1(201.29,169.2) 201.29,169.17 201.44,169.02 201.6,169.02 201.7,169.12 201.7,169.36 201.7,169.37 201.7,169.81 200.1,171.41 196.27,171.41 195.67,172 194.9,172 194.8,171.91 194.8,171.77 v1(195.12,171.46)
  BOTTOM w0.076: UT4.L7 201.24,165.15 201.24,166.41 201.56,166.72 201.56,166.74
  BOTTOM w0.099: 201.56,166.74 201.56,167.16 201.7,167.31 201.7,169.29 201.6,169.39 201.39,169.39 201.29,169.29 v1(201.29,169.2) ; LT3.4 193.35,170.02 193.57,169.8 194.37,169.8 195.12,170.55 v1(195.12,171.46)
TBT_A_USB20_NT: length 16.2
  IN4 w0.097: v1(192.54,170.09) 192.51,170.11 192.38,170.11 192.09,169.83 192.09,169.75 192.19,169.66 193.04,169.66 193.66,170.28 198.33,170.28 198.9,169.71 199.6,169.71 199.72,169.83 v1(199.72,169.91)
  BOTTOM w0.076: UT4.L6 200.71,165.02 200.82,165.02 200.9,165.09 200.9,165.22 200.66,165.46 200.66,165.69 201.04,166.07 201.04,166.29
  BOTTOM w0.089: 201.04,166.29 201.04,166.7 201.05,166.7 201.05,166.78
  BOTTOM w0.099: v1(199.72,169.91) 199.86,169.77 200.29,169.77 200.81,169.24 200.81,168.42 201.05,168.18 201.05,166.78 ; v1(192.54,170.09) 192.34,170.09 192.21,170.21 192.21,170.39 192.27,170.44 LT2.1
TBT_A_USB20_P: length 23.2
  TOP w0.089: UT1.E20 v1(184.55,167.71)
  IN4 w0.097: v1(184.55,167.71) 185.01,167.71 185.11,167.8 185.11,168.09 184.96,168.24 184.96,168.52 185.59,169.15 190.95,169.15 191.34,168.76 196.11,168.76 197.18,167.69 200.04,167.69 200.79,166.94 200.79,166.18 200.55,165.94 200.25,165.94 200.16,166.04 200.16,166.34 200.38,166.57 v1(200.39,166.57)
  BOTTOM w0.076: UT4.L5 200.13,165.07 200.07,165.12 200.07,165.36 200.18,165.46 200.18,165.89 200.08,165.99 200.08,166.1 200.16,166.17 200.5,166.17 200.59,166.26 200.59,166.49 200.51,166.57 v1(200.39,166.57)
TBT_A_USB20_PB: length 18.6
  IN4 w0.097: v1(202.1,169.2) 201.88,169.43 201.88,169.88 200.18,171.58 196.34,171.58 195.75,172.18 194.83,172.18 194.63,171.98 194.63,171.71 194.61,171.7 194.61,171.69 v1(194.39,171.47)
  BOTTOM w0.076: 201.75,166.74 201.75,166.73 201.73,166.72 201.73,166.66 201.41,166.34 201.41,164.82 UT4.K7
  BOTTOM w0.099: v1(194.39,171.47) 194.45,171.53 194.61,171.53 194.71,171.43 194.71,171.29 194.92,171.08 194.92,170.63 194.29,169.99 193.65,169.99 193.55,170.1 193.55,170.24 193.64,170.34 193.77,170.34 193.85,170.42 LT3.1 ; 201.75,166.74 201.75,166.78 201.75,166.78 201.75,167.08 201.89,167.23 201.89,168.98 v1(202.1,169.2)
TBT_A_USB20_PT: length 16.2
  IN4 w0.097: v1(191.78,170.09) 191.92,169.95 191.92,169.68 192.11,169.48 193.11,169.48 193.73,170.11 198.26,170.11 198.83,169.54 199.5,169.54 v1(199.72,169.32)
  BOTTOM w0.076: UT4.K6 200.41,164.82 200.41,165.17 200.48,165.25 200.48,165.74 200.87,166.13 200.87,166.27 200.86,166.27 200.86,166.29
  BOTTOM w0.089: 200.86,166.29 200.86,166.76 200.85,166.77 200.85,166.78
  BOTTOM w0.099: 200.85,166.78 200.85,168.1 200.62,168.34 200.62,169.16 200.21,169.57 199.97,169.57 v1(199.72,169.32) ; v1(191.78,170.09) 191.9,170.09 192.02,170.21 192.02,170.35 191.76,170.61 LT2.4
TBT_CIO_PLUG_EVENT#: length 189
  TOP w0.089: 174.39,161.14 v1(174.55,161.14) 174.94,161.14 175.6,161.8 176.15,161.8 176.38,161.57 UT1.W2
  TOP w0.127: 174.39,161.14 174.29,161.14 174.26,161.11 173.69,161.11 RT29.2
  IN2 w0.091: v1(197.06,70.28) 196.47,70.87 196.47,73.47 198.47,75.47 198.47,87.9 195.05,91.32 195.05,93.49 192.81,95.73 192.81,103.25 193.9,104.35 193.9,108.72 197.3,112.12 197.3,144.05 191.56,149.8 191.56,151.48 188.93,154.11 177.17,154.11 176.75,153.69 173.06,153.69 171.18,155.56 171.18,157.35 170.9,157.64 170.9,160.08 171.57,160.75 171.76,160.75 174.16,160.75 v1(174.55,161.14)
  IN3 w0.089: v1(210.19,19.4) 210.07,19.4 209.58,19.88 209.58,20.23 208.52,21.3 208.52,21.96 208.22,22.26 205.17,22.26 204.25,23.18 203.3,23.18 202.5,23.99 201.85,23.99 201.43,24.41 201.43,28.15 200.8,28.78 200.8,31.47 201.54,32.21 201.54,33.81 202.51,34.78 202.51,35.97 202.18,36.3 202.18,37.36 201.37,38.17 201.37,39.07 200.79,39.66 200.22,39.66 199.71,40.17 199.71,40.87 199.18,41.4 199.18,42.08
  IN3 w0.091: 199.18,42.08 199.18,48.51 197.54,50.14 197.54,51.35 194.21,54.69 194.21,56.12 194.76,56.67 194.76,58.64 194.21,59.2 194.21,67.87 195.17,68.84 196.19,68.84 196.63,69.28 196.63,69.85 v1(197.06,70.28)
  BOTTOM w0.089: UH1.AN43 210.73,18.97 210.83,19.07 210.83,19.32 210.7,19.46 210.25,19.46 v1(210.19,19.4)
TBT_EE_CLK: length 34.1
  TOP w0.089: v1(174.44,157.83) 175.56,157.83 177.07,159.34 177.07,159.95 UT1.AB4
  IN3 w0.091: v1(174.44,157.83) 174.65,158.04 187.29,158.04 187.59,158.34 188.16,158.34 189.76,156.74 v1(191.2,156.74)
  BOTTOM w0.107: 195.67,157 195.67,156.95 196.32,156.3 196.32,155.78 196.21,155.67 194.07,155.67 192.72,154.32 UT2.6 ; 195.67,157 195.66,157 191.46,157 v1(191.2,156.74) ; 195.67,157 RT101.1
TBT_EE_CS_N: length 24.7
  TOP w0.089: 174.39,158.21 174.7,158.21 174.89,158.02 175.5,158.02 176.84,159.36 UT1.AC3
  TOP w0.107: v1(174.13,158.34) 174.25,158.21 174.39,158.21
  IN3 w0.091: v1(187.08,158.85) 187.08,158.35 186.99,158.25 174.21,158.25 v1(174.13,158.34)
  BOTTOM w0.107: v1(187.08,158.85) 187.21,158.97 187.21,159.54 187.02,159.73 187.02,160.81 187.18,160.98 RT100.1 ; RT50.2 RT100.1 ; RT100.1 187.97,160.98 188.29,160.66 188.29,160.29 v2(188.4,160.17) 188.52,160.05 190.07,160.05 190.18,159.95 UT2.1
TBT_EE_DI: length 38.3
  TOP w0.089: UT1.AB3 176.6,159.94 176.6,159.38 176.47,159.25
  TOP w0.102: v1(174.7,158.66) 175.08,158.27 175.5,158.27 176.47,159.25
  TOP w0.107: v1(191.07,157.31) 191.22,157.31 193.24,155.29 194.64,155.29 194.64,155.26 v1(194.7,155.26)
  IN3 w0.091: v1(191.07,157.31) 191.03,157.31 191.02,157.32 190.89,157.32 190.38,157.83 190.38,161.58 190.06,161.89 188.54,161.89 187.62,160.97 186.22,160.97 185.11,159.86 179.78,159.86 179.27,159.35 176.16,159.35 175.78,159.73 174.44,159.73 174.13,159.42 174.13,158.97 174.44,158.66 v1(174.7,158.66)
  BOTTOM w0.107: UT2.5 193.99,154.55 v1(194.7,155.26) 194.79,155.35 196.45,155.35 197.01,155.91 RT98.1
TBT_EE_DO: length 43.1
  TOP w0.089: UT1.AC4 177.3,159.31 175.41,157.42 174.39,157.42
  TOP w0.107: v1(173.69,157.88) 174.15,157.42 174.39,157.42
  IN3 w0.091: v1(191.02,157.89) 191.08,157.96 191.08,159.93 190.64,160.37 190.64,161.7 190.06,162.27 188.35,162.27 187.52,161.45 186.13,161.45 184.86,160.18 179.59,160.18 179.02,159.61 176.22,159.61 175.84,159.99 174.13,159.99 173.68,159.54 173.68,157.88 v1(173.69,157.88)
  BOTTOM w0.107: RT49.1 188.48,161.83 189.39,160.91 v2(189.49,160.91) 190.47,160.91 190.76,160.63 191.27,160.63 191.45,160.45 UT2.2 191.45,158.45 191.08,158.08 191.08,157.96 v1(191.02,157.89) 190.66,157.54 190.66,156.7 191.03,156.33 192.38,156.33 192.67,156.62 195.53,156.62 195.94,156.2 RT99.1
TBT_EE_WP_N: length 23.4
  TOP w0.089: v1(175.08,161.79) 175.08,161.87 175.23,162.02 UT1.V1
  IN3 w0.091: v1(189.96,161.32) 188.6,161.32 v1(186.57,159.29)
  IN4 w0.097: v1(186.57,159.29) 186.57,159.35 185.84,160.08 184.83,160.08 184.29,159.54 176.73,159.54 175.06,161.21 175.06,161.78 v1(175.08,161.79)
  BOTTOM w0.107: RT48.2 190,161.36 v1(189.96,161.32) 190.09,161.2 190.59,161.2 190.92,160.86 192.48,160.86 192.72,160.62 UT2.3
TBT_FORCE_PWR: length 179.3
  TOP w0.107: RT13.2 169.9,161.87 170.5,161.27 v1(170.67,161.27)
  IN1 w0.097: v1(202.07,19.72) 200.4,21.38 200.4,26.53 199.97,26.96 199.97,27.83 198.77,29.03 196.97,29.03 194.8,31.19 192.16,31.19 190.18,33.17 190.18,33.9 186.7,37.38 186.7,53.25 188.17,54.71 188.17,63.64 188.52,63.99 188.52,72.67 191.4,75.55 v1(191.79,75.55)
  IN2 w0.091: v1(170.67,161.27) 170.69,161.25 170.69,160.79 168.78,158.88 168.78,157.72 169.02,157.47 169.02,156.01 170.47,154.56 170.88,154.56 172.62,152.81 177.23,152.81 177.41,153 185.3,153 185.89,152.41 189.02,152.41 190.68,150.74 190.68,149.44 195.95,144.17 195.95,112 193.03,109.08 193.03,104.71 191.79,103.48 v1(191.79,75.55)
  BOTTOM w0.089: v1(202.07,19.72) 201.81,19.46 201.3,19.46 201.12,19.28 UH1.P43
TBT_FORCE_PWR_R: length 13.9
  TOP w0.102: UT1.H4 v1(177.4,167.06)
  TOP w0.107: v1(168.77,162.95) 169.12,162.95 RT35.1 RT13.1
  IN3 w0.091: v1(177.4,167.06) 176.56,167.06 174.82,165.32 174.82,164.94 173.74,163.86 172.79,163.86 171.39,162.46 169.25,162.46 v1(168.77,162.95)
  BOTTOM w0.107: v2(168.28,163.35) 168.69,162.95 v1(168.77,162.95) 168.98,163.16 RT94.2
TBT_HDMI_DDC_CLK: length 3.7
  TOP w0.089: 174.47,160.33 174.68,160.54 174.84,160.54 175.63,161.32 175.76,161.32 175.77,161.33 176.15,161.33 UT1.Y2
  TOP w0.127: T9.1 174.26,160.12 174.47,160.33
TBT_HDMI_DDC_DATA: length 1.5
  TOP w0.089: UT1.Y1 175.68,161.1
  TOP w0.127: 175.68,161.1 T7.1
TBT_HOLD_N: length 6.7
  BOTTOM w0.107: v2(191.45,150.78) UT2.7 191.45,153.46 191.24,153.67 190.6,153.67 189.75,154.53 189.75,155.16 189.32,155.59 RT51.2
TBT_I2C_SCL: length 39.7
  TOP w0.089: 174.39,163.26 174.62,163.26 v1(174.83,163.05) 174.95,162.92 175.35,162.92 175.56,162.7 176.16,162.7 UT1.U2
  TOP w0.107: RT27.2 174.39,163.26
  IN4 w0.097: v1(196.93,161.5) 196.79,161.36 196.51,161.36 196.22,161.64 196.22,163.34 195.03,164.54 193.77,164.54 192.89,165.42 191.17,165.42 190.95,165.64 190.95,167.35 190.09,168.21 187.75,168.21 187.38,167.84 186.81,167.84 185.79,166.82 185.79,161.85 184.05,160.12 176.98,160.12 175.84,161.26 175.84,162.43 175.65,162.62 174.95,162.82 v1(174.83,163.05)
  BOTTOM w0.076: v1(196.93,161.5) 197.16,161.5 197.38,161.71 197.94,161.71 198.04,161.82 198.41,161.82 UT4.D2
TBT_I2C_SDA: length 38.8
  TOP w0.089: UT1.U1 175.87,162.53 175.49,162.53 175.33,162.69 174.87,162.69 v1(174.66,162.48) 174.46,162.69 174.39,162.69
  TOP w0.107: RT26.2 174.39,162.69
  IN4 w0.097: v1(174.66,162.48) 174.89,162.61 175.54,162.42 175.62,162.34 175.62,161.17 176.89,159.89 184.14,159.89 186.01,161.76 186.01,166.73 186.9,167.62 187.47,167.62 187.84,167.99 190,167.99 190.73,167.26 190.73,165.55 191.08,165.2 192.8,165.2 193.68,164.31 194.93,164.31 196,163.25 196,161.55 196.42,161.13 196.49,161.13 v1(196.68,160.94)
  BOTTOM w0.076: v1(196.68,160.94) 196.69,160.94 196.69,160.93 196.81,161.04 197.09,161.04 197.56,161.51 198.02,161.51 198.07,161.57 UT4.D1
TBT_PCIE_WAKE#: length 286.7
  TOP w0.107: RT10.2 172.07,161.5 v1(171.83,161.26) ; UE5.70 295.14,6.64 295.47,6.3 295.47,5.24 294.84,4.6 v2(289,4.6) 285.06,4.6 283.03,6.64 283.03,15.11 279.14,19 279.14,24.2 277.46,25.88 276.72,25.88 276.12,26.47 276.12,28.17 276.36,28.42 276.36,31.03 276.82,31.49 276.82,32.06 277.48,32.72 277.48,37.2 282.64,42.35 v1(282.64,44.77)
  IN2 w0.091: v1(282.64,44.77) 282.14,44.77 279.26,47.65 279.26,60.7 273.74,66.22 267.19,66.22 267.04,66.07 249.45,66.07 249.26,66.26 224.54,66.26 224.39,66.1 224.25,66.1 223.74,65.59 213.85,65.59 212.78,64.52 207.45,64.52 206.29,65.68 203.46,65.68 202.99,66.16 200.39,66.16 199.02,67.53 199.02,69.95 198.62,70.35 198.01,70.35 197.44,69.78 196.95,69.78 196.25,70.48 196.25,73.56 198.25,75.56 198.25,87.81 194.83,91.23 194.83,93.39 192.59,95.64 192.59,103.34 193.68,104.44 193.68,108.81 197.08,112.21 197.08,143.96 191.34,149.71 191.34,151.39 188.84,153.89 177.26,153.89 176.84,153.47 172.97,153.47 170.97,155.47 170.97,157.26 170.68,157.55 170.68,160.17 171.55,161.04 171.6,161.04 v1(171.83,161.26)
TBT_PCIE_WAKE_N: length 5.2
  TOP w0.089: 174.39,160.7 174.44,160.75 174.8,160.75 175.61,161.56 UT1.W1
  TOP w0.107: RT28.2 RT10.1 172.36,160.76 v2(171.78,160.18)
  TOP w0.127: 174.39,160.7 174.22,160.53 173.24,160.53 173.13,160.64 173.13,160.65 172.93,160.85 RT28.2
TBT_RBIAS: length 1.2
  TOP w0.089: UT1.H6 178.7,167.05 v1(178.71,167.05)
  BOTTOM w0.127: v1(178.71,167.05) 179.22,167.05 RT25.1
TBT_RESET_N: length 45.8
  TOP w0.102: UT1.F4 177.08,167.38 177.38,167.68 v1(177.38,167.71)
  TOP w0.107: v1(170.57,164.05) 170.57,164.05 170.54,164.03 RT23.1
  IN1 w0.097: v1(206.96,163.23) 206.57,163.61 203.4,163.61 202.45,164.56 195.2,164.56 194.95,164.31 192.87,164.31 192.15,165.03 191.25,165.03 190.59,165.69 190.59,166.04 190.57,166.05 190.57,167.35 189.87,168.05 188.79,168.05 187.28,169.57 178.44,169.57 177.94,169.07 177.94,168.05 177.59,167.71 v1(177.38,167.71) 177.38,167.68 175.29,165.59 173.44,165.59 171.9,164.05 170.57,164.05 v1(170.57,164.05)
  BOTTOM w0.107: v1(177.38,167.71) 177.37,167.7 RT80.1
  BOTTOM w0.381: v1(206.96,163.23) 206.89,163.29 RT102.2
TBT_RESET_N_EC: length 272.5
  TOP w0.107: v1(168.65,164.22) 169.12,164.22 RT23.2 ; v1(301.19,45.19) 301.13,45.19 300.5,44.56 300.5,43.2 299.69,42.39 299.69,40.64 298.39,39.34 v2(298.39,37.58) 298.39,35.02 299.37,34.03 299.37,25.91 299.94,25.34 UE5.15
  IN2 w0.091: v1(168.65,164.22) 168.71,164.22 169.18,163.75 169.18,162.59 168.4,161.81 168.4,160.92 167.3,159.82 167.3,157.86 168.35,156.81 168.35,155.92 168.08,155.66 168.08,155.2 169.38,153.89 170.62,153.89 172.35,152.16 177.5,152.16 177.68,152.35 185.03,152.35 185.62,151.75 188.61,151.75 190.03,150.33 190.03,149.17 195.29,143.9 195.29,112.41 191.53,108.64 191.53,106.7 190.95,106.13 190.95,74.35 191.34,73.97 191.89,73.97 193.25,72.61 193.25,70.75 195.2,68.79 196.03,68.79 199.49,65.34 202.07,65.34 202.83,64.58 203.94,64.58 204.31,64.95 204.65,64.95 205.51,64.08 212.97,64.08 214.04,65.15 224.06,65.15 224.73,65.82 249.08,65.82 249.27,65.63 267.22,65.63 267.37,65.78 273.56,65.78 278.82,60.52 278.82,47.41 282.2,44.03 299.98,44.03 301.14,45.19 v1(301.19,45.19)
TBT_RSENSE: length 1.2
  TOP w0.102: UT1.J6 v1(178.71,166.41)
  BOTTOM w0.127: v1(178.71,166.41) 179.21,166.41 RT25.2
TBT_RST#_R: length 2.4
  TOP w0.089: UT1.L4 v1(177.4,165.76)
  BOTTOM w0.107: v1(177.4,165.76) 177.03,165.39 RT1.2 176.64,165.86 v2(176.22,166.28)
TBT_SRC_CFG1: length 3.6
  TOP w0.089: UT1.AA1 175.58,160.64 175.18,160.24 175.18,160.15 174.7,159.67 174.51,159.67
  TOP w0.127: 174.51,159.67 174.1,159.26 RT11.1
TBT_SRC_HPD: length 3.6
  TOP w0.089: 175.47,166.93 175.62,167.08 UT1.G1
  TOP w0.107: 175.47,166.93 175.43,166.89 175.43,166.14 174.66,165.37 174.66,164.97 174.16,164.46 RT4.1
TBT_SVR_IND:
  vias: v1(174.06,168.82) v1(174.06,168.18) v1(174.7,168.69) v2(174.57,168.12)
TBT_TCK: length 21.4
  TOP w0.102: UT1.T4 v1(177.4,163.16)
  TOP w0.107: v1(171.59,156.69) 171.12,157.15 170.13,157.15 169.69,157.6 167.91,157.6 167.02,158.49 166.32,158.49 v2(166.16,158.64) 164.16,160.65 RT7.2
  BOTTOM w0.107: v1(171.59,156.69) 172.03,156.69 172.23,156.89 172.87,156.89 173.4,157.42 175.18,157.42 175.84,158.08 175.84,162.08 176.35,162.59 176.84,162.59 v1(177.4,163.16)
TBT_TDI: length 22.4
  TOP w0.089: UT1.Y4 v1(177.4,161.2)
  TOP w0.107: RT9.2 162.7,161.35 162.7,161.11 v2(163.39,160.41) 165.78,158.02 166.82,158.02 167.71,157.13 168.56,157.13 v1(169.42,156.27)
  BOTTOM w0.107: v1(169.42,156.27) 169.83,155.86 172.41,155.86 172.86,155.42 174.38,155.42 176.7,157.74 176.7,160.85 177.06,161.2 v1(177.4,161.2)
TBT_TDO: length 20.4
  TOP w0.102: UT1.W4 v1(177.4,161.86)
  TOP w0.107: RT6.2 164.98,160.85 v2(165.11,160.73) 168,157.83 169.78,157.83 170.23,157.39 172.35,157.39 172.98,156.75 v1(172.98,156.05)
  BOTTOM w0.107: v1(177.4,161.86) 177.01,161.86 176.46,161.31 176.46,158.02 175.39,156.95 173.88,156.95 v1(172.98,156.05)
TBT_TEST_EN: length 5.4
  TOP w0.107: v2(174.06,167.39) 173.78,167.39 172.86,166.47 172.86,166.18
  TOP w0.127: v2(174.06,167.39) 174.08,167.42 174.43,167.42 175.03,168.01 175.91,168.01 UT1.E1 ; 172.86,166.18 172.17,165.49 RT17.1
TBT_TEST_PWG: length 2.7
  TOP w0.102: RT18.1 177.29,158.48 177.29,158.73 177.99,159.43 177.99,159.89 177.99,159.95 UT1.AB5
TBT_TMS: length 22
  TOP w0.102: v1(177.4,162.51) 177.08,162.18 UT1.V4
  TOP w0.107: v1(170.44,156.31) 169.38,157.36 167.81,157.36 166.92,158.25 166.08,158.25 v2(165,159.33) 163.2,161.13 RT8.2
  BOTTOM w0.107: v1(177.4,162.51) 177.11,162.21 176.6,162.21 176.22,161.83 176.22,158.12 175.29,157.19 173.55,157.19 172.86,156.5 172.35,156.5 172.13,156.28 170.47,156.28 v1(170.44,156.31)
TBT_TMU_CLK_OUT: length 3.3
  TOP w0.089: UT1.V2 176.15,162.25 175.03,162.25 174.67,161.89
  TOP w0.127: 174.67,161.89 174.54,161.77 T2.1 174.16,162.11 RT34.1
TBT_XTAL_25_IN: length 11
  TOP w0.089: UT1.D22 185.81,168.69 186.22,168.69 v2(187.15,169.63) 187.33,169.81
  TOP w0.127: 187.33,169.81 187.35,169.83 190.33,169.83 CT37.1 190.84,169.96 191.16,169.64 193.24,169.64 194.14,168.75 YT1.1
TBT_XTAL_25_OUT: length 10.7
  TOP w0.089: UT1.D23 186.34,168.46 187.18,169.3 187.33,169.3
  TOP w0.127: 187.33,169.3 v2(188.41,169.3) 190.04,169.3 CT38.1 190.84,169.13 192.54,169.13 193.02,168.66 193.02,167.26 192.04,166.28 YT1.3
TBTA_CC1: length 19.3
  TOP w0.381: CT112.1 202.95,165.98 203.2,166.22 203.2,166.75 v1(203.27,166.82)
  IN1 w0.508: v1(191.35,172.75) 191.96,172.75 193.87,170.83 194.96,170.83 197.31,168.49 197.52,168.49 198.31,167.7 201.34,167.7 201.4,167.76 202.43,167.76 203.27,166.92 v1(203.27,166.82)
  BOTTOM w0.203: 202.41,165.74 202.41,165.62 202.16,165.37 UT4.L9
  BOTTOM w0.254: v1(203.27,166.82) 203.27,166.6 202.41,165.74
  BOTTOM w0.279: JUSBC1.A5 192.1,177.5 192.29,177.31 v1(192.29,176.63)
TBTA_CC2: length 24.3
  TOP w0.279: v1(197.45,175.89) DT12.1 196.9,175.47 197.04,175.32
  TOP w0.381: v1(204.27,166.22) 204.12,166.38 CT113.1
  TOP w0.508: v1(197.76,174.91) 197.46,174.91 197.04,175.32
  IN1 w0.457: v1(193.52,178.81) 193.52,178.21
  IN1 w0.508: v1(204.27,166.22) 204.27,168.88 203.59,169.56 203.15,169.56 202.57,170.15 201.67,170.15 201.3,170.52 201.22,170.6 199.69,170.6 198.1,172.19 198.1,174.57 v1(197.76,174.91) ; 193.52,178.21 194.15,177.58 195.15,177.58 196.84,175.89 v1(197.45,175.89)
  BOTTOM w0.203: v1(193.52,178.81) 193.52,178.81 193.52,178.97 193.35,179.15 JUSBC1.B5 ; v1(204.27,166.22) 204.11,166.06 203.91,166.06 203.82,165.97 203.39,165.97 203.39,165.97 203.32,165.97 202.89,165.53 202.89,165.47 202.66,165.24 UT4.L10
TBTA_DEBUG1: length 2.6
  BOTTOM w0.102: 198.32,166.66 198.32,166.08 198.65,165.75 198.65,165.18 198.66,165.17 UT4.L2
  BOTTOM w0.107: 198.32,166.66 198.32,166.91
  BOTTOM w0.127: 198.32,166.91 198.45,167.04 RT71.1
TBTA_DEBUG2: length 3.2
  BOTTOM w0.076: 198,166.66 v2(198,166.4) 198,166.12 198.41,165.72 198.41,165.07 198.41,164.88 198.66,164.63 UT4.K2
  BOTTOM w0.107: RT72.1 197.81,166.91 198,166.72 198,166.66
TBTA_DIG_AUD_N: length 3.3
  BOTTOM w0.076: UT4.K3 199.16,164.64 198.91,164.89 198.91,164.96 198.91,165.17 198.83,165.25 198.83,165.97 198.79,166.01 198.79,166.5 198.92,166.63 198.92,166.65 198.94,166.66
  BOTTOM w0.089: RT69.1 199.27,167.25 199.27,166.99 198.94,166.66
TBTA_DIG_AUD_P: length 2.8
  BOTTOM w0.076: UT4.L3 199.16,165.15 198.99,165.32 198.99,166.04 198.95,166.08 198.95,166.41 199.07,166.53
  BOTTOM w0.089: 199.07,166.53 199.14,166.6 199.16,166.6 199.46,166.9 199.46,167.19 RT68.1
TBTA_HPD: length 50
  TOP w0.102: v1(177.4,165.11) UT1.M4
  TOP w0.107: RT41.1 169.06,163.58 v1(168.78,163.58)
  IN1 w0.097: v1(168.78,163.58) 169.9,162.46 171.51,162.46 172.7,163.64 173.33,163.64 174.44,164.75 177.05,164.75 v1(177.4,165.11) 177.81,165.51 178.82,165.51 179.14,165.83 179.14,168.72 179.48,169.06 186.77,169.06 187.71,168.12 187.71,165.01 190.36,162.36 190.36,161.04 190.83,160.58 192.16,160.58 193.91,158.83 193.91,158.18 194.64,157.45 196.48,157.45 198.64,159.61 202,159.61 v1(202.21,159.4)
  BOTTOM w0.076: UT4.C10 202.66,160.97 202.41,160.72 202.41,159.78 202.21,159.58 v1(202.21,159.4)
TBTA_I2C_INT: length 43.3
  TOP w0.102: v1(177.4,166.41) UT1.J4
  TOP w0.107: RT32.2 168.78,164.72 v1(168.65,164.85)
  IN1 w0.097: v1(194.51,158.46) 194.51,158.55 192.26,160.8 190.92,160.8 190.59,161.14 190.59,163.59 189.3,164.88 189.3,166.34 188.29,167.35 188.29,167.93 186.86,169.35 178.72,169.35 178.19,168.82 178.19,167.16 177.43,166.41 v1(177.4,166.41)
  IN4 w0.097: v1(168.65,164.85) 169.74,165.94 169.74,166.21 170.53,167 173.61,167 174.28,167.67 176.14,167.67 v1(177.4,166.41)
  BOTTOM w0.107: v1(194.51,158.46) 195.14,159.1 196.22,159.1 196.99,159.86 196.99,160.45 197.6,161.07 UT4.C1
TBTA_I2C_SCL1_R: length 12.1
  IN3 w0.091: v1(205.46,153.51) 205.3,153.66 205.3,154.53 201.43,158.4 200.63,158.4 v1(200.42,158.61)
  BOTTOM w0.076: 199.91,159.59 199.91,160.36 200.12,160.57 UT4.B5
  BOTTOM w0.107: RT57.2 205.3,154.24 205.3,153.66 v1(205.46,153.51) 205.3,153.36 205.3,152.91 RT60.2 ; 199.91,159.59 200.55,158.99 200.55,158.74 v1(200.42,158.61)
TBTA_I2C_SDA1_R: length 11.8
  IN3 w0.091: v1(200.48,158.02) 200.64,158.18 201.34,158.18 205.09,154.44 205.09,153.74 v1(204.86,153.51)
  BOTTOM w0.107: v1(200.48,158.02) 200.86,158.4 200.86,158.97 200.16,159.67 UT4.A5 ; RT59.2 205.07,152.93 205.07,153.3 v1(204.86,153.51) 205.07,153.72 205.07,154.22 RT58.2
TBTA_LDO_BMC: length 2.6
  BOTTOM w0.203: UT4.E1 197.96,162.07 197.83,161.94 197.14,161.94 197.12,161.96 196.5,161.96 195.97,161.42 CT98.1
TBTA_LSRX: length 31.9
  TOP w0.089: v1(176.91,170.72) 176.91,170.35 177.3,169.96 UT1.A4
  IN1 w0.091: v1(199.34,166.2) 198.67,166.2 197.31,167.56 197.1,167.56 194.63,170.03 193.36,170.03 192.8,170.59 188.84,170.59 187.67,171.77 185.33,171.77 184.6,172.5 177.62,172.5 176.91,171.79 v1(176.91,170.72)
  BOTTOM w0.076: UT4.K4 199.41,164.82 199.41,165.3 199.23,165.47 199.23,166.1 v1(199.34,166.2)
  BOTTOM w0.089: RT42.1 v2(177.38,172.24) 176.91,171.77 v1(176.91,170.72)
TBTA_LSTX: length 28.6
  TOP w0.089: v1(199.66,165.68) 199.66,165.25 v2(199.56,165.16) ; RT40.1 RT21.2 177.99,171.77 177.99,170.83 v1(177.9,170.74) 177.76,170.6 UT1.A5
  IN1 w0.091: v1(199.66,165.68) 199.58,165.6 198.42,165.6 197.06,166.96 196.85,166.96 194.38,169.43 190.34,169.43 189.81,169.96 188.63,169.96 187.42,171.16 184.67,171.16 184.39,171.44 178.6,171.44 v1(177.9,170.74)
  BOTTOM w0.102: v1(199.66,165.68) UT4.L4
TBTA_MRESET: length 2.4
  BOTTOM w0.076: 203.76,162.06 203.76,162.07 UT4.E11
  BOTTOM w0.107: RT63.1 205.42,162.38 205.11,162.06 203.76,162.06
TBTA_ROSC: length 4.5
  BOTTOM w0.076: UT4.G2 198.4,163.32 198.26,163.32 198.26,163.32 198.05,163.32 198.05,163.32 197.77,163.32 197.67,163.41 197.67,163.41 197.6,163.48 197.11,163.48
  BOTTOM w0.107: RT75.1 195.6,164.36 v2(195.27,164.69)
  BOTTOM w0.127: RT75.1 196.85,163.67 197.04,163.48 197.11,163.48
TBTA_SBU1: length 27.4
  TOP w0.089: v1(194.48,174.94) 194.27,175.16 194.27,175.35 194.14,175.48 194.14,175.73 194.27,175.86 DT13.1 194.9,175.86 194.99,175.77 194.99,175.39 v1(194.95,175.36)
  IN4 w0.091: v1(194.48,174.94) 194.57,174.85 194.57,174.54 194.18,174.15 192.09,174.15 191.99,174.06 191.99,172.94 194,170.94 199.79,170.94 200.39,170.34 200.39,168.52 201.62,167.29 201.62,166.59 201.72,166.5 v1(202.07,166.5)
  BOTTOM w0.076: UT4.K8 201.7,164.57 201.91,164.77 201.91,165.45 202.16,165.7 202.16,166.41 v1(202.07,166.5)
  BOTTOM w0.089: v1(194.95,175.36) 194.26,175.36 194.03,175.59 193.39,175.59 193.19,175.79 193.19,177.2 193.6,177.6 JUSBC1.A8
TBTA_SBU2: length 27.4
  TOP w0.089: v1(189.11,175.23) 188.84,175.5 188.84,175.82 DT14.1 188.54,175.67 v1(188.38,175.51)
  IN4 w0.091: v1(188.38,175.51) 188.38,175.55 189.27,176.44 190.01,176.44 191.77,178.2 191.77,178.85 v1(191.77,178.85) ; v1(189.11,175.23) 190.19,174.15 191.44,174.15 191.81,173.77 191.81,172.87 193.93,170.76 199.72,170.76 200.21,170.26 200.21,168.45 201.44,167.22 201.44,166.52 201.8,166.16 v1(201.8,165.9)
  BOTTOM w0.076: UT4.L8 201.74,165.15 201.74,165.84 v1(201.8,165.9)
  BOTTOM w0.089: v1(191.77,178.85) 191.85,178.92 JUSBC1.B8
TBTB_I2C_INT: length 6
  TOP w0.089: UT1.E2 176.33,168 176.09,167.77 175.47,167.77
  TOP w0.107: 175.47,167.77 175.13,167.77 173.83,166.47 173.49,166.47 v2(173.27,166.24) 171.75,164.73 RT33.2
TEST_PG: length 6.9
  TOP w0.1: RG17.1 223.71,101.89 224.2,101.4 v2(224.2,100.3) 224.2,100.17 v1(224.57,99.8)
  BOTTOM w0.3: UG1.AA31 227.62,99.8 v1(224.57,99.8)
TEST_PG_BACO: length 3.9
  TOP w0.089: RG20.1 225.57,102.8
  TOP w0.1: 225.57,102.8 225.7,102.67 225.77,102.6 225.77,102.03 226,101.8 226.17,101.8 v1(226.97,101)
  BOTTOM w0.1: UG1.Y32 226.97,100.85 v1(226.97,101)
TESTEN: length 37.5
  TOP w0.107: RG396.1 216.72,111.28 216.44,111.01 216.44,110.93 215.53,110.01 ; 215.53,110.01 RG7.1 ; 215.53,110.01 TV6.1 213.88,110.01 213.43,109.57 v1(210.07,109.57)
  IN2 w0.091: v1(210.06,103.11) 210.06,104.49 210.51,104.93 210.51,109.13 v1(210.07,109.57)
  IN3 w0.091: v1(228.57,96.2) 228.03,96.74 217.94,96.74 v1(217.12,97.57)
  BOTTOM w0.089: 215.65,97.78 215.86,97.57 v1(217.12,97.57)
  BOTTOM w0.1: UG1.AE30 228.57,96.05 v1(228.57,96.2)
  BOTTOM w0.107: v1(210.06,103.11) 210.06,102.29 212.37,99.98 213.44,99.98 215.65,97.78
TMDS_C_TX0N: length 21.1
  BOTTOM w0.089: U1.16 222.23,157.58 222.36,157.45 222.9,157.45 223.29,157.85 223.29,160.01 v3(222.87,160.43) 222.49,160.81 222.49,161.99 221.92,162.56 212.04,162.56 210.75,163.86 210.75,164.5 210.66,164.59 210.44,164.59 210.32,164.7 210.32,164.86 210.52,165.05 LV4.4 210.35,165.58 RV643.1
TMDS_C_TX0P: length 21.1
  BOTTOM w0.089: U1.17 223.01,157.18 223.56,157.74 v3(223.56,158.31) 223.56,160.12 222.76,160.92 222.76,162.1 222.03,162.83 212.15,162.83 211.02,163.97 LV4.1 211.18,165.58 RV646.1
TMDS_C_TX1N: length 21.4
  BOTTOM w0.089: U1.19 222.23,156.38 222.31,156.3 223.07,156.3 224.16,157.39 224.16,160.37 223.36,161.17 223.36,162.35 222.28,163.43 v3(217.78,163.43) 213.84,163.43 213.16,164.11 213.16,164.52 213.07,164.61 212.81,164.61 212.72,164.7 212.72,164.88 212.93,165.09 LV5.4 212.76,165.64 RV642.1
TMDS_C_TX1P: length 21.4
  BOTTOM w0.089: RV639.1 213.6,165.64 LV5.1 213.43,164.22 213.95,163.7 v3(220.62,163.7) 222.39,163.7 223.63,162.46 223.63,161.28 224.43,160.48 224.43,157.28 223.18,156.03 222.28,156.03 222.23,155.98 U1.20
TMDS_C_TX2N: length 19.4
  BOTTOM w0.089: RV645.1 217.32,165.61 LV6.4 217.49,165.01 217.38,164.9 217.38,164.69 217.48,164.59 217.83,164.59 218.11,164.31 222.82,164.31 224.35,162.77 224.35,161.77 225.28,160.85 v3(225.28,158.6) 225.28,157.24 223.09,155.05 222.36,155.05 222.23,155.18 U1.22
TMDS_C_TX2P: length 19.4
  BOTTOM w0.089: RV638.1 218.01,165.45 LV6.1 217.99,164.81 218.22,164.58 222.93,164.58 224.62,162.88 224.62,161.88 v3(225,161.5) 225.54,160.96 225.54,157.13 223.2,154.78 U1.23
TMDS_C_TXCN: length 18.1
  IN4 w0.089: v1(222.89,158.92) 222.84,158.87 221.98,158.87 221.23,159.62 221.23,162.83 220.17,163.89 218.66,163.89 218.41,164.14 218.41,164.92 218.2,165.13 217.74,165.13 217.53,164.92 217.53,164.08 217.44,163.99 217.17,163.99 217.09,164.08 217.09,164.92 216.75,165.26 215.52,165.26 215.24,164.98 v1(215.24,164.34)
  BOTTOM w0.089: v1(215.24,164.34) 215.28,164.39 LV3.4 215.25,165.41 RV641.1 ; v1(222.89,158.92) 222.71,158.74 222.27,158.74 222.23,158.78 U1.13
TMDS_C_TXCP: length 18.1
  IN4 w0.089: v1(215.82,164.34) 215.49,164.67 215.49,164.87 215.63,165.01 216.64,165.01 216.83,164.82 216.83,163.97 217.07,163.73 217.55,163.73 217.79,163.97 217.79,164.82 217.84,164.87 218.1,164.87 218.15,164.82 218.15,164.03 218.55,163.63 220.06,163.63 220.97,162.72 220.97,159.52 221.87,158.61 222.62,158.61 v1(222.89,158.34)
  BOTTOM w0.089: RV640.1 215.8,165.41 LV3.1 215.78,165.04 215.55,164.81 215.55,164.62 v1(215.82,164.34) ; U1.14 222.23,158.38 222.31,158.47 222.76,158.47 v1(222.89,158.34)
TMDS_CTRLCLK: length 20.4
  IN1 w0.097: v1(218.85,160.55) 219.03,160.37 219.03,160.09 219.31,159.81 220.41,159.81 221.1,160.5 221.1,165.45 222.27,166.61 222.27,172.24 221.13,173.37 220.05,173.37 JHDMI.15
  BOTTOM w0.107: U1.7 218.76,160.06 218.84,160.14 218.93,160.14 219.05,160.26 219.05,160.41 218.92,160.55 v1(218.85,160.55)
TMDS_CTRLDAT: length 20.4
  IN1 w0.097: v1(219.49,160.72) 219.26,160.48 219.26,160.18 219.4,160.04 220.32,160.04 220.87,160.6 220.87,165.54 222.04,166.71 222.04,172.14 221.72,172.47 221.33,172.47 221.01,172.16 220.14,172.16 220.02,172.04 220.02,171.72 219.86,171.56 219.5,171.56 219.37,171.69 219.37,172.5 JHDMI.16
  BOTTOM w0.107: U1.8 219.16,160.05 219.29,160.17 219.29,160.51 v1(219.49,160.72)
TMDS_R_TX0N: length 13.7
  IN4 w0.089: JHDMI.9 215.75,173.93 215.75,173.7 215.46,173.41 211.98,173.41 211.28,172.71 211.28,170.8 211.4,170.67 211.54,170.67 v1(211.75,170.88)
  BOTTOM w0.089: RV643.2 210.35,166.49 LV4.3 210.52,167.1 210.61,167.2 210.61,167.34 RV501.1 210.62,167.98 v3(210.62,168.71) 210.62,170.29 211.1,170.77 211.64,170.77 v1(211.75,170.88)
TMDS_R_TX0P: length 13.7
  IN4 w0.089: JHDMI.7 215.49,173.93 215.49,173.8 215.35,173.67 211.87,173.67 211.02,172.82 211.02,170.69 211.29,170.42 211.63,170.42 v1(211.75,170.3)
  BOTTOM w0.089: v1(211.75,170.3) 211.54,170.5 211.21,170.5 210.89,170.18 210.89,167.98 RV501.2 210.88,167.33 210.88,167.17 211.02,167.04 LV4.2 211.18,166.49 RV646.2
TMDS_R_TX1N: length 11.3
  BOTTOM w0.089: RV642.2 212.76,166.55 LV5.3 212.93,167.07 213.04,167.18 213.04,167.39 RV502.1 212.71,167.72 v3(212.71,168.78) 212.71,169.55 212.77,169.62 212.77,171.03 211.65,172.14 211.65,173.18 212.17,173.69 214.16,173.69 214.41,173.45 214.41,172.96 JHDMI.6
TMDS_R_TX1P: length 11.3
  BOTTOM w0.089: RV639.2 213.6,166.55 LV5.2 213.43,167.03 213.31,167.14 213.31,167.41 RV502.2 213.74,167.84 213.74,168.18 213.61,168.31 213.09,168.31 212.98,168.42 212.98,169.44 213.04,169.5 v3(213.04,170.11) 213.04,171.14 211.92,172.25 211.92,173.07 212.28,173.43 214.05,173.43 214.14,173.34 214.14,173.07 213.82,172.75 JHDMI.4
TMDS_R_TX2N: length 14.8
  IN1 w0.089: v1(218.38,170.88) 218.34,170.84 216.95,170.84 216.19,171.6 212.7,171.6 211.92,172.37 211.92,172.89 212.75,173.72 212.75,173.93 JHDMI.3
  BOTTOM w0.089: 217.29,166.53 217.46,166.7 LV6.3 217.49,167.03 217.6,167.14 217.6,167.14 217.6,167.37 RV503.1 217.59,168.02 v3(217.59,169.04) 217.59,170.37 217.84,170.62 218.12,170.62 v1(218.38,170.88)
TMDS_R_TX2P: length 14.8
  IN1 w0.089: v1(218.38,170.3) 218.09,170.58 216.84,170.58 216.08,171.34 212.59,171.34 211.66,172.26 211.66,173 212.49,173.83 212.49,173.93 JHDMI.1
  BOTTOM w0.089: v1(218.38,170.3) 218.32,170.35 217.95,170.35 217.86,170.26 217.86,168.02 RV503.2 217.86,167.38 217.86,167.25 217.99,167.13 LV6.2 218.16,166.53 218.18,166.53
TMDS_R_TXCN: length 9.3
  IN4 w0.089: v1(214.92,170.18) 215.06,170.33 216.54,170.33 217.25,171.03 217.25,172.38 JHDMI.12
  BOTTOM w0.089: v1(214.92,170.18) 215.1,170.36 215.29,170.36 215.38,170.28 215.38,167.98 RV500.1 215.39,167.32 215.39,167.14 215.28,167.03 LV3.3 215.11,166.49 RV641.2
TMDS_R_TXCP: length 9.3
  IN4 w0.089: JHDMI.10 216.99,172.38 216.99,171.14 216.44,170.59 215.1,170.59 v1(214.92,170.76)
  BOTTOM w0.089: v1(214.92,170.76) 215.05,170.63 215.4,170.63 215.65,170.39 v3(215.65,168.95) 215.65,167.98 RV500.2 215.66,167.35 215.66,167.09 215.78,166.98 LV3.2 215.95,166.49 RV640.2
TMDS_TX0N: length 109.5
  IN4 w0.089: v1(215.69,79.46) 215.69,79.92 215.6,80 210.18,80 209.19,80.99 209.19,82.2 207.78,83.61 207.78,88.45 207.31,88.92 207.31,98.38 202.64,103.06 202.64,107.24 199.94,109.93 199.94,114.24 200.39,114.68 200.39,121.29 200.66,121.56 200.66,133.29 201.3,133.94 201.3,140.96 201.86,143.01 210.58,151.73 212.09,151.73 212.21,151.85 212.96,151.85 214.13,153.02 214.13,155.94 213.85,156.22 212.42,156.22 212.25,156.39 212.07,156.39 211.56,156.9 211.56,157.44 211.81,157.69 v1(212.47,157.69)
  BOTTOM w0.089: CV1060.2 212.87,157.49 212.67,157.49 v1(212.47,157.69) ; v1(215.69,79.46) 215.93,79.7 215.93,79.96 216.13,80.16 216.59,80.16 216.94,79.81 216.94,78.57 217.33,78.18 221.23,78.18 222.31,79.26 222.31,80.22 222.6,80.51 222.87,80.51 223.02,80.66 UG1.BB38
TMDS_TX0P: length 109.5
  IN4 w0.089: v1(216.24,79.46) 216.21,79.46 215.88,79.79 215.88,79.99 215.67,80.21 210.26,80.21 209.39,81.08 209.39,82.28 207.98,83.69 207.98,88.54 207.51,89.01 207.51,98.47 202.84,103.14 202.84,107.32 200.15,110.01 200.15,114.16 200.59,114.6 200.59,121.2 200.86,121.48 200.86,133.21 201.51,133.85 201.51,140.93 202.04,142.9 202.04,142.91 210.67,151.53 212.18,151.53 212.29,151.65 213.05,151.65 214.33,152.94 214.33,156.02 213.94,156.42 212.51,156.42 212.34,156.59 212.16,156.59 211.76,156.99 211.76,157.35 211.9,157.49 212.1,157.49 212.47,157.12 v1(212.47,157.11)
  BOTTOM w0.089: CV1059.2 212.8,157.27 212.63,157.27 v1(212.47,157.11) ; v1(216.24,79.46) 216.11,79.58 216.11,79.89 216.2,79.98 216.52,79.98 216.72,79.78 216.72,78.48 217.24,77.96 221.32,77.96 222.49,79.13 222.49,80.14 222.68,80.33 222.98,80.33 223.07,80.24 223.07,79.95 UG1.BC38
TMDS_TX1N: length 103
  IN4 w0.089: v1(222.45,82.84) 222.08,82.47 221.97,82.47 221.78,82.27 221.78,80.66 221.35,80.24 217.64,80.24 216.39,78.99 210.19,78.99 208.33,80.85 208.33,82.21 206.71,83.83 206.71,90.43 199.19,110.23 199.19,114.79 199.66,115.26 199.66,121.59 199.86,121.79 199.86,133.96 200.49,134.59 200.49,140.67 201.2,143.19 210.38,152.38 211.93,152.38 212.45,152.9 212.45,154.99 212.11,155.34 211.78,155.34 v1(211.65,155.47)
  BOTTOM w0.089: v1(222.45,82.84) 222.69,82.6 UG1.AY38 ; CV1062.2 213.05,155.48 212.85,155.28 211.84,155.28 v1(211.65,155.47)
TMDS_TX1P: length 103
  IN4 w0.089: v1(211.65,154.88) 211.91,155.14 212.02,155.14 212.25,154.91 212.25,152.99 211.85,152.58 210.3,152.58 201.02,143.3 200.28,140.7 200.28,134.67 199.65,134.04 199.65,121.87 199.46,121.68 199.46,115.34 198.99,114.87 198.99,110.2 206.51,90.39 206.51,83.75 208.13,82.13 208.13,80.76 210.11,78.78 216.44,78.78 217.71,80.06 221.42,80.06 221.95,80.59 221.95,82.2 222.04,82.29 v1(222.45,82.29)
  BOTTOM w0.089: v1(211.65,154.88) 211.83,155.06 212.84,155.06 CV1061.2 ; UG1.AY39 222.14,82.6 v1(222.45,82.29)
TMDS_TX2N: length 100.5
  IN4 w0.089: v1(218.41,78.89) 217.42,77.9 209.64,77.9 206.76,80.77 206.76,81.9 205.25,83.41 205.25,90.87 198,109.98 198,115.58 198.54,116.13 198.54,122.07 198.76,122.29 198.76,134.93 199.41,135.58 199.41,142.83 210.33,153.74 v1(211.64,153.74)
  BOTTOM w0.089: UG1.BC39 221.82,80.04 221.62,80.23 221.41,80.23 220.38,79.21 219.01,79.21 218.88,79.08 218.6,79.08 v1(218.41,78.89) ; CV1064.2 212.87,153.91 212.44,153.91 212.13,153.6 211.78,153.6 v1(211.64,153.74)
TMDS_TX2P: length 100.4
  IN4 w0.089: v1(211.64,153.16) 211.26,153.54 210.41,153.54 199.61,142.74 199.61,135.49 198.97,134.85 198.97,122.21 198.75,121.99 198.75,116.04 198.2,115.5 198.2,110.02 205.46,90.91 205.46,83.49 206.97,81.98 206.97,80.85 209.72,78.1 217.33,78.1 218.05,78.82 218.05,79.28 218.21,79.44 v1(218.41,79.44)
  BOTTOM w0.089: v1(218.41,79.44) 218.41,79.44 218.6,79.25 218.81,79.25 218.94,79.38 220.25,79.38 221.32,80.45 221.58,80.45 221.82,80.69 UG1.BB39 ; v1(211.64,153.16) 211.87,153.38 212.23,153.38 212.53,153.69 212.89,153.69 CV1063.2
TMDS_TXCN: length 114.4
  IN4 w0.089: v1(212.37,160.33) 211.73,160.33 211.45,160.05 211.45,159.11 212.21,158.35 213.94,158.35 215.59,156.71 215.59,152.91 213.53,150.85 211,150.85 202.66,142.51 202.19,140.72 202.19,133.46 201.54,132.82 201.54,112.97 200.77,112.19 200.77,110.33 203.49,107.61 203.49,103.45 208.18,98.76 208.18,89.24 208.63,88.8 208.63,86.81 208.82,86.62 208.82,84 209.99,82.82 209.99,81.32 210.49,80.82 214.78,80.82 215.14,81.19 215.65,81.19 215.67,81.21 216.06,81.21 216.65,80.63 220.68,80.63 221.43,81.38 221.43,82.46 222.23,83.26 222.61,83.26 223.03,82.84 223.03,81.74 222.82,81.53 222.82,80.3 223.01,80.11 v1(223.55,80.11)
  BOTTOM w0.089: v1(212.37,160.33) 212.64,160.06 212.88,160.06 CV1057.2
  BOTTOM w0.107: v1(223.55,80.11) 224.01,80.11 UG1.BC36
TMDS_TXCP: length 114.3
  IN4 w0.089: v1(212.37,159.62) 212.41,159.67 212.41,159.79 212.26,159.95 212.19,159.95 212.01,160.13 211.82,160.13 211.65,159.97 211.65,159.2 212.3,158.55 214.02,158.55 215.79,156.79 215.79,152.82 213.61,150.65 211.08,150.65 202.84,142.41 202.39,140.7 202.39,133.38 201.74,132.73 201.74,112.88 200.97,112.11 200.97,110.42 203.69,107.69 203.69,103.53 208.39,98.84 208.39,89.33 208.83,88.88 208.83,86.89 209.02,86.7 209.02,84.08 210.19,82.91 210.19,81.41 210.58,81.02 214.69,81.02 215.06,81.39 216.13,81.39 216.72,80.8 220.61,80.8 221.26,81.45 221.26,82.53 222.16,83.43 222.69,83.43 223.21,82.91 223.21,81.67 223,81.45 223,80.38 223.08,80.29 223.22,80.29 223.59,80.66 v1(223.59,80.66)
  BOTTOM w0.089: CV1058.2 212.79,159.84 212.58,159.84 v1(212.37,159.62)
  BOTTOM w0.107: UG1.BB36 224.01,80.59 223.66,80.59 v1(223.59,80.66)
TOBII_INT: length 292.7
  TOP w0.107: v1(158.52,164.14) 158.56,164.18 JTOBII.6 ; v1(316.64,28.23) 316.61,28.19 v2(316.61,24.19) 316.61,23.11 317.41,22.31 317.41,21.61 316.92,21.13 RE651.2
  IN2 w0.091: v1(158.52,164.14) 157.35,162.97 157.35,158.48 156.95,158.08 156.95,154.27 159.04,152.18 164.79,152.18 167.72,149.25 168.37,149.25 169.38,148.24 174.28,148.24 174.99,147.53 176.2,147.53 176.91,148.24 185.97,148.24 190.39,143.82 190.39,128.13 183.69,121.44 183.69,111.49 182.85,110.65 182.85,110.08 181.98,109.2 181.98,107.15 182.85,106.27 182.85,100.78 184.83,98.8 184.83,94.67 186.87,92.63 186.87,72.81 187.24,72.44 187.24,70.73 188.41,69.56 189.11,69.56 197.53,61.15 205.18,61.15 210.87,55.47 210.87,54.32 212.01,53.18 212.01,52.09 214.36,49.73 215.6,48.49 225.86,48.49 226.98,47.38 258.29,47.38 259.34,46.32 267.68,46.32 271.37,42.63 271.37,40.89 274.5,37.76 284.88,37.76 286.15,36.5 288.48,36.5 293.88,31.1 300.23,31.1 303.27,28.06 316.45,28.06 316.62,28.23 v1(316.64,28.23)
  BOTTOM w0.107: RE300.1 155.24,167.8 155.55,167.48 155.55,166.71 156.48,165.78 157.47,165.78 158.52,164.73 v1(158.52,164.14)
TOBII_PWR_EN#: length 320.4
  TOP w0.107: v2(330.4,46.13) 330.82,45.71 v1(330.82,45.63) 330.82,45.62 330.82,45.47 330.54,45.19 UE6.17 ; v1(144.98,157.77) 145.36,158.15 145.36,161.23 146.3,162.17 146.3,164.09 145.66,164.73 UE12.4 145.66,166.4 CE79.1 145.37,166.68 RE652.2
  IN2 w0.091: v1(330.82,45.63) 330.83,45.64 330.83,45.77 330.53,46.07 330.02,46.07 329.55,45.6 329.55,42.11 328.44,41 327.28,41 326.47,40.19 326.47,33.44 320.85,27.83 301.69,27.83 298.64,30.88 293.79,30.88 288.39,36.28 284.98,36.28 283.72,37.54 274.41,37.54 271.15,40.8 271.15,42.54 267.6,46.09 229.56,46.09 228.49,47.16 217.84,47.16 216.95,48.06 215.35,48.06 211.57,51.83 211.57,52.75 210.37,53.95 210.37,55.28 205.02,60.62 197.29,60.62 189.05,68.86 188.38,68.86 186.68,70.56 186.68,72.19 186.43,72.43 186.43,92.44 184.38,94.49 184.38,98.63 182.42,100.59 182.42,106.09 181.54,106.97 181.54,110.51 183.16,112.12 183.16,121.68 189.95,128.48 189.95,143.33 185.51,147.78 177.26,147.78 176.52,147.03 174.44,147.03 173.67,147.8 169.09,147.8 168.08,148.81 167.53,148.81 164.61,151.73 158.75,151.73 154.42,156.07 153.03,156.07 151.52,157.58 145.17,157.58 v1(144.98,157.77)
TON_1.2V: length 2
  BOTTOM w0.203: PU201.9 94.88,43.6 PR206.2
TP_CLK: length 125.7
  TOP w0.107: RE100.2 303.06,5.91 303.06,6.43 302.9,6.59 v1(302.85,6.59) 302.85,6.79 302.75,6.9 302.38,6.9 301.94,7.33 UE5.87
  IN1 w0.097: v1(302.85,6.59) 302.9,6.59 303.26,6.23 303.26,6.16 303.09,5.99 298.98,5.99 295.98,8.99 295.98,10.83 295.03,11.78 292.81,11.78 291.42,13.17 277.62,13.17 277.31,12.85 275.66,12.85 274.08,11.27 266.75,11.27 266.52,11.5 242.49,11.5 241.27,10.28 234.1,10.28 232.98,9.17 226.33,9.17 225.55,8.39 214.42,8.39 214.09,8.05 192.9,8.05 192.54,8.41 192.18,8.41 v1(191.97,8.62)
  BOTTOM w0.107: v1(191.97,8.62) 191.8,8.45 191.29,8.45 191.19,8.55 191.19,10.17 191.32,10.3 JTP.12
TP_DATA: length 126.3
  TOP w0.107: UE5.88 302.34,7.26 302.47,7.13 302.95,7.13 v1(303.49,6.59) 303.3,6.4 303.3,5.77 RE101.2
  IN1 w0.097: v1(191.97,8.04) 192.12,8.19 192.45,8.19 192.81,7.83 214.18,7.83 214.52,8.17 225.65,8.17 226.42,8.94 233.07,8.94 234.19,10.06 241.37,10.06 242.58,11.28 266.42,11.28 266.65,11.05 274.17,11.05 275.75,12.63 277.4,12.63 277.72,12.95 291.32,12.95 292.71,11.56 294.94,11.56 295.76,10.73 295.76,8.89 298.89,5.76 303.18,5.76 303.49,6.07 v1(303.49,6.59)
  BOTTOM w0.107: v1(191.97,8.04) 191.8,8.21 191.2,8.21 190.95,8.46 190.95,10.17 190.82,10.3 JTP.13
