# Allegro board LAD752PR10-0816.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
CSOP_1: length 39.4
  TOP w0.254: PR722.2 58.37,16.81 PC717.1 PC716.2 58.38,15.82 v1(57.82,15.26)
  IN3 w0.254: v1(57.82,15.26) 60.45,17.89 62.08,17.89 64.64,15.34 65.22,15.34 66.43,14.13 78.14,14.13 81.97,17.96 81.97,19.14 82.34,19.51 82.34,21.65 v1(80.15,23.84)
  BOTTOM w0.254: v1(80.15,23.84) 80.15,23.91 79.83,24.23 PR712.2
CSP1: length 48.3
  TOP w0.107: v1(250.8,62.48) v2(250.03,62.48)
  IN3 w0.254: v1(278.06,54.13) 278.62,54.69 278.62,56.16 276.23,58.54 276.23,64.47 v1(277.87,66.1)
  IN4 w0.254: v1(277.87,66.1) 275.87,64.1 273.4,64.1 272.29,62.99 251.17,62.99 250.8,62.62 v1(250.8,62.48)
  BOTTOM w0.254: PR6015.1 v1(278.06,54.13) ; PR6046.2 279.62,67.85 v1(277.87,66.1) ; PL6101.2 v1(250.8,62.48)
CSP2: length 71.3
  TOP w0.107: v1(242.23,62.48) v2(242.23,61.77)
  IN1 w0.254: v1(242.23,62.48) 242.1,62.48 241.69,62.9 241.69,63.72 243.34,65.37 274.77,65.37 275.63,64.51 283.47,64.51 284.67,65.71 284.67,69.46 284.68,69.47 284.68,69.63 v1(285.38,70.33) 285.5,70.2 285.95,70.2 286.52,69.63 286.52,65.95 280.37,59.79 v1(278.14,59.79)
  BOTTOM w0.254: PR6040.2 284.55,69.5 v1(285.38,70.33) ; PR6021.1 v1(278.14,59.79) ; PL6200.2 v1(242.23,62.48)
CSP3: length 60
  TOP w0.107: v1(233.66,62.48) 233.02,62.48 v2(232.95,62.55)
  IN1 w0.254: v1(233.66,62.48) 234.14,62.97 234.14,64.05 236.03,65.93 275.45,65.93 276.26,65.12 278.43,65.12 v1(279.07,65.75)
  IN3 w0.254: v1(278.14,58.01) 279.07,58.93 v1(279.07,65.75)
  BOTTOM w0.254: v1(278.14,58.01) PR6022.1 ; PR6048.2 v1(279.07,65.75) ; PL6201.2 v1(233.66,62.48)
CSP4: length 73.8
  TOP w0.107: v1(224.96,63.48) v2(224.96,62.73)
  IN1 w0.254: v1(224.96,63.48) 225.21,63.72 225.69,63.72 226.32,64.36 226.32,65.31 227.88,66.87 275.85,66.87 276.27,67.29 281.65,67.29 282.99,68.64 283.57,68.64 284.05,69.11 284.05,69.76 283.64,70.17 v1(283.46,70.17)
  IN3 w0.254: v1(283.54,65.34) 284.11,65.91 284.11,69.7 283.64,70.17 v1(283.46,70.17)
  BOTTOM w0.254: PL6300.2 v1(224.96,63.48) ; v1(283.54,65.34) 283.49,65.28 PR6029.1 ; v1(283.46,70.17) 282.95,70.17 282.39,69.62 PR6044.2
CSP_VDDCI: length 21.7
  IN1 w0.254: v1(281.19,50.54) 280.08,50.54 279.36,51.26 276.36,51.26 275.19,52.43 275.19,56.84 274.87,57.16 v1(274.87,60.52)
  BOTTOM w0.254: v1(274.87,60.52) 273.58,61.82 273.06,61.82 272.58,61.34 PL6400.2 ; PR6068.1 282.32,48.79 PR6066.2 282.32,49.77 281.54,50.54 v1(281.19,50.54)
CSSN_1: length 20.5
  TOP w0.254: v1(61.03,26.7) 60.95,26.78 PR704.1
  IN3 w0.254: v1(61.03,26.7) 61.86,27.53 64.78,27.53 65.48,28.23 65.48,31.02 59.76,36.74 59.76,37.62 v1(59.57,37.81)
  BOTTOM w0.254: v1(59.57,37.81) 59,37.81 58.75,37.56 PR702.3
CSSN_2: length 6
  TOP w0.203: PU700.1 58.64,24.59 v1(59.05,25) 59.35,25.31 59.83,25.31 PR704.2
  BOTTOM w0.107: v2(60.97,25.31) 60.52,25.75 PC708.2
  BOTTOM w0.254: PC709.1 59.43,24.56 59.05,24.94 v1(59.05,25) 59.39,25.35 PC708.2
CSSP_1: length 25.7
  TOP w0.107: v2(59.51,27.78) 58.81,27.08 v1(58.81,26.89)
  TOP w0.254: v1(58.81,26.89) 58.87,26.89 58.98,26.78 PR703.1
  IN3 w0.254: v1(60.27,38.01) 60.27,36.86 65.9,31.23 65.9,28.08 64.97,27.15 62.24,27.15 61.29,26.19 59.51,26.19 v1(58.81,26.89)
  BOTTOM w0.254: PR702.2 58.75,38.58 59,38.32 59.95,38.32 v1(60.27,38.01)
CSSP_2: length 4.1
  TOP w0.203: PR703.2 59.21,25.87 v1(58.41,25.07) 58.24,24.9 PU700.2
  BOTTOM w0.254: PC707.2 58.37,25.02 v1(58.41,25.07) 58.48,25.14 PC708.1
CTL1: length 340.9
  TOP w0.107: UU1.6 24.64,44.33 v1(24.73,44.25) ; v1(327.86,32.86) 327.86,33.62 328.78,34.54 332.02,34.54 335,37.52 335,40.77 334.32,41.45 UE6.7
  IN2 w0.091: v1(327.86,32.86) 327.43,32.86 320.51,25.94 308.87,25.94 308.03,25.1 306.2,25.1 305.44,25.86 296.59,25.86 295.77,25.04 293,25.04 290.99,27.05 285.74,27.05 281.3,31.49 279.02,31.49 278.33,32.18 277.13,32.18 276.44,31.49 273.98,31.49 269.12,36.35 267.92,36.35 262.35,41.92 234,41.92 233.31,42.62 227.58,42.62 226.51,43.68 214.8,43.68 213.55,44.94 207.59,44.94 206.86,44.21 202.91,44.21 202.91,44.21 199.03,44.21 198.05,43.24 192.39,43.24 191.65,42.5 183.72,42.5 180.64,39.42 179.1,39.42 178.71,39.03 174.13,39.03 173.38,39.78 113.29,39.78 111.08,42 109.99,42 106.45,45.54 99.95,45.54 98.89,46.6 95.37,46.6 94.78,47.19 69.36,47.19 68.68,47.87 65.15,47.87 64.85,47.58 58.55,47.58 57.76,48.37 55.39,48.37 55.38,48.36 49.75,48.36 48.94,47.55 35.24,47.55 33.98,48.81 29.23,48.81 26.58,46.16 26.58,46.16 24.73,44.3 v1(24.73,44.25)
CTL2: length 344.5
  TOP w0.107: UE6.8 334.15,41.95 335.23,40.87 335.23,37.22 v2(332.92,34.91) 332.32,34.31 329.31,34.31 v1(328.37,33.37) ; UU1.7 v1(24.69,44.83)
  IN2 w0.091: v1(328.37,33.37) 327.63,33.37 320.42,26.16 308.78,26.16 307.94,25.32 306.29,25.32 305.53,26.08 296.5,26.08 295.68,25.26 293.09,25.26 291.08,27.26 285.83,27.26 281.39,31.71 279.31,31.71 278.62,32.4 277.04,32.4 276.35,31.71 274.07,31.71 269.15,36.63 267.95,36.63 262.44,42.14 234.09,42.14 233.4,42.84 227.67,42.84 226.6,43.9 214.89,43.9 213.64,45.16 207.5,45.16 206.77,44.43 203,44.43 203,44.43 198.94,44.43 197.96,43.46 192.3,43.46 191.56,42.72 183.63,42.72 180.55,39.64 179.01,39.64 178.62,39.25 174.22,39.25 171.42,42.05 171.42,45.02 170.91,45.53 170.14,46.3 155.74,46.3 154.94,45.5 154.52,45.5 153.72,46.3 147.74,46.3 146.92,45.48 146.59,45.48 145.85,46.22 109.28,46.22 108.82,45.76 100.05,45.76 98.98,46.82 95.46,46.82 94.59,47.69 85.3,47.69 84.89,48.09 65.06,48.09 64.76,47.79 58.65,47.79 57.85,48.59 55.3,48.59 55.29,48.58 44.99,48.58 44.18,47.77 35.33,47.77 34.07,49.03 29.06,49.03 24.87,44.83 v1(24.69,44.83)
DAT_SMB: length 10.5
  TOP w0.107: v1(84.78,9.25) 84.99,9.46 84.99,10.11 84.55,10.55 82.39,10.55 81.92,11.02 81.92,11.5 PR21.1
  BOTTOM w0.107: PBATT1.6 84.32,10.3 84.57,10.04 84.78,10.04 84.95,9.87 84.95,9.42 v1(84.78,9.25)
DBGDATA_6: length 18.9
  TOP w0.089: v1(238.06,84.82) v2(238.06,85.53)
  IN4 w0.089: 236.56,76.71 236.56,76.76 236.47,76.85 236.47,77.47 237.57,78.57 238.17,78.57 238.47,78.87 238.47,84.12 238.06,84.53 v1(238.06,84.82)
  IN4 w0.097: v1(232.38,74.85) 232.56,75.03 235.67,75.03 236.56,75.92 236.56,76.71
  BOTTOM w0.089: v1(238.06,84.82) 238.06,85.49 238.57,86 UG1.AT20
  BOTTOM w0.107: RG169.1 RG166.2 232.74,75.53 232.38,75.18 v1(232.38,74.85)
DBGDATA_7: length 15.3
  IN4 w0.089: 236.25,76.71 236.25,77.5 237.62,78.86 237.62,82.35 238.02,82.76 v1(238.02,82.92)
  IN4 w0.097: 236.25,76.71 236.25,75.92 235.58,75.25 231.96,75.25 v1(231.57,74.86)
  BOTTOM w0.089: UG1.AY20 238.34,82.6 v1(238.02,82.92)
  BOTTOM w0.107: v1(231.57,74.86) RG167.1 RG168.2
DDR4_DRAMRST#: length 17.1
  TOP w0.107: v1(138.23,40.18) 138.44,39.97 CD92.1 ; RD31.1 138.32,50.41 CD91.1 137.92,50.4 v1(137.41,49.88)
  IN3 w0.091: v1(138.23,40.18) 137.41,41.01 137.41,46.85 136.85,47.4 136.85,49.33 v1(137.41,49.88)
  BOTTOM w0.107: v1(137.41,49.88) 137.61,49.88 138.44,50.72 JDIMM1.108 ; v1(138.23,40.18) 138.44,39.97 JDIMM2.108
DDR_A_ACT#: length 47.3
  IN4 w0.152: v1(144.52,91.39) 145.11,90.81 145.11,86.65 144.7,86.24 144.7,74.34 140.08,69.72 140.08,64.22 138.89,63.03 138.89,56.08 139.83,55.14 v1(139.83,55.12)
  BOTTOM w0.076: CPU1.AU3 145.38,94.61 145.38,92.25 v1(144.52,91.39)
  BOTTOM w0.175: JDIMM1.114 139.94,52.63 139.2,53.37 139.2,54.47 139.83,55.1 v1(139.83,55.12)
DDR_A_ALERT#: length 53.3
  IN4 w0.152: v1(139.83,53.65) 139.11,52.93 137.43,52.93 135.75,54.61 135.75,63.75 137.35,65.35 137.35,70.86 141.88,75.38 141.88,88.41 143.57,90.1 143.57,92.39 v1(144.36,93.17)
  BOTTOM w0.076: CPU1.AU5 145.05,95.58 145.05,93.47 144.79,93.21 144.39,93.21 v1(144.36,93.17)
  BOTTOM w0.175: v1(139.83,53.65) 140.12,53.65 140.44,53.33 JDIMM1.116
DDR_A_BG0: length 49.1
  IN4 w0.152: v1(137.62,55.43) 136.54,56.51 136.54,63.42 138.14,65.02 138.14,70.53 142.67,75.06 142.67,87.37 v1(143.07,87.76)
  BOTTOM w0.076: CPU1.AU1 145.66,93.02 145.65,93.02 145.65,91.96 144.36,90.67 144.01,90.67 142.68,89.34 142.68,88.15 v1(143.07,87.76)
  BOTTOM w0.175: v1(137.62,55.43) 138.52,55.43 139.18,56.09 139.18,57.76 140.19,58.77 JDIMM1.115
DDR_A_BG1: length 46.2
  IN4 w0.152: v1(137.62,56.8) 137,57.42 137,63.23 138.6,64.83 138.6,70.33 143.22,74.96 143.22,85.32 143.46,85.56 143.46,88.64 v1(143.07,89.03)
  BOTTOM w0.076: v1(143.07,89.03) 143.07,89.14 145.93,92.01 145.93,93.7 145.66,93.98 CPU1.AU2
  BOTTOM w0.175: v1(137.62,56.8) 138.17,56.8 138.7,57.33 138.7,57.96 139.69,58.95 JDIMM1.113
DDR_A_BS0: length 50.3
  IN4 w0.089: v1(152.29,92.42) 153.3,91.42 153.3,86.05 154.68,84.67 154.68,83.85
  IN4 w0.152: v1(150.91,53.67) 150.91,53 150.65,52.74 150.19,52.74 149.93,53 149.93,61.63 150.46,62.16 150.46,62.53 150.92,62.99 150.92,66.33 154.68,70.09 154.68,83.85
  BOTTOM w0.076: v1(152.29,92.42) 152.74,92.88 152.74,95.73 CPU1.AH5
  BOTTOM w0.175: JDIMM1.150 150.94,53.64 v1(150.91,53.67)
DDR_A_BS1: length 48.4
  IN4 w0.089: v1(152.31,90.5) 152.75,90.5 152.94,90.31 152.94,85.57 153.76,84.75 153.76,83.85
  IN4 w0.152: v1(148.86,58.5) 149.01,58.65 149.01,63.32 149.16,63.48 149.85,63.48 150,63.63 150,63.94 149.85,64.1 149.16,64.1 149.01,64.25 149.01,64.56 149.16,64.72 149.85,64.72 150,64.87 150,65.18 149.85,65.33 149.16,65.33 149.01,65.49 149.01,65.71 153.76,70.47 153.76,83.85
  BOTTOM w0.076: CPU1.AH1 153.2,91.32 153.12,91.24 152.87,91.24 152.79,91.16 152.79,91.01 152.87,90.94 153.12,90.94 153.2,90.86 153.2,90.71 153.12,90.63 152.87,90.63 152.79,90.56 152.79,90.4 152.87,90.33 153.12,90.33 153.2,90.25 153.2,89.66 153.11,89.57 152.74,89.57 152.65,89.65 152.65,90.01 152.31,90.35 v1(152.31,90.5)
  BOTTOM w0.175: JDIMM1.145 149.69,59.01 149.8,58.9 149.8,58.02 149.63,57.85 149.37,57.85 148.86,58.36 v1(148.86,58.5)
DDR_A_CAS#: length 51.5
  IN4 w0.152: v1(154.82,87.32) 155.57,87.32 158.64,84.25 158.64,68.14 154.41,63.91 154.41,59.75 153.9,59.23 153.9,57.91 154.05,57.76 154.1,57.76 154.25,57.6 154.25,57.29 154.1,57.14 154.04,57.14 153.88,56.98 153.88,56.67 154.04,56.52 154.1,56.52 154.25,56.36 154.25,56.05 154.1,55.9 154.01,55.9 153.85,55.74 153.85,55.43 154.01,55.28 154.1,55.28 154.25,55.12 154.25,54.84 154.1,54.69 v1(153.5,54.69)
  BOTTOM w0.076: v1(154.82,87.32) 154.36,87.32 154.19,87.15 154.19,86.77 154.38,86.58 155.27,86.58 156.73,88.04 156.73,93.31 CPU1.AD1
  BOTTOM w0.175: v1(153.5,54.69) 152.44,53.63 JDIMM1.156
DDR_A_D0: length 57.4
  IN4 w0.097: v1(130.46,95.72) 130.33,95.85 129.94,95.85 126.49,92.4 126.49,86.65 125.1,85.26 125.1,82.85 120.42,78.16 120.42,72.48 117.49,69.55 117.35,69.55 117.16,69.74 117.02,69.74 116.89,69.6 116.89,69.47 117.08,69.27 117.08,69.14 116.87,68.93 116.66,68.93 116.28,69.31 115.9,69.31 115.62,69.03 115.62,67.85 113.82,66.05 113.82,61.98 113.14,61.3 113.14,55.73 v1(112.68,55.27)
  BOTTOM w0.076: CPU1.BR6 132.92,96.88 132.09,96.88 132.04,96.82 131.69,96.82 131.61,96.9 130.96,96.9 130.46,96.41 v1(130.46,95.72)
  BOTTOM w0.107: JDIMM1.4 112.44,53.17 112.22,53.39 112.22,54.81 v1(112.68,55.27)
DDR_A_D1: length 57.1
  IN4 w0.097: v1(131.84,97.18) 131.14,97.18 130.33,96.36 129.6,96.36 125.89,92.66 125.89,86.91 124.5,85.52 124.5,83.12 119.8,78.42 119.8,74.29 119.37,73.86 119.37,73.73 119.68,73.42 119.68,73.28 119.54,73.15 119.41,73.15 119.1,73.46 118.96,73.46 118.83,73.32 118.83,73.18 119.1,72.91 119.1,72.77 118.96,72.63 118.83,72.63 118.55,72.91 118.42,72.91 118.28,72.77 118.28,72.64 118.56,72.36 118.56,72.22 118.42,72.09 118.28,72.09 118.01,72.36 117.87,72.36 113.21,67.71 113.21,62.23 112.53,61.55 112.53,59.31 111.97,58.75 111.97,57.24 v1(112.68,56.54)
  BOTTOM w0.076: v1(131.84,97.18) CPU1.BT6
  BOTTOM w0.107: v1(112.68,56.54) 112.19,57.02 JDIMM1.3
DDR_A_D2: length 57.4
  IN4 w0.097: v1(115.34,55.27) 116.2,55.27 116.34,55.4 116.34,55.6 116.21,55.72 115.86,55.72 115.75,55.83 115.75,56.05 115.87,56.17 116.28,56.17 116.34,56.23 116.34,58.24 116.78,58.68 116.78,61.37 117.59,62.18 117.59,66.59 122.8,71.8 122.8,73.11 122.9,73.21 123.42,73.21 123.52,73.3 123.52,73.5 123.42,73.59 122.9,73.59 122.8,73.69 122.8,73.91 122.9,74.01 123.67,74.01 123.77,74.11 123.77,74.33 123.66,74.44 122.9,74.44 122.8,74.54 122.8,74.93 122.9,75.03 123.27,75.03 123.67,75.42 123.67,76.72 127.21,80.27 127.21,83.78 128.76,85.32 128.76,90.86 131.46,93.57 131.46,94.17 v1(131.33,94.3)
  BOTTOM w0.076: CPU1.BP3 133.43,95.29 132.87,95.29 132.85,95.27 132.27,95.27 132.05,95.05 131.55,95.05 131.33,94.83 v1(131.33,94.3)
  BOTTOM w0.107: JDIMM1.20 116.44,54.17 v1(115.34,55.27)
DDR_A_D3: length 57
  IN4 w0.097: v1(115.34,57.81) 115.34,58.09 115.45,58.2 115.67,58.2 115.74,58.26 115.74,58.48 115.64,58.58 115.41,58.58 115.32,58.67 115.32,58.83 115.42,58.93 115.64,58.93 115.74,59.03 115.74,59.22 115.64,59.32 115.44,59.32 115.34,59.42 115.34,61.19 115.68,61.53 115.68,61.66 115.33,62.02 115.33,62.16 115.47,62.3 115.61,62.3 116.12,61.79 116.26,61.79 116.4,61.93 116.4,62.07 115.71,62.76 115.71,62.9 115.85,63.04 115.99,63.04 116.64,62.39 116.85,62.39 116.99,62.53 116.99,63.39 116.82,63.55 115.42,63.55 115.33,63.65 115.33,63.91 115.42,64.01 116.89,64.01 116.99,64.11 116.99,64.31 116.89,64.41 116.19,64.41 116.09,64.5 116.09,64.71 116.19,64.81 116.89,64.81 116.99,64.91 116.99,66.92 122.18,72.12 122.18,76.43 126.61,80.86 126.61,84.03 128.15,85.57 128.15,91.48 130.46,93.78 v1(131,93.78)
  BOTTOM w0.076: v1(131,93.78) 131.05,93.83 131.4,93.83 132.07,94.5 132.49,94.5 132.96,94.97 CPU1.BR3
  BOTTOM w0.107: JDIMM1.17 115.69,58.16 v1(115.34,57.81)
DDR_A_D4: length 57.4
  IN4 w0.097: v1(129.99,95.38) 129.9,95.38 126.79,92.28 126.79,86.52 125.41,85.14 125.41,82.58 120.72,77.89 120.72,72.36 114.12,65.76 114.12,61.85 113.44,61.17 113.44,54.76 v1(112.68,54)
  BOTTOM w0.076: v1(129.99,95.38) 129.99,96.18 130.89,97.07 131.22,97.07 131.69,97.53 132.68,97.53 132.91,97.31 133.66,97.31 134.19,96.78 CPU1.BN5
  BOTTOM w0.107: v1(112.68,54) 113.44,53.23 JDIMM1.8
DDR_A_D5: length 56.9
  IN4 w0.097: v1(112.68,57.81) 112.27,58.21 112.27,58.63 112.83,59.19 112.83,61.42 113.52,62.11 113.52,66.17 115.32,67.97 115.32,69.15 115.85,69.69 116.55,69.69 117.2,70.34 117.33,70.34 117.52,70.14 117.66,70.14 117.8,70.28 117.8,70.42 117.61,70.61 117.61,70.75 117.74,70.88 117.88,70.88 118.07,70.69 118.21,70.69 118.34,70.83 118.34,70.96 118.15,71.15 118.15,71.29 118.29,71.43 118.42,71.43 118.62,71.24 118.75,71.24 118.89,71.37 118.89,71.51 118.7,71.7 118.7,71.84 118.83,71.97 118.97,71.97 119.16,71.78 119.3,71.78 119.43,71.92 119.43,72.06 119.24,72.25 119.24,72.38 119.38,72.52 119.52,72.52 119.71,72.33 119.84,72.33 119.98,72.47 119.98,72.6 119.79,72.79 119.79,72.93 120.12,73.26 120.12,78.29 124.8,82.97 124.8,85.39 126.19,86.78 126.19,92.53 129.75,96.08 130.77,96.08 v1(130.83,96.15)
  BOTTOM w0.076: v1(130.83,96.15) 130.83,96.55 131.02,96.74 131.54,96.74 131.62,96.66 132.16,96.66 132.22,96.71 132.63,96.71 132.78,96.57 132.82,96.57 132.9,96.49 133.31,96.49 133.7,96.88 CPU1.BP6
  BOTTOM w0.107: v1(112.68,57.81) 112.8,57.81 113.25,58.26 113.25,58.9 113.19,58.96 JDIMM1.7
DDR_A_D6: length 57
  IN4 w0.097: v1(115.34,54) 115.34,53.28 115.44,53.18 116.42,53.18 116.52,53.28 116.52,53.55 116.42,53.65 116,53.65 115.9,53.75 115.9,53.95 116,54.05 116.42,54.05 116.52,54.15 116.52,54.37 116.42,54.47 116,54.47 115.9,54.57 115.9,54.77 116,54.87 116.54,54.87 116.64,54.97 116.64,58.11 117.08,58.55 117.08,61.24 117.89,62.05 117.89,62.5 117.99,62.6 118.19,62.6 118.29,62.7 118.29,62.9 118.19,63 117.99,63 117.89,63.1 117.89,63.29 117.99,63.39 118.19,63.39 118.29,63.49 118.29,63.69 118.19,63.79 117.99,63.79 117.89,63.89 117.89,66.46 124.07,72.63 124.07,76.69 127.52,80.14 127.52,83.66 129.14,85.28 129.14,90.49 v1(130.39,91.74)
  BOTTOM w0.076: CPU1.BP2 133.98,94.14 133.98,93.45 133.78,93.26 133.69,93.26 133.04,92.6 132.77,92.6 131.91,91.74 v1(130.39,91.74)
  BOTTOM w0.107: JDIMM1.16 115.44,53.9 v1(115.34,54)
DDR_A_D7: length 57.5
  IN4 w0.097: v1(115.34,56.54) 115.94,56.54 116.04,56.64 116.04,57.14 115.92,57.26 115.8,57.26 115.7,57.36 115.7,57.55 115.8,57.65 115.94,57.65 116.04,57.75 116.04,58.99 116.16,59.12 116.39,59.12 116.49,59.22 116.49,59.52 116.39,59.62 115.74,59.62 115.64,59.72 115.64,59.92 115.74,60.02 116.39,60.02 116.49,60.11 116.49,60.31 116.39,60.41 115.74,60.41 115.64,60.51 115.64,60.71 115.74,60.81 116.39,60.81 116.49,60.91 116.49,61.5 117.29,62.3 117.29,66.71 122.5,71.93 122.5,75.4 122.6,75.5 123.23,75.5 123.33,75.6 123.33,75.8 123.23,75.9 122.58,75.9 122.48,76 122.48,76.2 122.58,76.3 123.27,76.3 123.37,76.4 123.37,77.18 126.91,80.73 126.91,83.9 128.45,85.44 128.45,91.12 v1(130.17,92.84)
  BOTTOM w0.076: v1(130.17,92.84) 130.57,92.84 131.25,93.52 131.41,93.52 131.56,93.37 132.11,93.37 132.7,93.96 132.7,94.06 132.7,94.41 132.72,94.44 132.91,94.63 133.13,94.63 133.24,94.75 134.14,94.75 CPU1.BN3
  BOTTOM w0.107: JDIMM1.21 116.69,58.53 116.02,57.86 116.02,57.21 v1(115.34,56.54)
DDR_A_D8: length 53.4
  IN4 w0.097: v1(135.99,95.21) 135.37,94.59 134.01,94.59 129.86,90.43 129.86,83.27 129.7,83.11 129.38,83.11 129.28,83.01 129.28,82.82 129.38,82.72 129.7,82.72 129.86,82.56 129.86,81.02 125.1,76.26 125.1,72.21 119.33,66.44 119.33,62.04 118.82,61.54 118.82,60.85 118.13,60.16 118.13,57.45 118.03,57.36 117.88,57.36 117.78,57.26 117.78,57.07 117.88,56.97 118.03,56.97 118.13,56.87 118.13,56.63 118.03,56.54 v1(117.38,56.54)
  BOTTOM w0.076: CPU1.BL4 135.67,95.54 v1(135.99,95.21)
  BOTTOM w0.107: v1(117.38,56.54) 118.69,57.86 JDIMM1.29
DDR_A_D9: length 53.3
  IN4 w0.097: v1(117.38,57.81) 117.82,58.25 117.82,60.27 118.52,60.97 118.52,61.66 119.02,62.17 119.02,64.38 118.92,64.48 118.73,64.48 118.63,64.58 118.63,64.78 118.73,64.87 118.92,64.87 119.02,64.97 119.02,65.17 118.92,65.27 118.73,65.27 118.63,65.37 118.63,65.57 118.73,65.67 118.92,65.67 119.02,65.77 119.02,66.56 124.8,72.33 124.8,76.39 128.7,80.29 128.7,81.11 128.8,81.21 129.46,81.21 129.56,81.3 129.56,81.49 129.46,81.59 128.8,81.59 128.7,81.69 128.7,81.88 128.8,81.98 129.46,81.98 129.56,82.07 129.56,82.27 129.46,82.36 128.8,82.36 128.7,82.46 128.7,83.58 129.55,84.43 129.55,90.39 133.94,94.77 134.9,94.77 v1(135.99,95.86)
  BOTTOM w0.076: CPU1.BL5 135.67,96.19 v1(135.99,95.86)
  BOTTOM w0.107: v1(117.38,57.81) 117.69,58.13 JDIMM1.25
DDR_A_D10: length 54
  IN4 w0.097: v1(133.47,91.87) 133.47,91.45 133.1,91.09 133.1,90.33 132.03,89.25 132.03,79.9 127.71,75.58 127.71,71.44 124.22,67.95 124.22,67.81 124.66,67.36 124.66,67.22 124.52,67.08 124.38,67.08 123.94,67.53 123.8,67.53 123.66,67.39 123.66,67.25 124.1,66.8 124.1,66.66 123.96,66.52 123.82,66.52 123.38,66.97 123.24,66.97 123.1,66.82 123.1,66.68 123.54,66.24 123.54,66.1 123.4,65.96 123.26,65.96 122.82,66.4 122.68,66.4 122.54,66.26 122.54,66.12 122.98,65.68 122.98,65.54 122.82,65.38 122.68,65.38 122.34,65.71 122.2,65.71 122.06,65.57 122.06,65.43 122.4,65.1 122.4,64.96 122.23,64.79 122.23,59.74 120.99,58.5 120.99,56.94 v1(120.59,56.54)
  BOTTOM w0.076: v1(133.47,91.87) 133.47,92.6 134.09,93.22 134.52,93.22 134.72,93.42 134.72,93.64 135.31,94.24 CPU1.BL2
  BOTTOM w0.107: JDIMM1.41 121.69,57.64 v1(120.59,56.54)
DDR_A_D11: length 54.1
  IN4 w0.097: v1(133.91,92.28) 133.91,91.58 133.36,91.03 133.36,90.2 132.41,89.25 132.41,79.85 128.01,75.46 128.01,71.31 126.4,69.7 126.4,69.56 126.84,69.11 126.84,68.97 126.7,68.83 126.56,68.83 126.12,69.28 125.98,69.28 125.84,69.14 125.84,69 126.28,68.55 126.28,68.41 126.14,68.27 126,68.27 125.56,68.72 125.42,68.72 125.28,68.58 125.28,68.44 125.72,67.99 125.72,67.85 125.58,67.71 125.44,67.71 125,68.16 124.86,68.16 124.72,68.02 124.72,67.88 125.16,67.43 125.16,67.29 122.66,64.79 122.66,59.75 121.34,58.42 121.34,56.17 121.24,56.07 121.09,56.07 120.99,55.98 120.99,55.78 121.09,55.69 121.24,55.69 121.34,55.59 121.34,55.39 121.22,55.27 v1(120.59,55.27)
  BOTTOM w0.076: CPU1.BM1 135.12,93.59 134.58,93.05 134.19,93.05 133.91,92.77 v1(133.91,92.28)
  BOTTOM w0.107: JDIMM1.42 121.94,53.94 120.61,55.27 v1(120.59,55.27)
DDR_A_D12: length 53.2
  IN4 w0.097: v1(117.38,54) 118.17,54 118.44,54.26 118.44,55.9 118.73,56.2 118.73,59.73 119.93,60.93 119.93,66.19 125.7,71.96 125.7,76.01 130.46,80.78 130.46,90.16 134.25,93.95 135.51,93.95 136.78,95.21 v1(136.78,95.21)
  BOTTOM w0.076: v1(136.78,95.21) CPU1.BK4
  BOTTOM w0.107: v1(117.38,54) 117.44,53.93 JDIMM1.24
DDR_A_D13: length 54
  IN4 w0.097: v1(117.38,55.27) 118.43,56.32 118.43,60.03 119.12,60.72 119.12,61.41 119.63,61.92 119.63,66.31 125.4,72.08 125.4,76.14 130.16,80.9 130.16,90.47 134.09,94.4 135.7,94.4 136.4,95.1 136.4,95.43 v1(136.79,95.81)
  BOTTOM w0.089: v1(136.79,95.81) 136.41,96.19 CPU1.BK5
  BOTTOM w0.107: JDIMM1.28 118.44,53.2 117.79,53.86 117.79,54.86 v1(117.38,55.27)
DDR_A_D14: length 53.3
  IN4 w0.097: v1(120.59,54) 121.64,54 121.74,54.09 121.74,54.34 121.64,54.43 121.2,54.43 121.1,54.53 121.1,54.72 121.2,54.82 121.64,54.82 121.74,54.92 121.74,58.39 122.96,59.62 122.96,64.66 127.39,69.09 127.39,69.23 126.94,69.67 126.94,69.81 127.08,69.96 127.22,69.96 127.67,69.51 127.81,69.51 127.95,69.65 127.95,69.79 127.5,70.24 127.5,70.38 127.64,70.52 127.78,70.52 128.23,70.07 128.37,70.07 128.51,70.21 128.51,70.35 128.06,70.8 128.06,70.94 128.2,71.08 128.31,71.19 128.31,75.33 132.72,79.74 132.72,89.19 133.61,90.08 133.61,90.96 134.91,92.26 v1(134.91,92.82)
  BOTTOM w0.076: 135.8,93.59 135.26,93.04 135.13,93.04 v1(134.91,92.82)
  BOTTOM w0.089: CPU1.BK1 135.8,93.59
  BOTTOM w0.107: JDIMM1.38 120.94,53.64 v1(120.59,54)
DDR_A_D15: length 54.6
  IN4 w0.089: v1(131.69,89.61) 131.69,84.76 131.7,84.74 131.7,83.85
  IN4 w0.097: v1(120.59,57.81) 120.59,58.9 120.47,59.02 120.23,59.02 120.13,59.12 120.13,59.41 120.26,59.54 121.58,59.54 121.67,59.64 121.67,59.82 121.58,59.92 121.03,59.92 120.94,60.01 120.94,60.22 121.03,60.31 121.83,60.31 121.93,60.41 121.93,60.67 121.83,60.77 121.33,60.77 121.23,60.87 121.23,61.07 121.32,61.17 121.83,61.17 121.93,61.27 121.93,62.52 121.8,62.64 121.33,62.64 121.23,62.74 121.23,62.96 121.33,63.06 121.83,63.06 121.93,63.16 121.93,63.36 121.83,63.46 121.33,63.46 121.23,63.56 121.23,63.75 121.33,63.85 121.83,63.85 121.93,63.95 121.93,64.15 121.83,64.25 121.33,64.25 121.23,64.35 121.23,64.55 121.33,64.65 121.83,64.65 121.93,64.74 121.93,64.94 121.83,65.04 121.36,65.04 121.26,65.14 121.26,65.42 121.64,65.8 121.64,65.8 127.41,71.56 127.41,75.71 131.7,80.01 131.7,83.85
  BOTTOM w0.089: CPU1.BK2 136.67,93.95 136.67,92.99 133.28,89.61 v1(131.69,89.61)
  BOTTOM w0.107: JDIMM1.37 120.69,57.91 v1(120.59,57.81)
DDR_A_D16: length 50.4
  IN4 w0.097: v1(136.79,92.4) 135.69,92.4 134.06,90.77 134.06,89.82 133.23,89 133.23,86.35 133.53,86.05 133.53,79.07 129.24,74.78 129.24,69.91 124.26,64.93 124.26,64.36 124.16,64.26 123.79,64.26 123.69,64.16 123.69,63.96 123.79,63.86 124.16,63.86 124.26,63.77 124.26,63.57 124.16,63.47 123.79,63.47 123.69,63.37 123.69,63.17 123.79,63.07 124.16,63.07 124.26,62.97 124.26,62.77 124.16,62.68 123.79,62.68 123.69,62.58 123.69,62.38 123.79,62.28 124.16,62.28 124.26,62.18 124.26,59.88 122.95,58.57 v1(122.95,57.81)
  BOTTOM w0.076: v1(136.79,92.4) 137.27,92.4 137.54,92.67 137.54,93.02 137.41,93.15 137.41,93.88 137.51,93.98 137.51,95.17 137.88,95.54 CPU1.BG4
  BOTTOM w0.107: JDIMM1.45 122.69,58.06 v1(122.95,57.81)
DDR_A_D17: length 51.2
  IN4 w0.097: v1(122.95,56.54) 123.45,57.04 123.45,58.64 124.69,59.88 124.69,64.93 129.54,69.78 129.54,74.65 133.84,78.94 133.84,86.42 133.55,86.71 133.55,88.93 134.25,89.63 134.25,90.58 135.62,91.96 v1(136.4,91.96)
  BOTTOM w0.076: CPU1.BG5 138.39,95.91 138.39,95.42 138.22,95.25 137.96,95.25 137.72,95.01 137.72,93.89 137.67,93.84 137.67,93.2 137.71,93.16 137.71,92.6 137.06,91.96 v1(136.4,91.96)
  BOTTOM w0.107: v1(122.95,56.54) 123.69,57.28 JDIMM1.49
DDR_A_D18: length 50.2
  IN4 w0.097: v1(139.28,95.26) 138.34,94.32 138.34,93.17 136.02,90.85 136.02,77.61 131.71,73.3 131.71,69.31 128.73,66.33 128.73,65.67 128.63,65.57 128.31,65.57 128.22,65.47 128.22,65.27 128.31,65.18 128.63,65.18 128.73,65.08 128.73,64.88 128.63,64.78 128.31,64.78 128.22,64.68 128.22,64.48 128.31,64.38 128.63,64.38 128.73,64.28 128.73,64.04 128.57,63.89 127.63,63.89 127.53,63.79 127.53,63.59 127.63,63.49 128.12,63.49 128.22,63.39 128.22,63.19 128.12,63.1 127.63,63.1 127.53,63 127.53,62.8 127.63,62.7 128.12,62.7 128.22,62.6 128.22,62.4 128.12,62.3 127.63,62.3 127.53,62.2 127.53,60.42 126.51,59.39 v1(126.51,57.81)
  BOTTOM w0.076: CPU1.BF4 139.01,95.54 v1(139.28,95.26)
  BOTTOM w0.107: JDIMM1.63 127.19,58.5 v1(126.51,57.81)
DDR_A_D19: length 50.4
  IN4 w0.097: v1(139.29,95.86) 139.67,95.49 139.67,95.11 139.43,94.87 139.16,94.87 138.61,94.32 138.61,93.15 136.29,90.83 136.29,86.72 136.33,86.68 136.33,77.49 132.01,73.17 132.01,69.19 129.03,66.21 129.03,63.04 128.93,62.94 128.63,62.94 128.53,62.84 128.53,62.64 128.63,62.54 128.93,62.54 129.03,62.44 129.03,62.24 128.93,62.14 128.48,62.14 128.34,62.01 128.34,60.72 127.28,59.66 127.28,57.31 v1(126.51,56.54)
  BOTTOM w0.076: v1(139.29,95.86) 138.97,96.19 CPU1.BF5
  BOTTOM w0.107: JDIMM1.59 126.19,58.72 126.09,58.62 126.09,56.95 v1(126.51,56.54)
DDR_A_D20: length 50.4
  IN4 w0.097: v1(135.62,91.06) 134.99,91.06 134.5,90.57 134.5,89.62 133.93,89.05 133.93,86.77 134.14,86.56 134.14,78.82 129.84,74.52 129.84,69.65 124.99,64.81 124.99,59.61 123.83,58.45 123.83,56.15 v1(122.95,55.27)
  BOTTOM w0.076: v1(135.62,91.06) 136.17,91.06 136.74,91.62 137.21,91.62 138,92.41 138,93.18 137.83,93.34 137.83,93.72 137.92,93.81 137.92,94.05 CPU1.BG2
  BOTTOM w0.107: JDIMM1.50 123.94,54.29 122.96,55.27 v1(122.95,55.27)
DDR_A_D21: length 50.8
  IN4 w0.097: v1(135.17,90.61) 134.69,90.13 134.69,89.54 134.17,89.02 134.17,86.88 134.44,86.61 134.44,78.39 130.25,74.2 130.25,69.63 126.12,65.5 126.12,64.55 126.02,64.46 125.39,64.46 125.29,64.36 125.29,64.16 125.39,64.06 125.96,64.06 126.06,63.96 126.06,63.76 125.96,63.66 125.39,63.66 125.3,63.57 125.3,59.41 124.15,58.26 124.15,55.2 v1(122.95,54)
  BOTTOM w0.076: CPU1.BG1 138.11,93.46 138.2,93.37 138.2,92.32 136.49,90.61 v1(135.17,90.61)
  BOTTOM w0.107: v1(122.95,54) 122.94,53.99 JDIMM1.46
DDR_A_D22: length 50.2
  IN4 w0.097: v1(126.51,54) 127.38,54 127.88,54.5 127.88,59.35 129.63,61.1 129.63,65.03 131.68,67.09 131.68,67.23 131.36,67.55 131.36,67.69 131.5,67.83 131.64,67.83 131.96,67.51 132.1,67.51 132.24,67.65 132.24,67.79 131.92,68.11 131.92,68.25 132.06,68.39 132.2,68.39 132.38,68.21 132.52,68.21 132.62,68.31 132.62,72.92 137.01,77.31 137.01,89.03 136.72,89.31 136.72,90.57 139.29,93.14 v1(139.29,93.26)
  BOTTOM w0.076: CPU1.BF1 138.97,93.59 v1(139.29,93.26)
  BOTTOM w0.107: v1(126.51,54) 126.94,53.56 JDIMM1.62
DDR_A_D23: length 50.7
  IN4 w0.097: v1(126.51,55.27) 127.58,56.34 127.58,59.47 129.33,61.22 129.33,65.16 130.03,65.86 130.03,66 129.72,66.3 129.72,66.44 129.86,66.58 130,66.58 130.31,66.28 130.45,66.28 130.62,66.45 130.62,66.59 130.32,66.89 130.32,67.03 130.46,67.17 130.6,67.17 130.9,66.87 131.04,66.87 131.18,67.01 131.18,67.15 130.85,67.47 130.85,67.61 132.31,69.07 132.31,73.05 136.7,77.44 136.7,86.56 136.48,86.79 136.48,90.73 138.92,93.17 138.92,93.53 v1(139.29,93.91)
  BOTTOM w0.076: v1(139.29,93.91) 138.97,94.24 CPU1.BF2
  BOTTOM w0.107: JDIMM1.58 125.94,54.7 v1(126.51,55.27)
DDR_A_D24: length 49.3
  IN4 w0.097: v1(137.95,90.64) 138.04,90.54 138.04,76.88 133.65,72.49 133.65,67.09 133.55,66.99 133.41,66.99 133.31,67.1 133.17,67.1 133.03,66.96 133.03,66.82 133.29,66.55 133.29,66.41 133.15,66.27 133.01,66.27 132.74,66.54 132.6,66.54 132.46,66.4 132.46,66.26 132.73,65.99 132.73,65.85 132.59,65.71 132.45,65.71 132.18,65.98 132.04,65.98 131.9,65.84 131.9,65.7 132.17,65.43 132.17,65.29 132.03,65.15 131.89,65.15 131.62,65.42 131.48,65.42 131.34,65.28 131.34,65.14 131.61,64.87 131.61,64.73 130.77,63.89 130.77,60.01 130.51,59.75 130.51,59.61 130.8,59.33 130.8,59.19 130.66,59.05 130.52,59.05 130.23,59.33 130.09,59.33 129.63,58.87 129.63,58.72 129.77,58.59 129.77,58.45 129.58,58.26 129.42,58.26 129.29,58.39 129.15,58.39 129.02,58.26 v1(129.02,57.81)
  BOTTOM w0.076: v1(137.95,90.64) 138.5,90.64 139.14,91.28 139.4,91.28 140.41,92.29 140.41,93.28 140.35,93.34 140.35,93.72 140.63,94 CPU1.BD2
  BOTTOM w0.107: v1(129.02,57.81) 128.19,58.64 JDIMM1.67
DDR_A_D25: length 49.3
  IN4 w0.097: v1(129.02,54) 128.62,54.4 128.62,58.28 129.46,59.13 129.46,59.27 129.22,59.51 129.22,59.65 129.36,59.79 129.5,59.79 129.74,59.55 129.88,59.55 130.02,59.69 130.02,59.83 129.81,60.04 129.81,60.18 129.96,60.32 130.1,60.32 130.24,60.18 130.38,60.18 130.47,60.27 130.47,64.84 133.35,67.71 133.35,72.61 137.74,77.01 137.74,89.95 v1(137.5,90.19)
  BOTTOM w0.076: CPU1.BD1 140.63,92.18 139.38,90.94 138.63,90.19 v1(137.5,90.19)
  BOTTOM w0.107: JDIMM1.70 128.94,53.92 v1(129.02,54)
DDR_A_D26: length 49
  IN4 w0.089: 140.8,89.01 140.52,88.72 140.52,83.85
  IN4 w0.097: 140.8,89.01 140.8,94.16 v1(141.86,95.21) ; 140.52,83.85 140.52,75.95 135.98,71.42 135.98,66.03 133.71,63.76 133.71,63.45 133.81,63.35 134.28,63.35 134.38,63.25 134.38,63.05 134.28,62.95 133.81,62.95 133.71,62.85 133.71,56.89 133.35,56.54 v1(132.17,56.54)
  BOTTOM w0.076: CPU1.BC4 141.53,95.54 v1(141.86,95.21)
  BOTTOM w0.107: JDIMM1.79 131.19,57.51 v1(132.17,56.54)
DDR_A_D27: length 48.7
  IN4 w0.089: 140.21,83.88 140.21,88.86 140.51,89.15
  IN4 w0.097: v1(132.17,57.81) 133.03,57.81 133.4,58.18 133.4,58.67 133.31,58.77 132.84,58.77 132.74,58.87 132.74,59.06 132.84,59.16 133.31,59.16 133.4,59.26 133.4,59.46 133.31,59.56 132.84,59.56 132.74,59.66 132.74,59.86 132.84,59.96 133.31,59.96 133.4,60.05 133.4,60.25 133.31,60.35 132.84,60.35 132.74,60.45 132.74,60.65 132.84,60.75 133.31,60.75 133.4,60.85 133.4,63.88 135.68,66.16 135.68,71.58 140.21,76.12 140.21,83.88 ; v1(141.87,95.86) 140.51,94.49 140.51,89.15
  BOTTOM w0.076: CPU1.BC5 141.55,96.19 v1(141.87,95.86)
  BOTTOM w0.107: JDIMM1.83 132.19,57.84 v1(132.17,57.81)
DDR_A_D28: length 49.6
  IN4 w0.097: v1(139.29,91.99) 139.29,90.9 138.65,90.25 138.65,76.63 134.31,72.3 134.31,66.57 131.39,63.66 131.39,58.92 130.96,58.49 130.96,57.47 129.68,56.18 129.68,55.92 v1(129.02,55.27)
  BOTTOM w0.076: CPU1.BD5 140.11,95.67 140.11,94.14 140.02,94.05 140.02,92.92 139.67,92.57 139.67,92.37 v1(139.29,91.99)
  BOTTOM w0.107: JDIMM1.66 127.94,54.19 v1(129.02,55.27)
DDR_A_D29: length 49.7
  IN4 w0.097: v1(138.85,91.54) 138.85,90.74 138.35,90.24 138.35,76.76 133.95,72.36 133.95,66.63 131.1,63.78 131.1,59.05 130.66,58.61 130.66,57.59 130.5,57.43 130.36,57.43 129.89,57.89 129.75,57.89 129.61,57.75 129.61,57.61 130.08,57.15 130.08,57.01 129.6,56.54 v1(129.02,56.54)
  BOTTOM w0.076: v1(138.85,91.54) 139.41,91.54 140.24,92.38 140.24,93.12 140.18,93.18 140.18,93.89 140.33,94.04 140.33,95.24 CPU1.BD4
  BOTTOM w0.107: JDIMM1.71 129.19,58.71 129.43,58.47 129.43,56.95 v1(129.02,56.54)
DDR_A_D30: length 49.3
  IN4 w0.089: 140.82,83.85 140.82,88.58 141.53,89.29
  IN4 w0.097: 140.82,83.85 140.82,75.82 136.29,71.3 136.29,65.79 134.69,64.19 134.69,62.67 134.59,62.57 134.11,62.57 134.01,62.47 134.01,62.27 134.11,62.18 134.59,62.18 134.69,62.08 134.69,61.88 134.59,61.78 134.11,61.78 134.01,61.68 134.01,61.11 134.69,60.43 134.69,56.29 133.67,55.27 v1(132.17,55.27) ; v1(141.87,93.25) 141.53,92.91 141.53,89.29
  BOTTOM w0.076: v1(141.87,93.25) 141.53,93.59 CPU1.BC1
  BOTTOM w0.107: v1(132.17,55.27) 131.72,54.82 131.72,53.64 131.44,53.37 JDIMM1.80
DDR_A_D31: length 49
  IN4 w0.089: 141.93,89.12 141.12,88.31 141.12,83.85
  IN4 w0.097: 141.93,89.12 142.45,89.64 142.45,93.32 v1(141.86,93.91) ; v1(132.17,54) 132.67,53.5 133.3,53.5 133.89,54.09 134.34,54.09 134.99,54.75 134.99,64.06 136.59,65.67 136.59,71.17 141.12,75.7 141.12,83.85
  BOTTOM w0.076: CPU1.BC2 141.53,94.24 v1(141.86,93.91)
  BOTTOM w0.107: v1(132.17,54) 132.44,53.72 JDIMM1.84
DDR_A_D32: length 49.4
  IN4 w0.097: v1(157.82,89.91) 157.5,89.59 157.5,88.03 160.77,84.77 160.77,67.27 157.05,63.56 157.05,58.36 156.74,58.05 156.74,55.52 156.92,55.34 157.68,55.34 157.78,55.24 157.78,55 157.68,54.9 156.91,54.9 156.79,54.77 156.79,54.57 156.89,54.48 157.68,54.48 157.78,54.38 157.78,54.14 157.68,54.04 v1(156.34,54.04)
  BOTTOM w0.076: CPU1.AB1 158.25,93.57 158.25,90.33 v1(157.82,89.91)
  BOTTOM w0.107: v1(156.34,54.04) 156.94,53.43 JDIMM1.174
DDR_A_D33: length 49.5
  IN4 w0.097: v1(157.31,90.72) 156.99,90.72 156.6,90.33 156.6,87.79 160.16,84.23 160.16,67.52 155.94,63.29 155.94,58.55 155.77,58.39 155.77,56.8 155.99,56.58 v1(156.34,56.58)
  BOTTOM w0.076: CPU1.AB2 157.95,93.96 157.95,93.47 158.03,93.39 158.03,90.93 157.81,90.72 v1(157.31,90.72)
  BOTTOM w0.107: v1(156.34,56.58) 154.98,56.58 154.84,56.72 154.84,57.09 154.95,57.2 155.54,57.2 155.65,57.31 155.65,57.65 155.54,57.76 154.95,57.76 154.84,57.87 154.84,58.22 154.95,58.33 155.52,58.33 155.69,58.5 JDIMM1.169
DDR_A_D34: length 48.5
  IN4 w0.097: v1(159.7,54.06) 158.6,55.16 158.6,57.88 158.99,58.27 158.99,60.64 158.38,61.25 158.38,63.18 161.97,66.77 161.97,85.75 158.63,89.1 158.63,89.88 158.18,90.32 158.18,93.98 v1(159.41,95.21)
  BOTTOM w0.076: v1(159.41,95.21) 159.08,95.54 CPU1.AA4
  BOTTOM w0.107: v1(159.7,54.06) 159.94,53.81 JDIMM1.186
DDR_A_D35: length 48.8
  IN4 w0.097: v1(159.7,55.33) 160.22,55.85 160.22,60.5 160.3,60.58 160.3,63.82 162.88,66.4 162.88,85.65 159.2,89.32 159.2,90.26 158.8,90.67 158.8,92.72 159.01,92.93 159.53,92.93 159.86,93.26 159.86,95.3 v1(159.4,95.77)
  BOTTOM w0.076: CPU1.AA5 158.98,96.19 v1(159.4,95.77)
  BOTTOM w0.107: v1(159.7,55.33) 158.94,54.58 JDIMM1.182
DDR_A_D36: length 49.4
  IN4 w0.097: v1(156.34,55.31) 155.47,56.18 155.47,58.51 155.63,58.68 155.63,63.41 159.86,67.64 159.86,84.15 156.22,87.79 156.22,91.35 v1(157.34,92.47)
  BOTTOM w0.076: CPU1.AB5 157.62,95.58 157.62,93.28 157.7,93.2 157.7,92.82 v1(157.34,92.47)
  BOTTOM w0.107: JDIMM1.170 155.94,53.68 155.66,53.96 155.66,54.63 v1(156.34,55.31)
DDR_A_D37: length 49.3
  IN4 w0.089: v1(157.34,91.86) 157.74,91.46 157.74,90.46 156.98,89.69 156.98,88.93
  IN4 w0.097: 156.98,88.93 156.98,87.8 160.46,84.32 160.46,67.39 156.75,63.68 156.75,62.96 156.65,62.86 156.34,62.86 156.24,62.76 156.24,62.56 156.34,62.46 156.65,62.46 156.75,62.36 156.75,60.9 156.65,60.8 156.34,60.8 156.24,60.7 156.24,60.5 156.34,60.4 156.65,60.4 156.75,60.3 156.75,60.1 156.65,60 156.34,60 156.24,59.91 156.24,59.71 156.34,59.61 156.65,59.61 156.75,59.51 156.75,59.31 156.65,59.21 156.34,59.21 156.24,59.11 156.24,58.92 156.34,58.82 156.65,58.82 156.75,58.72 156.75,58.49 156.65,58.39 156.43,58.39 156.34,58.29 v1(156.34,57.85)
  BOTTOM w0.076: v1(157.34,91.86) 157.58,91.62 157.76,91.62 157.86,91.72 157.86,93.29 157.78,93.36 157.78,94.25 157.94,94.4 157.94,95.24 CPU1.AB4
  BOTTOM w0.107: v1(156.34,57.85) 156.81,57.85 156.92,57.96 156.92,58.28 156.81,58.39 156.26,58.39 156.16,58.5 156.16,58.72 156.26,58.83 156.59,58.83 156.69,58.94 JDIMM1.173
DDR_A_D38: length 48.9
  IN4 w0.097: v1(159.7,56.6) 159.7,56.54 159.39,56.23 159.08,56.23 158.9,56.41 158.9,56.8 159,56.9 159.19,56.9 159.29,57 159.29,57.2 159.19,57.3 159,57.3 158.9,57.4 158.9,57.65 159,57.75 159.2,57.75 159.29,57.84 159.29,61.09 159.19,61.19 158.9,61.19 158.8,61.29 158.8,61.49 158.9,61.59 159.29,61.59 159.39,61.69 159.39,62.41 159.3,62.51 158.98,62.51 158.89,62.6 158.89,62.8 158.98,62.9 159.3,62.9 159.39,63 159.39,63.77 162.27,66.65 162.27,85.72 158.82,89.17 158.82,90.01 158.37,90.46 158.37,93.56 158.81,94 v1(159.41,94)
  BOTTOM w0.076: CPU1.AA2 159.18,94.24 v1(159.41,94)
  BOTTOM w0.107: JDIMM1.183 159.19,58.9 159.29,58.81 159.29,57.01 v1(159.7,56.6)
DDR_A_D39: length 49.1
  IN4 w0.097: v1(159.7,57.87) 159.92,58.09 159.92,58.32 159.82,58.42 159.69,58.42 159.59,58.52 159.59,58.71 159.69,58.81 159.82,58.81 159.92,58.91 159.92,59.11 159.82,59.21 159.69,59.21 159.59,59.31 159.59,59.51 159.69,59.61 159.82,59.61 159.92,59.71 159.92,59.9 159.82,60 159.69,60 159.59,60.1 159.59,60.3 159.69,60.4 159.82,60.4 159.92,60.5 159.92,60.72 159.84,60.8 159.69,60.8 159.59,60.9 159.59,61.15 159.69,61.25 159.9,61.25 160,61.35 160,61.59 159.9,61.7 159.79,61.7 159.7,61.8 159.7,62.06 159.79,62.16 159.9,62.16 160,62.26 160,62.46 159.9,62.56 159.79,62.56 159.7,62.66 159.7,63.64 162.57,66.52 162.57,85.68 159.01,89.25 159.01,90.14 158.56,90.59 158.56,93.48 158.77,93.69 159.11,93.69 v1(159.41,93.4)
  BOTTOM w0.076: CPU1.AA1 158.85,93.47 158.85,92.78 158.95,92.68 159.08,92.68 159.27,92.87 159.49,92.87 159.63,93 159.63,93.18 v1(159.41,93.4)
  BOTTOM w0.107: v1(159.7,57.87) 160.06,57.5 160.34,57.5 160.45,57.61 160.45,58.11 160.29,58.28 159.71,58.28 159.6,58.39 159.6,58.61 159.71,58.71 160.34,58.71 160.45,58.82 160.45,59.05 160.19,59.3 JDIMM1.187
DDR_A_D40: length 49.1
  IN4 w0.097: v1(159.41,91.94) 159.03,91.56 159.03,90.76 159.46,90.33 159.46,89.33 164.07,84.71 164.07,66.56 161.03,63.52 161.03,60.33 160.96,60.25 160.96,54.83 v1(161.66,54.12)
  BOTTOM w0.076: v1(159.41,91.94) 160.13,92.67 160.13,93.7 160.13,94.35 160.13,95 160.13,95.58 CPU1.V5
  BOTTOM w0.107: JDIMM1.190 160.94,53.4 v1(161.66,54.12)
DDR_A_D41: length 49.6
  IN4 w0.097: v1(160.31,90.49) 159.97,90.14 159.97,89.35 164.68,84.64 164.68,66.32 162.2,63.84 162.2,61.2 162.05,61.05 162.05,59.95 161.95,59.85 161.72,59.85 161.59,59.72 161.59,59.43 161.68,59.34 161.87,59.34 161.97,59.24 161.97,59 161.87,58.9 161.66,58.9 161.56,58.8 161.56,58.54 161.66,58.44 161.87,58.44 161.97,58.34 161.97,58.03 161.87,57.93 v1(161.66,57.93)
  BOTTOM w0.076: v1(160.31,90.49) 160.46,90.64 160.46,93.96 CPU1.V2
  BOTTOM w0.107: JDIMM1.195 162.19,58.51 162.38,58.33 163.73,58.33 163.84,58.22 163.84,57.9 163.73,57.79 162.81,57.79 162.7,57.68 162.7,56.47 162.59,56.36 162.23,56.36 162.12,56.47 162.12,57.75 161.95,57.93 v1(161.66,57.93)
DDR_A_D42: length 49.1
  IN4 w0.097: v1(165.34,57.87) 165.12,58.08 165.12,58.59 165.34,58.81 165.34,59.25 165.24,59.35 164.76,59.35 164.66,59.45 164.66,59.65 164.76,59.75 165.24,59.75 165.34,59.85 165.34,60.05 165.24,60.15 164.76,60.15 164.66,60.24 164.66,60.45 164.76,60.54 165.24,60.54 165.34,60.65 165.34,63.17 167.12,64.95 167.12,85 161.49,90.63 161.49,93.25 161.61,93.37 v1(161.91,93.37)
  BOTTOM w0.076: v1(161.91,93.37) 161.91,93.12 161.69,92.9 161.48,92.9 161.37,93.01 161.37,93.47 CPU1.U1
  BOTTOM w0.107: JDIMM1.207 165.19,59.12 165.02,58.94 164.62,58.94 164.5,58.83 164.5,58.67 164.61,58.56 165.08,58.56 165.17,58.47 165.17,58.29 165.07,58.18 164.66,58.18 164.51,58.02 164.51,57 164.61,56.89 164.81,56.89 164.93,57.02 164.93,57.51 165.05,57.62 165.21,57.62 165.34,57.75 v1(165.34,57.87)
DDR_A_D43: length 49.1
  IN4 w0.097: v1(165.34,56.6) 165.06,56.6 164.82,56.83 164.82,58.77 164.36,59.23 164.36,60.76 164.51,60.9 164.94,60.9 165.04,61.01 165.04,61.38 164.85,61.57 164.85,61.88 165.04,62.07 165.04,62.39 164.92,62.52 164.68,62.52 164.59,62.61 164.59,62.85 164.7,62.96 164.94,62.96 165.04,63.06 165.04,63.29 166.82,65.07 166.82,85.03 161.25,90.6 161.25,93.71 161.48,93.94 v1(161.93,93.94)
  BOTTOM w0.076: v1(161.93,93.94) 161.63,94.24 CPU1.U2
  BOTTOM w0.107: v1(165.34,56.6) 164.9,56.6 164.79,56.49 164.79,56.1 164.61,55.92 164.34,55.92 164.19,56.06 JDIMM1.203
DDR_A_D44: length 49.8
  IN4 w0.097: v1(160.76,90.04) 160.37,90.04 160.22,89.88 160.22,89.37 164.98,84.61 164.98,66.2 162.5,63.71 162.5,59.71 162.27,59.48 162.27,56.84 162.09,56.66 v1(161.66,56.66)
  BOTTOM w0.076: v1(160.76,90.04) 161.64,90.04 161.74,90.14 161.74,90.49 161.67,90.57 160.87,90.57 160.79,90.65 160.79,90.93 160.87,91 161.73,91 161.81,91.08 161.81,91.33 161.73,91.41 160.92,91.41 160.74,91.58 CPU1.V1
  BOTTOM w0.107: JDIMM1.191 161.19,57.3 160.6,56.71 160.6,56.42 160.85,56.17 161.17,56.17 v1(161.66,56.66)
DDR_A_D45: length 49.4
  IN4 w0.097: v1(159.41,91.39) 159.41,90.77 159.77,90.4 159.77,89.28 164.38,84.68 164.38,66.44 161.39,63.45 161.39,62.87 161.49,62.77 161.8,62.77 161.9,62.67 161.9,62.45 161.8,62.35 161.53,62.35 161.34,62.16 161.34,60.89 161.44,60.79 161.64,60.79 161.74,60.69 161.74,60.39 161.64,60.29 161.43,60.29 161.26,60.13 161.26,55.8 v1(161.66,55.39)
  BOTTOM w0.076: CPU1.V4 160.74,95.39 160.3,94.94 160.3,94.05 160.3,92.27 v1(159.41,91.39)
  BOTTOM w0.107: v1(161.66,55.39) 162.14,54.92 162.14,53.64 161.94,53.45 JDIMM1.194
DDR_A_D46: length 49.2
  IN4 w0.097: v1(161.93,95.86) 160.72,94.65 160.72,90.6 166.19,85.13 166.19,65.3 163.71,62.83 163.71,59.02 164.22,58.51 164.22,55.18 v1(165.34,54.06)
  BOTTOM w0.076: v1(161.93,95.86) 161.6,96.19 CPU1.U5
  BOTTOM w0.107: v1(165.34,54.06) 165.44,53.95 JDIMM1.208
DDR_A_D47: length 48.9
  IN4 w0.097: v1(161.93,95.21) 161,94.28 161,90.59 166.52,85.07 166.52,65.21 164.06,62.75 164.06,59.1 164.52,58.65 164.52,55.6 164.79,55.33 v1(165.34,55.33)
  BOTTOM w0.076: v1(161.93,95.21) 161.6,95.54 CPU1.U4
  BOTTOM w0.107: JDIMM1.204 164.44,54.43 v1(165.34,55.33)
DDR_A_D48: length 50.4
  IN4 w0.097: v1(163.72,90.83) 163.33,90.44 163.33,90.14 168.76,84.71 168.76,64.69 166.68,62.62 166.68,56.5 166.82,56.36 167.02,56.36 v1(167.27,56.61)
  BOTTOM w0.076: v1(163.72,90.83) 163.96,91.07 163.96,91.61 163.68,91.88 163.58,91.88 163.4,91.7 163.29,91.7 163.18,91.81 163.18,91.92 163.36,92.1 163.36,92.2 162.98,92.59 162.98,93.96 CPU1.R2
  BOTTOM w0.107: JDIMM1.211 166.19,59.09 166.09,58.98 166.09,58.75 166.19,58.64 166.75,58.64 166.86,58.53 166.86,58.2 166.75,58.09 166.19,58.09 166.09,57.98 166.09,57.45 165.93,57.3 165.93,55.96 166.04,55.85 166.65,55.85 166.76,55.96 166.76,56.44 166.93,56.61 v1(167.27,56.61)
DDR_A_D49: length 49.6
  IN4 w0.097: v1(164.44,95.86) 163.52,94.94 163.52,92.37 167.47,88.42 167.55,88.42 170.26,85.71 170.26,63.54 168.56,61.84 168.56,58.79 169.43,57.92 169.43,55.43 v1(170.8,54.06)
  BOTTOM w0.076: v1(164.44,95.86) 164.11,96.19 CPU1.P5
  BOTTOM w0.107: v1(170.8,54.06) 170.44,53.7 JDIMM1.228
DDR_A_D50: length 50
  IN4 w0.097: v1(162.82,91.73) 162.82,90.12 168.28,84.65 168.28,64.65 166.38,62.74 166.38,54.52 166.47,54.43 166.72,54.43 166.84,54.54 166.84,55.23 167,55.39 v1(167.27,55.39)
  BOTTOM w0.076: v1(162.82,91.73) 162.81,91.73 162.81,94.23 162.96,94.38 162.96,95.24 CPU1.R4
  BOTTOM w0.107: JDIMM1.212 166.44,54.65 167.18,55.39 v1(167.27,55.39)
DDR_A_D51: length 49.2
  IN4 w0.097: v1(164.44,95.21) 163.78,94.55 163.78,92.54 167.58,88.74 167.66,88.74 170.56,85.84 170.56,63.41 168.86,61.71 168.86,58.92 169.73,58.04 169.73,56.4 v1(170.8,55.33)
  BOTTOM w0.076: v1(164.44,95.21) 164.11,95.54 CPU1.P4
  BOTTOM w0.107: JDIMM1.224 169.44,53.97 v1(170.8,55.33)
DDR_A_D52: length 49.4
  IN4 w0.097: v1(167.2,54.12) 166.9,53.82 166.38,53.82 166.07,54.12 166.07,62.87 167.98,64.78 167.98,84.4 162.37,90.02 v1(162.37,92.18)
  BOTTOM w0.076: v1(162.37,92.18) 162.37,92.64 162.65,92.92 162.65,95.58 CPU1.R5
  BOTTOM w0.107: v1(167.2,54.12) 167.2,54.1 167.44,53.86 JDIMM1.216
DDR_A_D53: length 49.5
  IN4 w0.097: v1(164.44,93.91) 164.04,93.51 164.04,92.71 167.62,89.12 167.71,89.12 171.37,85.46 171.37,73.61 170.86,73.1 170.86,63.29 169.16,61.59 169.16,59.04 170.03,58.17 170.03,56.96 170.39,56.6 v1(170.8,56.6)
  BOTTOM w0.076: v1(164.44,93.91) 164.11,94.24 CPU1.P2
  BOTTOM w0.107: JDIMM1.225 169.69,58.68 169.59,58.57 169.16,58.57 169.05,58.46 169.05,58.18 169.16,58.07 169.44,58.07 169.55,57.96 169.55,57.66 169.66,57.56 170.08,57.56 170.19,57.45 170.19,57.23 170.08,57.12 169.66,57.12 169.55,57.01 169.55,56.74 169.69,56.6 v1(170.8,56.6)
DDR_A_D54: length 50.2
  IN4 w0.097: v1(167.27,57.94) 167.29,57.96 167.29,58.56 167.19,58.66 167.08,58.66 166.98,58.76 166.98,58.95 167.08,59.05 167.19,59.05 167.29,59.15 167.29,59.35 167.19,59.45 167.08,59.45 166.98,59.55 166.98,59.75 167.08,59.85 167.19,59.85 167.29,59.95 167.29,60.14 167.19,60.24 167.08,60.24 166.98,60.34 166.98,60.54 167.08,60.64 167.19,60.64 167.29,60.74 167.29,60.96 166.98,61.27 166.98,62.49 169.06,64.57 169.06,84.86 163.88,90.04 163.88,90.18 v1(164.12,90.42)
  BOTTOM w0.076: CPU1.R1 163.26,93.13 163.62,92.77 163.62,92.66 163.51,92.54 163.51,92.44 163.62,92.33 163.73,92.33 163.84,92.44 163.95,92.44 164.07,92.32 164.07,92.21 163.95,92.1 163.95,91.99 164.06,91.88 164.17,91.88 164.28,92 164.39,92 164.54,91.85 164.54,91.75 164.23,91.44 164.23,91.33 164.34,91.23 164.45,91.23 164.75,91.53 164.86,91.53 164.97,91.42 164.97,91.32 164.66,91.01 164.66,90.9 164.77,90.79 164.88,90.79 165.18,91.1 165.29,91.1 165.4,90.99 165.4,90.88 165.09,90.58 165.09,90.47 165.2,90.36 165.31,90.36 165.61,90.67 165.72,90.67 165.87,90.52 165.87,90.39 165.36,89.88 165.2,89.88 164.44,90.64 164.34,90.64 v1(164.12,90.42)
  BOTTOM w0.107: v1(167.27,57.94) 167.27,58.22 167.38,58.33 167.67,58.33 167.78,58.43 167.78,58.66 167.67,58.77 167.36,58.77 167.19,58.94 JDIMM1.215
DDR_A_D55: length 48.9
  IN4 w0.097: v1(164.44,93.27) 164.44,92.73 167.73,89.44 167.82,89.44 171.67,85.59 171.67,73.02 171.57,72.93 171.26,72.93 171.16,72.83 171.16,72.64 171.26,72.54 171.57,72.54 171.67,72.44 171.67,72.25 171.57,72.15 171.26,72.15 171.16,72.06 171.16,71.86 171.26,71.77 171.57,71.77 171.67,71.67 171.67,71.48 171.57,71.38 171.26,71.38 171.16,71.28 171.16,71.09 171.26,71 171.57,71 171.67,70.9 171.67,70.71 171.57,70.61 171.26,70.61 171.16,70.51 171.16,70.24 171.26,70.15 171.55,70.15 171.65,70.05 171.65,69.86 171.55,69.76 171.26,69.76 171.16,69.67 171.16,69.47 171.26,69.38 171.55,69.38 171.65,69.28 171.65,69.09 171.55,68.99 171.26,68.99 171.16,68.89 171.16,68.67 171.26,68.57 171.49,68.57 171.59,68.48 171.59,68.28 171.49,68.19 171.26,68.19 171.16,68.09 171.16,63.17 169.46,61.46 169.46,60.91 169.56,60.82 169.88,60.82 169.97,60.72 169.97,60.53 169.88,60.43 169.57,60.43 169.46,60.31 169.46,60.14 169.56,60.04 169.88,60.04 169.97,59.95 169.97,59.75 169.88,59.66 169.57,59.66 169.46,59.54 169.46,59.21 v1(170.8,57.87)
  BOTTOM w0.076: CPU1.P1 164.12,93.59 v1(164.44,93.27)
  BOTTOM w0.107: JDIMM1.229 170.69,57.97 v1(170.8,57.87)
DDR_A_D56: length 50
  IN4 w0.097: v1(165.78,91.91) 167.36,91.91 168.56,90.71 169.4,90.71 173.19,86.92 173.19,62.99 171.92,61.72 171.92,60.86 171.82,60.76 171.62,60.76 171.52,60.66 171.52,60.47 171.62,60.37 171.82,60.37 171.92,60.28 171.92,60.08 171.82,59.99 171.62,59.99 171.52,59.89 171.52,59.7 171.62,59.6 171.82,59.6 171.92,59.5 171.92,57.83 v1(173.15,56.6)
  BOTTOM w0.076: v1(165.78,91.91) 165.78,92.52 165.53,92.78 165.53,93.03 165.33,93.23 165.33,95.09 CPU1.M4
  BOTTOM w0.107: v1(173.15,56.6) 171.69,58.05 JDIMM1.233
DDR_A_D57: length 49.5
  IN4 w0.097: v1(167.13,90.56) 167.69,90.56 168.36,89.88 169.37,89.88 172.58,86.67 172.58,67.5 172.49,67.41 172.32,67.41 172.22,67.31 172.22,67.12 172.32,67.02 172.49,67.02 172.58,66.93 172.58,66.73 172.49,66.64 172.32,66.64 172.22,66.54 172.22,66.35 172.32,66.25 172.49,66.25 172.58,66.15 172.58,65.93 172.49,65.83 172.32,65.83 172.22,65.74 172.22,65.54 172.32,65.45 172.49,65.45 172.58,65.35 172.58,63.43 170.7,61.55 170.7,59.48 171.31,58.87 171.31,55.17 172.42,54.06 v1(173.15,54.06)
  BOTTOM w0.076: CPU1.M1 165.9,93.46 165.9,93.03 166.47,92.46 166.47,92.19 167.13,91.53 v1(167.13,90.56)
  BOTTOM w0.107: JDIMM1.236 172.44,53.35 v1(173.15,54.06)
DDR_A_D58: length 49.3
  IN4 w0.097: v1(166.95,95.35) 168.12,95.35 169.28,94.19 169.44,94.19 176.1,87.54 176.1,68.66 175.29,67.86 175.29,57.54 176.23,56.6 v1(176.71,56.6)
  BOTTOM w0.076: CPU1.L4 166.67,95.54 166.86,95.35 v1(166.95,95.35)
  BOTTOM w0.107: JDIMM1.245 174.69,58.61 v1(176.71,56.6)
DDR_A_D59: length 49.5
  IN4 w0.097: v1(166.95,93.91) 169.3,93.91 175.8,87.41 175.8,68.79 174.99,67.98 174.99,57.03 176.69,55.33 v1(176.71,55.33)
  BOTTOM w0.076: CPU1.L2 166.62,94.24 v1(166.95,93.91)
  BOTTOM w0.107: v1(176.71,55.33) 174.94,53.56 JDIMM1.246
DDR_A_D60: length 49.8
  IN4 w0.097: v1(165.33,92.36) 167.34,92.36 168.6,91.09 169.43,91.09 173.49,87.04 173.49,62.45 172.74,61.7 172.32,61.7 172.22,61.6 172.22,61.08 172.32,60.98 172.84,60.98 172.94,60.88 172.94,60.69 172.84,60.59 172.32,60.59 172.22,60.49 172.22,60.29 172.32,60.19 172.84,60.19 172.94,60.09 172.94,59.89 172.84,59.79 172.32,59.79 172.22,59.69 172.22,59.44 172.32,59.34 172.6,59.34 172.77,59.18 172.77,58.25 v1(173.15,57.87)
  BOTTOM w0.076: v1(165.33,92.36) 165.33,92.92 165.16,93.09 165.16,95.58 CPU1.M5
  BOTTOM w0.107: v1(173.15,57.87) 172.76,58.26 172.76,59.08 172.69,59.14 JDIMM1.237
DDR_A_D61: length 49.8
  IN4 w0.097: v1(166.68,91.01) 167.83,91.01 168.45,90.39 169.29,90.39 172.89,86.8 172.89,63.3 171,61.42 171,59.61 171.61,58.99 171.61,55.76 172.04,55.33 v1(173.15,55.33)
  BOTTOM w0.076: v1(166.68,91.01) 166.68,91.6 166.18,92.1 166.18,92.44 165.7,92.93 165.7,93.1 165.49,93.3 165.49,93.96 CPU1.M2
  BOTTOM w0.107: JDIMM1.232 171.44,53.62 v1(173.15,55.33)
DDR_A_D62: length 49.1
  IN4 w0.097: v1(166.96,95.9) 168.85,95.9 176.52,88.23 176.52,68.67 175.59,67.74 175.59,67.33 175.69,67.23 176.12,67.23 176.22,67.13 176.22,66.94 176.12,66.84 175.69,66.84 175.59,66.75 175.59,66.52 175.69,66.43 176.12,66.43 176.22,66.33 176.22,66.14 176.12,66.04 175.69,66.04 175.59,65.95 175.59,58.98 v1(176.71,57.87)
  BOTTOM w0.076: v1(166.96,95.9) 166.67,96.19 CPU1.L5
  BOTTOM w0.107: JDIMM1.249 175.69,58.88 v1(176.71,57.87)
DDR_A_D63: length 49.4
  IN4 w0.097: v1(166.98,93.35) 167.03,93.3 169.48,93.3 174.69,88.09 174.69,71.15 174.79,71.06 175.17,71.06 175.27,70.96 175.27,70.77 175.17,70.67 174.79,70.67 174.69,70.57 174.69,56.9 175.35,56.24 175.35,54.5 175.79,54.06 v1(176.71,54.06)
  BOTTOM w0.076: CPU1.L1 166.67,93.59 166.91,93.35 v1(166.98,93.35)
  BOTTOM w0.107: v1(176.71,54.06) 175.94,53.29 JDIMM1.250
DDR_A_DQS0: length 57.3
  IN4 w0.089: 129.55,94.02 129.6,94.06 129.6,94.07 129.74,94.21 129.74,94.22 129.78,94.26 129.78,94.27 130.17,94.66 130.17,94.8 130.48,95.1 130.7,95.1 130.81,95 v1(130.81,94.74)
  IN4 w0.099: 129.55,94.02 127.65,92.11 127.65,86.39 126.11,84.85 126.11,81.74 121.42,77.06 121.42,72.07 116.41,67.06 116.41,65.74 115.85,65.18 115.22,65.18 114.82,64.78 114.82,60.5 114.61,60.29 114.26,60.29 114.14,60.16 114.14,59.88 114.23,59.79 114.62,59.79 114.84,59.57 114.84,59.11 114.62,58.89 114.24,58.89 114.14,58.79 114.14,58.49 114.25,58.38 114.6,58.38 114.84,58.14 114.84,56.65 114.6,56.41 114.27,56.41 v1(114.07,56.22)
  BOTTOM w0.076: CPU1.BP5 133.47,95.96 133.2,96.23 132.77,96.23 132.63,96.09 131.69,96.09 131.46,95.86 131.26,95.86 130.79,95.39 130.79,94.76 v1(130.81,94.74)
  BOTTOM w0.107: JDIMM1.13 114.69,58.97 114.56,58.83 114.56,58.45 114.86,58.15 114.86,56.72 114.52,56.37 114.23,56.37 v1(114.07,56.22)
DDR_A_DQS1: length 54.5
  IN4 w0.089: 131.2,83.85 131.2,83.86 131.19,83.87 131.19,90.2 131.97,90.98 132.17,90.98 132.27,90.87 v1(132.27,90.53)
  IN4 w0.099: 131.2,83.85 131.2,80.53 126.9,76.23 126.9,72.17 120.72,66 120.72,60.72 119.45,59.45 119.45,57.96 119.9,57.51 119.9,55.43 119.69,55.21 119.45,55.21 v1(119.19,54.95)
  BOTTOM w0.076: v1(132.27,90.53) 133.67,90.53 136.44,93.31 136.44,93.76 136.06,94.14 136.06,94.56 CPU1.BK3
  BOTTOM w0.107: JDIMM1.34 119.94,52.75 119.83,52.86 119.83,53.25 119.28,53.8 118.91,53.8 118.54,54.17 118.54,54.98 118.72,55.17 118.97,55.17 v1(119.19,54.95)
