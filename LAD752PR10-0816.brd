# Allegro board LAD752PR10-0816.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
USB3TP4: length 163.6
  TOP w0.099: JIO.30 323.8,24.36 323.49,24.05 323.49,23.45 v1(323.4,23.36)
  IN4 w0.097: v1(194.22,33.15) 194.06,33.31 194.06,33.63 193.87,33.82 193.87,34.12 194.77,35.02 196.41,35.02 197.3,35.91 197.3,37.24 198.26,38.2 198.26,39.48 200.8,42.02 204.81,42.02 205.37,42.58 207.07,42.58 207.76,43.27 210.84,43.27 211.27,42.83 214.08,42.83 214.28,42.63 218.5,42.63 219.33,41.8 223.92,41.8 224.66,42.54 226.37,42.54 227.78,41.13 227.78,40.58 231.42,36.94 231.42,36.58 233.82,34.18 233.82,33.57 234.78,32.61 235.28,32.61 235.72,32.16 235.72,29.65 246,19.37 257.38,19.37 267.21,29.2 274.46,29.2 275.97,30.7 288.3,30.7 290.03,32.43 315.09,32.43 322.9,24.62 323.34,24.62 323.81,24.15 323.81,23.77 v1(323.4,23.36)
  BOTTOM w0.099: UH1.B13 195.14,33.54 195,33.54 194.9,33.44 194.57,33.44 194.38,33.62 194.16,33.62 194.06,33.52 194.06,33.3 v1(194.22,33.15)
USB3TP5: length 219.3
  TOP w0.099: CU39.2 15.98,57.91 16.3,57.91 16.97,57.23 16.97,56.67 v1(16.84,56.54)
  IN3 w0.099: v1(16.84,56.54) 17.07,56.36 17.07,56.32 17.07,54.98 17.41,54.64 18.81,54.64 19.97,53.48 24.28,53.48 26.77,51 34.95,51 36.01,49.94 45.9,49.94 46.5,49.33 55.28,49.33 55.66,49.71 57.66,49.71 58,50.04 65.62,50.04 67.66,48.01 72.45,48.01 77.04,43.42 77.04,31.99 76.53,31.47 76.53,28.71 77.03,28.21 81.33,28.21 87.41,22.14 96.64,22.14 97.68,21.09 101.67,21.09 102.12,20.64 107.97,20.64 109.34,19.27 145.3,19.27 146.29,20.26 168.9,20.26 171.71,23.07 180.19,23.07 181.85,24.73 182.73,24.73 183.71,25.72 183.71,26.42 189.18,31.88 189.18,35.31 189.27,35.41 189.96,35.41 v1(190.17,35.2)
  BOTTOM w0.089: 193.64,32.47 193.65,32.46 193.66,32.46 193.7,32.42 193.78,32.42 193.86,32.42 194.7,32.42 195.08,32.8 195.44,32.8 195.69,33.05 UH1.C14
  BOTTOM w0.099: v1(190.17,35.2) 190.37,35.4 190.92,35.4 191.01,35.3 191.01,33.8 192.01,32.8 193.31,32.8 193.51,32.6 193.64,32.47
USB20_CAM_N7_R: length 23.5
  TOP w0.099: JEDP.19 160.62,179.58 160.79,179.41 160.79,178.45 161.34,177.9 161.34,174.75 162.88,173.2 162.88,169.33 163.48,168.73 163.48,168.68 163.9,168.26 v3(165.39,168.26) 166.36,168.26 166.48,168.14 166.48,167.43 DV4.3 166.32,166.62 166.49,166.44 166.49,165.83 166.9,165.42 167.2,165.42 167.98,164.65 167.98,164 167.83,163.85 167.83,163.46 167.53,163.15 LV2.2
USB20_CAM_P7_R: length 23.5
  TOP w0.099: JEDP.20 161.12,179.58 160.98,179.44 160.98,178.53 161.53,177.98 161.53,174.83 163.08,173.28 163.08,169.41 v3(163.85,168.64) 164.01,168.47 165.09,168.47 165.11,168.49 165.66,168.49 165.68,168.47 166.42,168.47 166.67,168.22 166.67,167.54 DV4.2 166.86,166.62 166.68,166.45 166.68,165.91 166.98,165.61 167.28,165.61 168.17,164.73 168.17,163.92 168.03,163.77 LV2.3
USB20_N1: length 221.9
  TOP w0.099: UU1.2 22.08,42.54 22.23,42.39 22.23,41.16 22.79,40.61 25.88,40.61 25.98,40.51 25.98,40.34 25.74,40.1 25.74,40.11 v1(25.74,40.11)
  IN4 w0.097: v1(207.89,37.52) 207.8,37.42 207.42,37.42 207.23,37.22 207.23,36.81 205.18,34.76 205.18,34.36 204.8,33.97 203.76,33.97 203.46,33.68 203.46,33.04 201.99,31.57 200.41,31.57 199.72,30.88 199.72,29.99 198.91,29.18 193.99,29.18 191.87,31.3 184.4,31.3 182.77,29.66 182.11,29.66 181.46,29.01 180.5,29.01 179.14,27.65 179.14,26.26 176.68,23.79 137.92,23.79 137.19,23.06 123.98,23.06 121.79,25.26 106.1,25.26 104.81,26.55 104.81,30.11 103.34,31.58 103.34,34.61 101.81,36.15 101.81,43.97 99.04,46.73 95.19,46.73 94.65,47.28 91,47.28 90.47,46.74 58.44,46.74 57.29,47.89 46.98,47.89 45.82,46.73 35.54,46.73 32.51,43.7 28.96,43.7 25.84,40.59 25.84,40.21 v1(25.74,40.11)
  BOTTOM w0.089: UH1.AF5 207.32,37.52 v1(207.89,37.52)
USB20_N1_CONN: length 13
  BOTTOM w0.099: JUSB1.2 16.55,38.12 16.68,38 17.95,38 18.12,38.16 18.12,38.21 18.52,38.62 18.57,38.62 19.11,39.15 v3(19.43,39.15) 19.75,39.15 21.85,37.05 21.99,37.05 22.13,37.19 22.13,37.64 DU1.2 22.45,37.15 22.62,36.98 22.99,36.98 23.44,37.43 23.44,38.9 23.25,39.08 LU3.2
USB20_N2: length 149
  TOP w0.099: JIO.23 325.05,20.85 324.83,21.07 324.22,21.07 323.58,20.44 323.58,20.23 323.96,19.85 v1(323.97,19.85)
  IN4 w0.097: v1(323.97,19.85) 323.81,20.02 323.81,20.46 323.43,20.84 321.83,20.84 316.84,25.84 316.18,25.84 314.13,27.89 290.76,27.89 289.19,26.31 268.54,26.31 265.52,23.29 265.52,22.34 263.74,20.56 262.99,20.56 258.37,15.94 246.83,15.94 246.31,16.46 245.39,16.46 243.83,18.02 242.47,18.02 240.43,20.06 234.12,20.06 231.32,22.87 229.65,22.87 228.16,24.36 228.16,33.38 226.73,34.8 224.02,34.8 222.96,33.74 221.15,33.74 217.98,36.91 217.31,36.91 216.46,37.76 216.46,38.27 215.78,38.95 212.55,38.95 211.61,38.01 210.01,38.01 209.86,37.86 208.88,37.86 208.42,38.32 207.54,38.32 206.47,37.25 206.47,37.1 206,36.63 v1(205.7,36.63)
  BOTTOM w0.089: v1(205.7,36.63) 205.7,36.66 206.24,37.2 UH1.AD5
USB20_N3: length 181.7
  IN1 w0.097: v1(207.85,35.19) 207.85,35.17 207.59,34.9 207.5,34.9 207.4,35 207.4,37.04 205.96,38.48 205.27,38.48 204.75,39 203.74,39 202.44,40.3 202.44,40.59 201.69,41.34 198.85,41.34 197.1,43.1 197.1,47.85 193.66,51.29 193.66,57.42 197.12,60.88 197.12,66.34 200.93,70.15 200.93,73.9 201.81,74.78 201.81,86.59 203.83,88.61 203.83,99.02 202.59,100.26 202.59,101.84 196.74,107.7 196.74,108.36 194.12,110.98 194.12,122.03 193.57,122.58 193.57,132.5 193.19,132.88 193.19,147.65 191.35,149.48 191.35,150.61 190.87,151.09 190.87,152.82 187.91,155.78 179.4,155.78 179.02,156.16 176.61,156.16 175.72,157.05 172.37,157.05 171.98,157.43 170.65,157.43 170.59,157.49 169.56,157.49 168.77,158.28 168.77,158.67 166.6,160.84 165.83,160.84 164.61,162.07 164.61,165.77 166.36,167.53 166.36,169.94 166.9,170.48 166.9,171.8 166.99,171.89 167.32,171.89 167.44,171.76 167.44,171.63 v1(167.33,171.51)
  BOTTOM w0.089: UH1.AG8 207.34,35.7 v1(207.85,35.19)
  BOTTOM w0.099: LM1.1 168.47,173 168.3,172.83 168.3,172.78 168.29,172.77 168.29,172.64 167.95,172.3 167.95,171.92 167.74,171.71 167.53,171.71 v1(167.33,171.51)
USB20_N3_CONN: length 3.6
  BOTTOM w0.099: LM1.2 168.47,174.91 168.35,175.04 168.35,175.32 v3(168.1,175.57) 167.9,175.77 167.9,176.05 168.14,176.29 168.14,176.58 168.22,176.66 JCDRA.40
USB20_N4: length 157.7
  TOP w0.099: UE1.5 317,10.23 316.69,10.53 316.69,13.63 322.15,19.08 v3(322.15,20.35) 322.15,21.14 322.28,21.28 v1(322.28,21.68)
  IN4 w0.097: v1(206.14,40.93) 206.29,40.78 206.43,40.78 206.68,41.04 207.12,41.04 208.22,42.14 210,42.14 210.26,41.88 210.26,41.62 210.97,40.91 214.37,40.91 214.45,40.99 215.82,40.99 216.21,41.38 217.01,41.38 217.71,40.68 224.41,40.68 224.94,41.21 226.06,41.21 226.65,40.62 226.65,39.38 231.41,34.62 231.41,29.24 234.39,26.26 235.09,26.26 236.1,25.24 237.1,25.24 243.01,19.33 244.37,19.33 245.92,17.77 246.32,17.77 246.39,17.77 257.38,17.77 267.22,27.61 275.37,27.61 276.62,28.86 288.16,28.86 289.86,30.56 313.58,30.56 322.08,22.07 322.08,21.88 v1(322.28,21.68)
  BOTTOM w0.089: v1(206.14,40.93) 206.5,40.57 206.5,39.82 206.38,39.7 206.38,39.44 206.47,39.35 206.55,39.35 UH1.AE1
USB20_N5: length 123
  IN4 w0.097: v1(301.37,29.31) 301.19,29.48 301.19,29.71 300.99,29.91 292.65,29.91 291.47,28.73 290.01,28.73 289.1,27.82 276.66,27.82 275.79,26.96 267.61,26.96 259.39,18.73 259.39,17.97 258.19,16.78 255.49,16.78 255.15,17.11 245.66,17.11 244.1,18.67 242.74,18.67 240.7,20.72 234.68,20.72 229.59,25.8 229.59,33.87 226.56,36.9 225.1,36.9 224.37,37.62 224.37,37.92 223.37,38.92 220.14,38.92 219.67,38.45 218.77,38.45 217.77,39.45 211.7,39.45 211.2,38.94 207.65,38.94 206.46,37.76 206.04,37.76 206.04,37.76 v1(205.72,37.76)
  BOTTOM w0.089: v1(205.72,37.76) 205.71,37.76 205.58,37.89 205.58,38.02 205.71,38.14 205.71,38.45 205.47,38.68 UH1.AC2
  BOTTOM w0.099: JWLAN.5 301.32,32.65 301.17,32.5 301.17,29.5 v1(301.37,29.31)
USB20_N6: length 188.7
  TOP w0.099: v1(165.14,164.81) 164.88,165.07 163.39,165.07 162.65,165.81 162.65,166.07 162.57,166.15 162.19,166.15 161.73,166.61 DV2.3 162.38,166.62 162.48,166.72 162.48,167.83 162.12,168.18 v3(162.12,168.47) 162.12,170.46 160.64,171.94 160.64,177.6 159.78,178.46 159.78,179.69 159.62,179.84 JEDP.17
  IN1 w0.097: v1(165.14,164.81) 165.32,164.98 165.59,164.98 165.7,164.87 165.7,163.24 169.46,159.48 171.46,159.48 171.67,159.69 175.7,159.69 178.14,157.26 188.02,157.26 190.25,155.03 190.25,154.47 191.35,153.37 191.35,151.29 191.83,150.81 191.83,149.68 194.05,147.46 194.05,122.77 194.59,122.23 194.59,111.18 197.42,108.35 197.42,107.69 203.17,101.94 203.17,100.37 204.98,98.57 204.98,82.51 203.34,80.88 203.34,73.95 201.41,72.01 201.41,69.95 199,67.54 199,61.92 194.14,57.07 194.14,51.58 197.58,48.15 197.58,43.3 199.04,41.83 201.73,41.83 203.81,39.75 204.84,39.75 205.3,39.29 205.74,39.29 205.93,39.1 207.16,39.1 207.53,39.47 207.53,39.91 207.2,40.24 207.04,40.24 v1(206.87,40.41)
  BOTTOM w0.089: v1(206.87,40.41) 207.23,40.05 207.23,39.72 207.23,39.71 207.23,39.71 207.23,39.3 207.23,39.29 207.23,39.29 207.23,39 UH1.AF2
USB20_N7: length 162.6
  TOP w0.099: LV2.1 167.53,161 167.57,160.95 167.57,160.66 167.78,160.45 168.25,160.45 168.6,160.8 168.6,160.96 168.7,161.06 v1(169.11,161.06)
  IN1 w0.097: v1(169.11,161.06) 169.31,161.26 169.49,161.26 169.59,161.16 169.59,160.54 169.78,160.34 171.55,160.34 171.56,160.34 176.07,160.34 178.37,158.04 187.28,158.04 187.54,158.3 188.21,158.3 190.49,156.01 190.87,156.01 192,154.89 192,151.56 192.48,151.08 192.48,149.95 194.7,147.73 194.7,123.04 195.25,122.5 195.25,111.45 198.24,108.46 198.24,107.81 203.82,102.23 203.82,100.64 205.63,98.84 205.63,82.24 204,80.61 204,73.64 202.06,71.7 202.06,69.68 199.65,67.27 199.65,61.62 194.83,56.8 194.83,51.86 198.23,48.46 198.23,43.94 199.59,42.58 201.75,42.58 202.97,41.36 204.18,41.36 204.52,41.01 204.78,41.01 205.17,40.63 205.36,40.63 v1(205.57,40.42)
  BOTTOM w0.089: UH1.AB3 204.96,38.6 205.21,38.85 205.21,39.24 205.19,39.27 205.19,40.36 205.33,40.49 205.49,40.49 v1(205.57,40.42)
USB20_N8: length 245.8
  IN4 w0.097: v1(209.26,36.36) 209.11,36.51 208.7,36.51 208.35,36.16 207.72,36.16 207.46,35.91 207.46,34.08 207.03,33.64 206.07,33.64 205.88,33.45 205.88,32.35 203.78,30.26 201.05,30.26 198.85,28.06 193.67,28.06 191.25,30.48 186.09,30.48 183.8,28.19 180.85,28.19 180.09,27.44 180.09,25.7 177.37,22.97 138.26,22.97 137.36,22.07 123.82,22.07 121.45,24.43 105.72,24.43 103.96,26.19 103.96,29.5 102.52,30.95 102.52,34.25 100.83,35.94 100.83,42.52 97.6,45.75 84.41,45.75 84.31,45.85 58.16,45.85 56.98,47.03 53.24,47.03 52.76,46.55 46.81,46.55 46.17,45.9 37.44,45.9 32.33,40.8 28.82,40.8 24.37,36.35 23.19,36.35 22.66,36.88 22.66,42.72 20.01,45.37 20.01,47.16 16.66,50.51 16.66,55.83 16.46,56.04 16.34,56.04 v1(16.13,55.83)
  BOTTOM w0.089: UH1.AL8 209.64,35.98 v1(209.26,36.36)
  BOTTOM w0.099: v1(16.13,55.83) 16.06,55.9 15.54,55.9 15.33,56.11 15.33,56.72 15.66,57.05 LU9.4
USB20_N8_CONN: length 18.9
  TOP w0.099: v1(6.71,60.62) 6.66,60.68 JUSBC2.B7 ; JUSBC2.A7 8.06,59.92 8.29,60.16 8.6,60.16 v1(8.87,59.9)
  IN1 w0.097: v1(8.87,59.9) 8.99,59.9 9.64,59.9 9.83,60.1 9.83,61.19 8.76,62.26 7.95,62.26 7.51,61.83 7.51,61.31 6.83,60.62 v1(6.71,60.62)
  BOTTOM w0.099: v1(8.87,59.9) 10.81,59.9 11.52,60.61 12.37,60.61 13.38,59.6 13.84,59.6 13.94,59.5 DU11.3 14.96,58.76 15.17,58.97 15.17,59.73 15.35,59.91 15.66,59.91 15.76,59.81 15.76,59.66 15.66,59.56 LU9.3
USB20_N9: length 171.6
  TOP w0.099: RE647.1 158.01,162.75 LE3.1 158.68,162.91 158.83,163.07 158.97,163.07 159.19,162.85 v1(159.19,162.83)
  IN1 w0.097: v1(159.19,162.83) 158.98,163.04 157.57,163.04 157.23,162.71 157.23,159.1 156.36,158.22 156.36,153.82 157.93,152.24 161.19,152.24 161.19,152.24 161.74,152.24 164.55,149.43 185.44,149.43 188.97,145.9 188.97,123.78 192.39,120.36 192.39,113.74 191.72,113.06 191.72,110.76 200.7,101.77 200.7,94.81 198.41,92.52 198.41,79.12 195.91,76.62 195.91,72.39 192.73,69.2 192.73,62.78 192.07,62.12 v1(192.06,62.12)
  BOTTOM w0.099: UH1.AA1 204.34,39.26 204.29,39.21 204.15,39.21 202.83,40.53 202.83,43.17 199.85,46.15 199.85,47.16 191.63,55.38 191.63,59.94 191.66,59.98 191.66,60.56 191.63,60.59 191.63,62.46 191.73,62.55 192.16,62.55 192.26,62.46 192.26,62.26 192.12,62.12 v1(192.06,62.12)
USB20_N9_L: length 8.2
  TOP w0.099: RE647.2 157.1,162.75 LE3.2 156.6,162.91 156.49,163.02 156.23,163.02 156.02,163.24 v1(156.02,164.33) 156.35,164.65 156.35,165.06 156.16,165.24 JTOBII.3
  BOTTOM w0.099: v1(156.02,164.33) 156.26,164.09 156.26,162.33 156.47,162.12 156.56,162.12 157.57,161.12 DV14.2
USB20_P1: length 221.7
  TOP w0.099: v1(26.33,40.1) 26.17,40.26 26.17,40.59 25.96,40.8 22.87,40.8 22.42,41.24 22.42,42.39 22.58,42.55 UU1.3
  IN4 w0.097: v1(207.89,36.96) 207.89,37 207.65,37.25 207.5,37.25 207.4,37.15 207.4,36.74 205.35,34.69 205.35,34.28 204.87,33.8 203.83,33.8 203.64,33.61 203.64,32.97 202.07,31.4 200.48,31.4 199.89,30.81 199.89,29.92 198.98,29.01 193.92,29.01 191.8,31.13 184.48,31.13 182.84,29.49 182.18,29.49 181.53,28.84 180.58,28.84 179.32,27.58 179.32,26.19 176.75,23.62 137.99,23.62 137.26,22.89 123.91,22.89 121.72,25.08 106.03,25.08 104.64,26.48 104.64,30.03 103.17,31.5 103.17,34.54 101.63,36.07 101.63,43.9 98.97,46.56 95.12,46.56 94.58,47.1 91.08,47.1 90.54,46.56 58.37,46.56 57.22,47.71 47.05,47.71 45.9,46.55 35.61,46.55 32.58,43.53 29.03,43.53 26.02,40.52 26.02,40.4 26.32,40.1 v1(26.33,40.1)
  BOTTOM w0.089: v1(207.89,36.96) 207.52,36.96 UH1.AG7
USB20_P1_CONN: length 13
  BOTTOM w0.099: LU3.3 23.75,39.02 23.63,38.89 23.63,37.35 23.07,36.79 22.55,36.79 22.45,36.69 DU1.3 22.13,36.34 22.13,36.73 22.03,36.83 21.8,36.83 19.71,38.92 19.15,38.92 v3(18.48,38.25) 18.03,37.8 16.68,37.8 16.55,37.68 JUSB1.3
USB20_P2: length 148.9
  TOP w0.099: JIO.24 325,21.36 324.92,21.27 324.14,21.27 323.39,20.52 v1(323.39,19.85)
  IN4 w0.097: v1(323.39,19.85) 323.64,20.1 323.64,20.39 323.36,20.67 321.76,20.67 316.76,25.67 316.1,25.67 314.05,27.71 290.84,27.71 289.26,26.14 268.61,26.14 265.69,23.22 265.69,22.27 263.81,20.38 263.06,20.38 258.44,15.77 246.76,15.77 246.24,16.29 245.32,16.29 243.76,17.85 242.4,17.85 240.36,19.89 234.05,19.89 231.25,22.7 229.58,22.7 227.98,24.29 227.98,33.31 226.66,34.63 224.09,34.63 223.03,33.57 221.08,33.57 217.91,36.74 217.24,36.74 216.29,37.69 216.29,38.2 215.71,38.78 212.62,38.78 211.68,37.84 210.08,37.84 209.93,37.69 208.81,37.69 208.34,38.15 207.61,38.15 206.64,37.18 206.64,37.02 v1(205.68,36.07)
  BOTTOM w0.089: v1(205.68,36.07) 205.87,36.07 206.06,36.26 206.06,36.6 UH1.AD7
USB20_P3: length 181.6
  IN1 w0.097: v1(167.32,172.29) 167.09,172.06 166.92,172.06 166.73,171.87 166.73,170.56 166.19,170.01 166.19,167.6 164.43,165.84 164.43,162 165.76,160.67 166.53,160.67 168.6,158.6 168.6,158.21 169.49,157.32 170.52,157.32 170.58,157.26 171.91,157.26 172.29,156.88 175.65,156.88 176.54,155.99 178.95,155.99 179.33,155.61 187.84,155.61 190.7,152.75 190.7,151.02 191.18,150.54 191.18,149.41 193.01,147.57 193.01,132.81 193.4,132.43 193.4,122.5 193.94,121.96 193.94,110.91 196.57,108.28 196.57,107.63 202.42,101.77 202.42,100.18 203.65,98.95 203.65,88.68 201.63,86.66 201.63,74.85 200.76,73.97 200.76,70.22 196.94,66.41 196.94,60.95 193.49,57.5 193.49,51.22 196.93,47.78 196.93,43.03 198.78,41.17 201.62,41.17 202.27,40.52 202.27,40.22 203.67,38.83 204.68,38.83 205.2,38.31 205.89,38.31 207.23,36.97 207.23,34.93 207.42,34.73 207.73,34.73 v1(207.83,34.63)
  BOTTOM w0.089: v1(207.83,34.63) 207.61,34.63 207.34,34.89 UH1.AG10
  BOTTOM w0.099: v1(167.32,172.29) 167.32,172.03 167.44,171.9 167.66,171.9 167.76,172 167.76,172.38 168.1,172.72 168.1,172.87 167.97,173 LM1.4
USB20_P3_CONN: length 3.6
  BOTTOM w0.099: JCDRA.39 167.82,176.66 167.94,176.54 167.94,176.37 167.71,176.13 167.71,175.64 168.16,175.19 168.16,175.04 167.97,174.85 LM1.3
USB20_P4: length 157.7
  TOP w0.099: v1(321.62,21.67) 321.95,21.34 321.95,20.67 321.93,20.64 321.93,20.06 321.95,20.03 321.95,19.16 316.5,13.71 316.5,10.53 316.2,10.23 UE1.4
  IN4 w0.097: v1(206.14,40.35) 206.14,40.44 206.31,40.61 206.5,40.61 206.76,40.86 207.19,40.86 208.3,41.96 209.93,41.96 210.08,41.81 210.08,41.55 210.9,40.74 214.44,40.74 214.52,40.82 215.89,40.82 216.28,41.21 216.93,41.21 217.64,40.5 224.48,40.5 225.01,41.04 225.99,41.04 226.48,40.55 226.48,39.31 231.24,34.55 231.24,29.17 234.32,26.08 235.01,26.08 236.03,25.07 237.02,25.07 242.94,19.15 244.3,19.15 245.85,17.6 246.32,17.6 246.39,17.6 257.45,17.6 267.29,27.44 275.45,27.44 276.7,28.69 288.23,28.69 289.93,30.39 313.51,30.39 321.89,22.01 321.89,21.79 321.77,21.67 v1(321.62,21.67)
  BOTTOM w0.089: UH1.AE2 206.65,38.94 206.65,39.06 206.55,39.16 206.4,39.16 206.2,39.36 206.2,39.78 206.32,39.9 206.32,40.26 206.23,40.35 v1(206.14,40.35)
USB20_P5: length 123
  IN4 w0.097: v1(205.72,37.2) 206.11,37.59 206.53,37.58 207.72,38.77 211.27,38.77 211.77,39.28 217.7,39.28 218.7,38.28 219.75,38.28 220.21,38.75 223.3,38.75 224.2,37.85 224.2,37.55 225.03,36.72 226.49,36.72 229.42,33.8 229.42,25.73 234.61,20.54 240.63,20.54 242.67,18.5 244.03,18.5 245.59,16.94 255.08,16.94 255.42,16.61 258.26,16.61 259.56,17.9 259.56,18.66 267.68,26.79 275.87,26.79 276.73,27.65 289.17,27.65 290.08,28.56 291.54,28.56 292.72,29.74 300.92,29.74 301,29.66 301,29.48 300.83,29.31 v1(300.78,29.31)
  BOTTOM w0.089: v1(205.72,37.2) 205.36,37.56 205.36,38.21 UH1.AC3
  BOTTOM w0.099: JWLAN.3 300.82,32.65 300.98,32.5 300.98,29.5 v1(300.78,29.31)
USB20_P6: length 188.7
  TOP w0.099: v1(165.14,165.62) 165.23,165.53 165.23,165.39 165.1,165.26 163.47,165.26 162.84,165.89 162.84,166.05 162.94,166.15 163.19,166.15 DV2.2 162.81,166.62 162.67,166.76 162.67,167.91 162.34,168.23 162.34,168.76 162.31,168.79 162.31,170.54 160.83,172.02 160.83,177.68 159.97,178.54 159.97,179.61 160.12,179.77 JEDP.18
  IN1 w0.097: v1(165.14,165.62) 165.08,165.56 165.08,165.33 165.18,165.23 165.27,165.23 165.35,165.15 165.66,165.15 165.87,164.94 165.87,163.31 169.53,159.65 171.39,159.65 171.6,159.86 175.78,159.86 178.21,157.43 188.1,157.43 190.42,155.1 190.42,154.54 191.52,153.44 191.52,151.36 192,150.88 192,149.75 194.22,147.53 194.22,122.85 194.77,122.3 194.77,111.25 197.6,108.42 197.6,107.76 203.34,102.01 203.34,100.45 205.15,98.64 205.15,82.44 203.52,80.8 203.52,73.87 201.58,71.93 201.58,69.88 199.17,67.47 199.17,61.85 194.31,56.99 194.31,51.65 197.75,48.22 197.75,43.37 199.11,42.01 201.8,42.01 203.88,39.92 204.91,39.92 205.37,39.47 205.81,39.47 206,39.28 207.09,39.28 207.35,39.54 207.35,39.84 207.13,40.06 206.98,40.06 206.87,39.95 v1(206.87,39.81)
  BOTTOM w0.089: v1(206.87,39.81) 206.88,39.81 207.05,39.64 207.05,39.33 207,39.28 207,38.72 UH1.AF3
USB20_P7: length 162.6
  TOP w0.099: LV2.4 168.03,161.13 167.77,160.87 167.77,160.74 167.86,160.64 168.17,160.64 168.41,160.88 168.41,161.04 168.62,161.25 168.73,161.25 169.11,161.63 v1(169.11,161.64)
  IN1 w0.097: v1(169.11,161.64) 169.32,161.43 169.56,161.43 169.76,161.23 169.76,160.61 169.85,160.51 171.48,160.51 171.48,160.51 176.14,160.51 178.44,158.21 187.21,158.21 187.47,158.47 188.28,158.47 190.57,156.19 190.95,156.19 192.17,154.96 192.17,151.63 192.65,151.15 192.65,150.02 194.87,147.8 194.87,123.12 195.42,122.57 195.42,111.52 198.41,108.53 198.41,107.88 203.99,102.3 203.99,100.72 205.8,98.91 205.8,82.17 204.17,80.54 204.17,73.57 202.23,71.63 202.23,69.61 199.82,67.2 199.82,61.55 195,56.73 195,51.93 198.4,48.53 198.4,44.01 199.66,42.75 201.82,42.75 203.04,41.53 204.25,41.53 204.59,41.19 204.85,41.19 205.24,40.8 205.38,40.8 v1(205.57,40.99)
  BOTTOM w0.089: UH1.AB2 204.92,39 204.76,39.16 204.76,39.35 205,39.58 205,40.44 205.2,40.64 205.22,40.64 v1(205.57,40.99)
USB20_P8: length 245.7
  IN4 w0.097: v1(16.13,56.41) 16.13,56.41 16.33,56.21 16.53,56.21 16.84,55.9 16.84,50.58 20.18,47.23 20.18,45.44 22.83,42.8 22.83,36.95 23.26,36.53 24.3,36.53 28.74,40.97 32.26,40.97 37.36,46.08 46.09,46.08 46.74,46.72 52.69,46.72 53.17,47.21 57.05,47.21 58.23,46.02 84.39,46.02 84.48,45.92 97.67,45.92 101,42.59 101,36.01 102.69,34.32 102.69,31.02 104.14,29.57 104.14,26.26 105.79,24.61 121.52,24.61 123.89,22.24 137.29,22.24 138.19,23.14 177.29,23.14 179.92,25.77 179.92,27.51 180.77,28.36 183.73,28.36 186.02,30.65 191.32,30.65 193.74,28.23 198.78,28.23 200.98,30.43 203.71,30.43 205.7,32.43 205.7,33.52 206,33.81 206.96,33.81 207.29,34.15 207.29,35.98 207.65,36.34 208.28,36.34 208.62,36.68 208.94,36.68 v1(209.26,36.99)
  BOTTOM w0.089: v1(209.26,36.99) 209.58,36.67 UH1.AL7
  BOTTOM w0.099: LU9.1 16.16,57.64 16.01,57.49 15.95,57.49 15.85,57.39 15.85,56.97 15.53,56.64 15.53,56.19 15.62,56.09 15.82,56.09 16.13,56.4 v1(16.13,56.41)
USB20_P8_CONN: length 19
  TOP w0.099: JUSBC2.B6 6.49,60.17 6.63,60.04 v1(6.71,60.04) ; JUSBC2.A6 7.97,60.42 8.04,60.36 8.74,60.36 8.89,60.51 v1(8.89,60.6)
  IN1 w0.097: v1(8.89,60.6) 8.89,60.57 9.39,60.07 9.56,60.07 9.66,60.17 9.66,61.12 8.69,62.09 8.02,62.09 7.68,61.76 7.68,61.23 7.23,60.78 7.23,60.46 6.82,60.04 v1(6.71,60.04)
  BOTTOM w0.099: v1(8.89,60.6) 8.89,60.48 9.06,60.31 9.28,60.09 10.73,60.09 11.44,60.8 12.45,60.8 13.46,59.79 13.75,59.79 13.94,59.98 DU11.2 13.94,60.69 14.73,60.69 15.08,60.34 15.08,60.25 15.22,60.1 15.74,60.1 15.95,59.89 15.95,59.78 16.16,59.57 LU9.2
USB20_P9: length 171.5
  TOP w0.099: RE648.1 158.01,163.58 LE3.4 158.68,163.41 158.83,163.26 159.04,163.26 v1(159.19,163.41)
  IN1 w0.097: v1(159.19,163.41) 158.99,163.21 157.5,163.21 157.06,162.78 157.06,159.17 156.18,158.29 156.18,153.68 157.84,152.02 161.65,152.02 164.41,149.26 185.37,149.26 188.8,145.82 188.8,123.71 192.22,120.29 192.22,113.81 191.54,113.13 191.54,110.69 200.53,101.7 200.53,94.88 198.24,92.59 198.24,79.19 195.74,76.69 195.74,72.46 192.56,69.27 192.56,62.85 192.41,62.7 192.22,62.7 192.12,62.8 v1(192.12,62.96)
  BOTTOM w0.099: UH1.AA2 204.24,39.01 204.07,39.01 204.07,39.01 204.07,39.02 203.87,39.22 203.86,39.22 202.64,40.44 202.64,43.09 199.65,46.07 199.65,47.08 191.44,55.3 v3(191.44,60.27) 191.44,62.56 191.65,62.77 191.93,62.77 v1(192.12,62.96)
USB20_P9_L: length 7.8
  TOP w0.099: JTOBII.4 156.96,165.36 156.54,164.94 156.54,164.48 v1(156.71,164.32) 156.61,164.32 156.21,163.92 156.21,163.32 156.31,163.22 156.46,163.22 156.66,163.41 LE3.3 157.1,163.58 RE648.2
  BOTTOM w0.099: DV14.3 157.37,163.05 156.64,162.31 156.55,162.31 156.45,162.41 156.45,164.06 v1(156.71,164.32)
USB_OC0#: length 241.1
  TOP w0.107: UU1.13 20.3,45.33 19.76,45.88 18.49,45.88 17.98,46.39 v1(17.6,46.39)
  IN3 w0.091: v1(17.6,46.39) 23.44,40.55 30.49,40.55 33.19,37.85 33.19,35.82 33.93,35.07 33.93,33.96 34.93,32.95 34.93,27.65 34.49,27.21 34.49,25.24 35.06,24.67 37.64,24.67 38.59,23.72 38.59,20.63 42.56,16.66 42.56,16.35 42.88,16.03 43.49,16.03 45.78,13.75 49.87,13.75 51.47,12.15 62.43,12.15 62.97,11.61 68.43,11.61 71.26,8.78 81.11,8.78 81.17,8.85 86.38,8.85 88.11,10.58 103.94,10.58 104.67,9.84 108.12,9.84 v1(109.42,8.54)
  IN4 w0.097: v1(109.42,8.54) 114.25,13.37 118.94,13.37 119.22,13.09 119.22,10.61 119.51,10.32 132.43,10.32 139.18,17.07 177.57,17.07 185.01,24.51 185.89,24.51 187.77,26.39 193.08,26.39 193.88,25.59 200,25.59 201.49,24.1 202.38,24.1 203.02,23.46 203.02,21.36 203.92,20.45 203.92,18.74 204.2,18.46 204.77,18.46 205.67,17.56 205.67,16.78 205.58,16.69 v1(205.58,16.08)
  BOTTOM w0.089: 205.68,15.87 205.58,15.97 v1(205.58,16.08) 205.58,16.09 206.35,16.85 206.35,17.48 206.45,17.58 206.45,18.44 UH1.AD43
  BOTTOM w0.107: RPH6.4 205.68,15.87
USB_OC1#: length 89.4
  IN4 w0.089: 218.72,15.55 218.06,16.21 214.55,16.21 214.06,15.72
  IN4 w0.097: 214.06,15.72 212.67,15.72 211.69,16.7 209.4,16.7 208.68,15.97 206.78,15.97 v1(206.68,16.07) ; v1(267.47,13.23) 266.26,13.23 264.9,11.87 250.35,11.87 250.18,12.04 246.34,12.04 245.82,12.57 243.4,12.57 241.6,14.36 240.09,14.36 239.78,14.66 237.41,14.66 236.96,15.12 236.1,15.12 234.93,16.29 227.81,16.29 227.08,15.55 218.72,15.55
  BOTTOM w0.089: 206.19,15.16 206.19,15.46 206.68,15.95 v1(206.68,16.07) 206.7,16.1 206.7,17.33 207.03,17.66 207.03,18.44 206.27,19.2 UH1.AD42
  BOTTOM w0.107: CU17.1 262,24.3 262.53,23.77 UU3.3 262.53,21.22 263.14,20.62 263.53,20.62 263.74,20.83 266.51,20.83 267.7,19.64 267.7,18.27 267.12,17.69 267.12,16.81 266.48,16.17 266.48,14.22 v1(267.47,13.23) ; RPH6.3 205.19,14.38 205.31,14.26 206.09,14.26 206.19,14.36 206.19,15.16
USB_OC2#: length 7.5
  BOTTOM w0.102: v2(203.53,16.29) 203.53,16.57 203.85,16.9 204.5,16.9 204.61,17 204.61,17.26 205.13,17.78 205.16,17.78 205.42,18.05 205.42,19.61 UH1.AD39
  BOTTOM w0.107: v2(203.53,16.29) 203.53,15.59 203.72,15.4 203.97,15.4 204.19,15.18 RPH6.1
USB_OC3#: length 5.4
  BOTTOM w0.102: UH1.AC44 205.67,18.07 205.8,17.93 205.8,17.37 205.3,16.87 205.06,16.87 204.68,16.49 204.02,16.49 203.91,16.38 203.91,16.22
  BOTTOM w0.107: 203.91,16.22 203.91,15.78 204.1,15.59 204.35,15.59 204.69,15.26 RPH6.2
USB_PWR_EN: length 68
  TOP w0.107: v1(313.69,23.66) 313.38,23.97 RE645.2 ; UE5.117 v1(305.93,17.81)
  IN2 w0.091: v1(305.93,17.81) 305.93,18.11 305.55,18.49 305.14,18.49 304.42,19.21 302.23,19.21 301.73,18.71 297.81,18.71 296.46,20.06 288.19,20.06 284.35,23.91 276.68,23.91 276.11,24.48 276.11,25.62 275.54,26.19 267.78,26.19 v1(267.53,25.94)
  IN3 w0.091: v1(305.93,17.81) 305.93,17.8 307.83,15.91 308.75,15.91 310,17.16 312.17,17.16 313.02,18.01 313.02,22.98 v1(313.69,23.66)
  BOTTOM w0.107: v1(267.53,25.94) 265.57,25.94 264.74,25.11 262.77,25.11 262.53,25.35 UU3.4 262.02,26.07 CU16.1
USBC_PWR_EN: length 313.8
  TOP w0.107: UE10.5 309.05,48.03 309.18,47.9 v1(309.19,47.9) RE649.2
  IN2 w0.091: v1(268.36,37.18) 267.71,37.18 262.53,42.36 234.19,42.36 233.49,43.05 227.76,43.05 226.7,44.12 214.98,44.12 213.73,45.38 207.41,45.38 206.68,44.64 203.1,44.64 203.09,44.65 198.85,44.65 197.87,43.67 192.21,43.67 191.47,42.94 183.54,42.94 180.46,39.86 178.92,39.86 178.53,39.47 174.31,39.47 171.64,42.14 171.64,45.11 170.23,46.51 109.02,46.51 108.48,45.98 100.14,45.98 99.07,47.04 95.61,47.04 94.75,47.91 85.39,47.91 84.99,48.31 66.7,48.31 66.15,48.86 60.51,48.86 59.9,48.25 58.5,48.25 57.94,48.81 55.21,48.81 55.2,48.79 44.89,48.79 44.09,47.99 35.42,47.99 34.16,49.24 28.65,49.24 27.1,50.79 21.13,50.79 v1(20.58,51.34)
  IN4 w0.097: v1(268.36,37.18) 268.44,37.26 284.56,37.26 285.08,37.78 288.57,37.78 289.68,38.89 298.36,38.89 299.68,40.22 305.29,40.22 309.8,44.72 309.8,47.29 v1(309.19,47.9)
  BOTTOM w0.107: v1(20.58,51.34) 20.77,51.15 CU35.1 20.32,50.65 19.84,51.13 UU7.6
USBCHG_DET#: length 37.4
  TOP w0.107: DU6.2 v2(35.67,48.52)
  TOP w0.508: CU27.2 32.06,45.6 32.65,46.18 RU4.2 32.83,47.12 CU28.1 33.28,47.14 v1(33.7,47.56) 34.28,48.13 DU6.2
  IN1 w0.508: v1(33.7,47.56) 33.7,39.32 31.93,37.55 30.31,37.55 29.82,38.04 26.91,38.04 24.51,35.64 16.43,35.64 15.26,34.47 14.58,34.47 13.78,33.68 JUSB1.10
USBCHG_DET_D: length 38
  TOP w0.254: PD100.3 59.03,44.59 v1(59.6,44.02)
  TOP w0.381: v1(27.86,46.87) RU6.1 27.86,45.23 27.99,45.11 UU5.4
  IN3 w0.254: v1(59.6,44.02) 58.38,44.02 57.22,45.18 56.02,45.18 54.42,46.78 53.66,46.78 52.05,45.17 50.42,45.17 49.61,45.97 33.12,45.97 32.84,45.69 28.38,45.69 27.86,46.21 v1(27.86,46.87)
USBCHG_DET_EC#: length 302
  TOP w0.107: UE5.75 297.14,9.1 296.96,9.28 296.96,10.38 296.37,10.97 296.37,17.56 295.47,18.45 v1(295.47,22.32) ; DU6.1 31.14,48.52 v2(30.32,47.7) 29.7,47.09 v1(29.7,46.96) CU29.1 RU6.2
  IN2 w0.089: 193.27,42.06 197.58,42.06 197.59,42.08
  IN2 w0.091: 197.59,42.08 198.66,43.15 200.62,43.15 201.24,43.77 207.04,43.77 207.13,43.86 213.3,43.86 213.68,43.48 214.36,43.48 214.59,43.25 222.37,43.25 223.08,42.54 227.04,42.54 227.4,42.18 232.77,42.18 234.3,40.65 256.54,40.65 257.33,41.44 262.21,41.44 267.74,35.91 268.94,35.91 273.8,31.05 281.12,31.05 285.56,26.61 290.81,26.61 295.1,22.32 v1(295.47,22.32) ; 193.27,42.06 183.9,42.06 180.17,38.33 174.21,38.33 173.2,39.35 113.11,39.35 110.96,41.5 109.57,41.5 105.96,45.1 98.95,45.1 97.88,46.17 95.88,46.17 95.71,45.99 93.43,45.99 93.38,46.04 92.51,46.04 91.79,46.76 58.18,46.76 57.38,47.55 55.73,47.55 55.72,47.54 53.4,47.54 52.59,46.74 33.63,46.74 32.94,46.05 30.61,46.05 v1(29.7,46.96)
VCIN0_PH1: length 262.3
  TOP w0.203: v1(305.89,15.08) 305.89,14.95 306.23,14.61 UE5.109
  TOP w0.254: PH1.1 153.72,110.42 v1(153.94,110.2) ; v1(275.83,28.73) 275.83,30.93 276.36,31.46 PR24.1 PR25.1
  IN2 w0.254: v1(304.75,21.24) 302.95,21.24 301.32,19.61 298.19,19.61 296.83,20.96 294.5,20.96 292.92,22.55 286.98,22.55 283.51,26.01 280.26,26.01 277.53,28.73 v1(275.83,28.73) 275.32,29.24 269.9,29.24 269.09,30.05 269.09,31.17 263.65,36.61 240.34,36.61 239.41,37.54 233.34,37.54 232.57,38.31 224.76,38.31 222.96,40.11 216.56,40.11 215.92,40.75 214.67,40.75 214.35,40.44 213.25,40.44 213,40.7 212.09,40.7 210.82,39.43 207.12,39.43 207.05,39.36 205.44,39.36 205.37,39.43 203.82,39.43 201.85,41.4 199.42,41.4 197.73,39.71 195.99,39.71 195.46,39.17 192.85,39.17 191.65,37.97 191.65,34.99 190.92,34.26 183,34.26 181.73,32.99 155.71,32.99 v1(155.14,33.56)
  IN3 w0.254: v1(155.14,33.56) 154.79,33.91 154.79,45.03 156.13,46.38 156.13,51.33 157.24,52.45 157.24,65.48 153.55,69.17 153.55,96.02 152.03,97.54 152.03,99.47 152.51,99.96 152.51,102.28 153.5,103.27 153.5,109.81 153.88,110.2 v1(153.94,110.2)
  BOTTOM w0.254: v1(304.75,21.24) 305.89,21.24 306.72,20.41 306.72,15.92 v1(305.89,15.08)
VCIN1_AC_IN: length 486.5
  TOP w0.107: QE3.5 325.83,42.58 325.65,42.4 323.72,42.4 323.07,41.75 v1(322.59,41.75) ; CE40.2 308.93,13.79 v1(308.4,14.32) 308.4,14.67 308.05,15.01 UE5.110
  TOP w0.254: PR714.2 56.31,25.77 56.31,25.77 v1(56.59,25.5) 57.04,25.04 PU700.5 ; v1(109.04,72.42) 111.71,75.09 v2(112.72,75.09) 113.99,75.09 115.82,76.92 PR731.1
  IN1 w0.097: v1(322.59,41.75) 322.08,41.24 322.08,38.23 321.57,37.72 301.48,37.72 301.16,37.4 291.63,37.4 287.79,33.56 282.39,33.56 282.39,33.56 280.99,33.56 280.96,33.52 265.17,33.52 263.36,35.34 249.28,35.34 244.42,30.47 244.42,26.95 242.1,24.63 237.16,24.63 236.04,23.51 236.04,23.08 235.17,22.22 231.54,22.22 231.02,22.74 228.87,22.74 227.76,23.85 227.76,24.9 226.54,26.12 226.54,27.83 225.82,28.55 224.74,28.55 222.71,30.58 222.71,34.16 v1(222.71,34.16)
  IN1 w0.254: v1(56.59,25.5) 60.91,29.81 60.91,32.19 65.16,36.45 65.16,39.59 65.99,40.42 65.99,46.1 66.78,46.9 88.57,46.9 93,51.32 93,52.17 102.36,61.52 102.36,65.74 v1(109.04,72.42)
  IN2 w0.091: v1(212.21,117.76) 212.17,117.76 210.64,116.23 210.64,114.5 209.01,112.87 209.01,91.67 210.79,89.88 v1(211.21,89.88)
  IN3 w0.089: 216.18,42.08 216.11,42.02 216.11,40.8 216.49,40.42 219.18,40.42
  IN3 w0.091: v1(222.71,34.16) 223.19,34.64 223.19,34.7 223.53,35.03 223.53,38.89 222,40.42 219.18,40.42 ; v1(322.59,41.75) 322.08,41.24 322.08,36.31 319.6,33.83 319.6,30.27 315.59,26.25 315.59,19.96 309.95,14.32 v1(308.4,14.32) ; v1(211.21,89.88) 211.21,89.31 212.25,88.27 212.25,87.08 211.09,85.92 208.39,85.92 205.1,82.63 205.1,80.27 205.51,79.86 205.51,79.43 205.1,79.03 205.1,76.27 207.72,73.65 207.72,71.11 206.59,69.98 206.59,62.3 209.21,59.68 210.42,59.68 211.39,58.72 211.39,50.55 210.92,50.09 210.92,47.97 216.18,42.71 216.18,42.08
  BOTTOM w0.107: v1(212.21,117.76) 212.38,117.93 UG4.1 ; v1(222.71,34.16) 222.71,31.84 224.41,30.14 224.41,27.9 DH1.1 ; v1(211.21,89.88) 211.21,90.26 210.66,90.81 210.47,90.81 207.65,93.63 205.24,93.63 204.22,92.62 200.34,92.62 199.96,92.24 199.96,88.61 199.53,88.17 191.46,88.17 187.11,83.82 122.78,83.82 114.05,75.09 111.71,75.09 v1(109.04,72.42)
  BOTTOM w0.254: PR715.1 57.24,24.91 56.65,25.5 v1(56.59,25.5)
VCIN1_ADP_PROCHOT: length 19.1
  TOP w0.107: UE5.102 306.17,11.81 v1(305.13,12.86) ; v1(294.84,5.43) 294.84,5.75 v2(295.09,6)
  TOP w0.254: v1(294.84,5.43) 294.81,5.4 PR26.2 PC13.2 PR23.1
  IN4 w0.097: v1(294.84,5.43) 298.11,8.7 300.97,8.7 v1(305.13,12.86)
VCIN_ BATT_TEMP: length 289.6
  TOP w0.203: CE35.2 290.01,10 290.23,10.21 UE5.63
  TOP w0.254: PR22.2 81.31,9.92 81.87,9.35 PR16.1 81.87,8.36 PC14.1 ; PR22.2 79.72,9.85 PD3.2 ; PR22.2 79.34,9.92 78.56,10.7 78.56,14.07 v2(80.02,15.53) 81.11,16.61 v1(81.11,18.32) ; CE35.2 289.9,9.49 289.48,9.07 285.23,9.07 284.36,9.94 284.36,14.87 279.91,19.32 279.91,24.61 v1(279.6,24.92) ; PR727.1 54.76,17.74 v1(54.57,17.54)
  IN2 w0.254: v1(279.6,24.92) 279.55,24.88 278.82,24.88 277.77,25.93 276.22,25.93 275.66,26.49 265.02,26.49 256.75,34.75 239.96,34.75 239.79,34.58 234,34.58 233.63,34.96 231.7,34.96 231.32,35.34 227.91,35.34 226.89,34.32 224.48,34.32 223.1,32.94 220.35,32.94 218.64,34.65 218.64,35.4 218.39,35.66 217.69,35.66 217.03,36.31 215.37,36.31 213.85,37.83 212.93,37.83 212.67,37.57 212.67,37.05 211.35,35.73 209,35.73 208.44,36.29 207.65,36.29 207.4,36.04 207.4,35.02 207.27,34.89 207.27,34 206.96,33.69 206.13,33.69 205.94,33.88 203.21,33.88 203.01,33.68 198.82,33.68 197.65,32.52 195.14,32.52 193.34,30.72 177.3,30.72 168.65,22.07 120.58,22.07 118.44,19.93 102.98,19.93 102.56,19.51 97.99,19.51 97.03,18.55 81.33,18.55 v1(81.11,18.32) 81.11,17.58 79.07,15.54 69.72,15.54 67.55,13.37 63.3,13.37 62.97,13.7 57.59,13.7 56.43,14.85 56.43,16.55 55.44,17.54 v1(54.57,17.54)
VCOUT0_MAIN_PWR_ON#: length 283.7
  TOP w0.107: v1(59.17,48.85) 58.77,48.45 PR114.1 ; UE5.104 v1(308.4,12.61)
  IN2 w0.091: v1(306.46,26.3) 296.41,26.3 295.59,25.48 293.18,25.48 291.17,27.48 285.92,27.48 281.48,31.92 279.4,31.92 278.09,33.24 274.06,33.24 263.38,43.91 258.63,43.91 258.63,43.91 228.12,43.91 227.05,44.97 216.94,44.97 216.04,45.87 214.44,45.87 214.08,46.23 209.53,46.23 208.29,47.46 208.29,49.83 206.4,51.72 203.56,51.72 199.69,47.85 196.18,47.85 192.42,51.61 185.17,51.61 183.34,49.79 181.34,49.79 178.92,47.37 176.74,47.37 176.42,47.69 175.04,47.69 174.73,48 110.98,48 110.38,48.6 96.8,48.6 96.39,48.2 95.66,48.2 95.06,48.79 87.36,48.79 87.25,48.91 81.97,48.91 81.59,48.53 66.79,48.53 66.24,49.07 59.39,49.07 v1(59.17,48.85)
  BOTTOM w0.107: v1(308.4,12.61) 308.94,13.15 308.94,15.44 308.59,15.78 307.85,15.78 307.41,16.22 307.41,25.35 v1(306.46,26.3)
VCOUT1_PROCHOT#: length 3
  TOP w0.107: RE85.2 RE84.2 308.5,12.01 308.3,12.21 UE5.103
VD33STB: length 2.9
  TOP w0.107: RA25.2 37.29,28.79 36.86,29.22 v1(36.86,29.43) 36.33,29.43 v2(36.14,29.24)
  BOTTOM w0.107: v1(36.86,29.43) 36.51,29.43 36.44,29.51 UA1.10
VGA_EN: length 4.8
  BOTTOM w0.107: UM8.26 126.17,157.68 125.73,158.12 RM87.1 125.23,157.74 124.9,157.41 RM14.2 124.9,157 124.51,156.61 123.47,156.61 v2(123.33,156.47)
VGA_SMB_CK3: length 60.1
  IN4 w0.097: v1(225.37,89) 225.68,89.31 225.68,90.01 225.04,90.65 218.87,90.65 217.27,92.25 217.27,95.92 213.88,99.32 213.88,100.99 212.69,102.18 208.31,102.18 207.56,102.94 207.56,104.95 207.78,105.17 v1(207.78,105.44)
  BOTTOM w0.107: QG1.4 212.63,123.77 212.5,123.9 212.5,124.63 212.74,124.87 RG42.2 213.55,124.9 213.13,125.32 211.4,125.32 v3(209.59,123.51) 206.21,120.13 206.21,116.23 206.42,116.02 UG3.8 206.42,114.15 206.21,113.94 206.21,112.93 207.54,111.6 207.54,106.13 207.3,105.89 207.3,105.15 207.43,105.02 207.67,105.02 207.78,105.12 v1(207.78,105.44)
  BOTTOM w0.135: UG1.AM34 225.37,89.15 v1(225.37,89)
VGA_SMB_DA3: length 67.5
  IN4 w0.097: v1(208.19,105.03) 207.96,105.03 207.78,104.85 207.78,103.03 208.4,102.41 212.78,102.41 214.1,101.09 214.1,99.41 215.78,97.73 215.78,97.68 217.46,96 217.46,92.32 218.94,90.84 225.12,90.84 225.86,90.09 225.86,89.31 v1(226.17,89)
  BOTTOM w0.107: QG1.1 213.93,121.06 214.08,120.92 215,120.92 215.06,120.98 RG41.2 216.11,121.96 216.42,122.27 216.42,124.05 214.91,125.55 211.3,125.55 205.98,120.22 205.98,116.23 205.77,116.02 UG3.7 205.77,114.15 205.98,113.94 205.98,112.83 207.31,111.5 207.31,106.22 207.06,105.98 207.06,105.05 207.34,104.78 207.77,104.78 208.02,105.03 v1(208.19,105.03)
  BOTTOM w0.135: v1(226.17,89) 226.17,89.15 UG1.AM33
VL: length 4.4
  BOTTOM w0.107: v2(51.52,41.69) 53.11,41.69 53.73,42.31 PC111.1
  BOTTOM w0.203: PU100.13 53.86,43.5 53.95,43.42 53.95,43.05 53.73,42.84 53.73,42.83 PC111.1
VR_HOT#: length 360.3
  TOP w0.107: RE78.1 306.41,5.67 306.19,5.89 v1(306.19,6.26)
  IN1 w0.097: v1(306.19,6.26) 306.19,7.23 305.89,7.53 305.05,7.53 304.33,8.25 300.66,8.25 299.98,8.92 299.98,10.57 298.17,12.38 297.07,12.38 296.02,13.43 294.56,13.43 293.31,14.67 278.69,14.67 277.73,15.63 275.22,15.63 273.71,14.13 265.35,14.13 264.22,13 240.89,13 239.68,11.79 233.47,11.79 233.21,11.53 232.36,10.67 214.75,10.67 213.98,9.9 207.06,9.9 206.85,10.11 204.14,10.11 203.93,9.9 202.24,9.9 201.91,10.23 199.57,10.23 199.56,10.23 191.71,10.23 190.8,11.13 186.64,11.13 179.31,18.47 179.31,20 177.31,22 v1(176.28,22)
  IN3 w0.091: v1(98.16,22.57) 98.16,26.27 99.3,27.4 100.19,27.4 105.17,32.38 105.17,33.88 105.92,34.64 105.92,37.76 105.86,37.82 105.86,51.33 105.15,52.04 105.11,52.04 104.53,52.62 104.53,53.99 104.64,54.1 104.64,57.27 105.67,58.3 105.67,65.34 117.88,77.55 117.88,93.28 125.19,100.59 125.19,102.04 129.21,106.06 129.21,111.96 127.41,113.77 127.41,131.14 v1(124.02,134.53)
  IN4 w0.097: v1(176.28,22) 175.84,22.45 175.21,22.45 173.83,21.07 137.13,21.07 135.48,19.42 103.09,19.42 101.35,17.69 99.64,17.69 98.84,18.49 98.84,21.9 v1(98.16,22.57)
  BOTTOM w0.107: PC501.1 124.06,134.49 v1(124.02,134.53) 124.06,134.57 PR504.2
VR_PWRGD: length 370.6
  TOP w0.107: v1(123.44,134.53) 123.44,134.67 PR520.1 ; v1(304.49,12.86) 305.94,11.41 UE5.101
  IN1 w0.097: v1(203.67,54.54) 203.67,53.79 204.14,53.32 206.89,53.32 209.77,50.45 209.77,45.54 212.56,42.74 212.56,40.95 212.3,40.69 212.3,38.18 212.61,37.88 212.61,36.42 213.37,35.66 214.72,35.66 215.02,35.35 215.1,35.35 215.75,34.7 217.03,34.7 218.07,33.66 219.09,33.66 219.94,32.81 219.94,30.67 222.84,27.78 222.84,27.65 224.58,25.91 224.58,18.54 225.05,18.07 v1(225.05,17.98)
  IN2 w0.091: v1(225.05,17.98) 225.45,18.38 226.95,18.38 228.56,16.77 230.73,16.77 231.13,16.37 236.97,16.37 238,15.34 242.14,15.34 243.17,16.37 246.2,16.37 246.85,15.72 263.29,15.72 263.39,15.83 263.39,16.27 263.6,16.48 263.76,16.48 265.66,18.37 268.12,18.37 269.55,19.8 271.23,19.8 272.18,18.86 274.07,18.86 278.02,14.91 291.26,14.91 291.96,14.22 294.63,14.22 295,13.85 296.24,13.85 296.81,13.28 301.61,13.28 302.01,13.68 303.67,13.68 v1(304.49,12.86)
  IN3 w0.091: v1(123.44,134.53) 127.01,130.95 127.01,113.6 128.82,111.8 128.82,107.26 124.79,103.24 124.79,100.75 117.49,93.44 117.49,77.71 105.05,65.28 105.05,60.48 104.78,60.22 104.78,58.05 103.68,56.95 103.68,52 105.38,50.3 105.38,36.63 v1(105.51,36.5)
  IN4 w0.097: v1(203.67,54.54) 203.34,54.21 202.69,54.21 200.71,52.23 194.72,52.23 192.9,54.05 189.05,54.05 187.43,52.43 187.43,42.11 179.92,34.6 170.28,34.6 165.46,29.79 135.21,29.79 133.85,31.15 132.47,31.15 127.9,35.72 112.46,35.72 111.81,36.37 105.64,36.37 v1(105.51,36.5)
VR_SVID_ALERT#: length 15.8
  IN4 w0.097: v1(128.34,120.17) 127.97,120.54 127.97,122.96 126.12,124.81 126.12,130.23 v1(125.36,131)
  BOTTOM w0.107: PR509.2 v2(125.84,131.67) 125.84,131.48 v1(125.36,131) ; RH152.2 RH153.1 128.19,120.02 v1(128.34,120.17)
VR_SVID_CLK: length 30
  IN4 w0.089: 129.93,120.88 130.56,120.88 133.29,118.15 133.29,115.76
  IN4 w0.097: v1(136.92,116.68) 136.53,116.28 136.53,115.07 136.39,114.94 134.11,114.94 133.29,115.76 ; 129.93,120.88 128.38,122.43 128.38,123.13 126.56,124.94 126.56,130.46 125.54,131.49 v1(124.66,131.49)
  BOTTOM w0.076: v1(136.92,116.68) 137.29,116.31 CPU1.BH32
  BOTTOM w0.107: v1(124.66,131.49) 124.66,131.48 124.03,130.86 123.88,130.86 123.62,131.12 123.62,131.27 124.47,132.11 124.79,132.11 124.95,132.27 PR507.2
VR_SVID_DATA: length 30.8
  IN4 w0.097: v1(137.43,113.76) 136.37,113.76 135.89,114.24 133.41,114.24 132.39,115.26 130.53,115.26 129.8,115.98 129.8,117.41 v1(128.34,118.88) 127.57,119.64 127.57,122.72 124.97,125.32 124.97,130.59 v1(124.66,130.91)
  BOTTOM w0.076: v1(137.43,113.76) 137.44,113.76 CPU1.BH29
  BOTTOM w0.107: RH151.2 128.28,118.81 v1(128.34,118.88) ; PR511.2 126.73,131.51 125.8,130.59 124.98,130.59 v1(124.66,130.91)
VRAM_0: length 14.8
  IN1 w0.089: 238.25,76.71 239.13,77.59 239.13,78.33 239.77,78.98 239.77,82.57 239.59,82.75 239.59,84.3 239.24,84.65 v1(239.24,84.73)
  IN1 w0.097: v1(237.84,75.14) 237.41,75.57 237.41,75.88 238.25,76.71
  BOTTOM w0.089: UG1.AV19 239.57,84.4 v1(239.24,84.73)
  BOTTOM w0.107: RG161.2 RG160.1 235.7,75.61 235.86,75.44 237.54,75.44 v1(237.84,75.14)
VRAM_1: length 13.8
  IN1 w0.089: 237.93,76.71 238.95,77.73 238.95,78.4 239.59,79.05 239.59,82.42 239.23,82.79 v1(239.23,83.05)
  IN1 w0.097: v1(237.16,75) 237.11,75.05 237.11,75.89 237.93,76.71
  BOTTOM w0.089: UG1.AW19 239.67,83.5 v1(239.23,83.05)
  BOTTOM w0.107: RG162.1 RG163.2 234.55,75.55 235.1,75 v1(237.16,75)
VRAM_2: length 14.2
  IN1 w0.089: 238.83,76.71 239.3,77.19 239.3,78.26 239.95,78.9 239.95,82.67 239.78,82.84 239.78,85.8 v1(239.15,86.43)
  IN1 w0.097: v1(237.85,75.74) 238.83,76.71
  BOTTOM w0.089: v1(239.15,86.43) 238.78,86.8 UG1.AR20
  BOTTOM w0.107: v1(237.85,75.74) 237.74,75.85 RG165.2 RG164.1
VROM_SEL: length 26.5
  IN4 w0.089: v1(214.7,26.32) 214.13,25.75 211.24,25.75 210.73,25.24 210.73,20.48 210.94,20.26 211.46,20.26 211.79,20.58 211.79,21.19 212.03,21.43 212.38,21.43 212.64,21.7 215.21,21.7 216.47,22.96 218.99,22.96 219.18,22.77
  IN4 w0.097: 219.18,22.77 v1(219.29,22.66)
  BOTTOM w0.089: UH1.BC27 214.8,26.42 v1(214.7,26.32)
  BOTTOM w0.107: v1(219.29,22.66) 219.5,22.87 223.02,22.87 223.61,23.46 223.61,23.64 RH588.2 RH589.2
VSB_N_001: length 5.8
  TOP w0.508: PQ3.3 70.44,11.4 70.96,11.92 PR13.2 72.37,11.92 v2(72.71,11.58) 73.02,11.27 PR12.2 73.02,10.24 72.4,9.62 PC10.2
VSB_N_002: length 3.7
  TOP w0.107: v2(69.91,6.13) PQ4.2
  TOP w0.508: PQ4.2 69.91,7.68 69.4,8.19 PC12.1 68.86,8.21 PR17.1
VSB_N_003: length 5
  TOP w0.107: PQ4.1 71.15,8.65 72.17,8.65 v2(72.75,8.06)
  TOP w0.508: PR13.1 71.7,10.2 70.73,9.24 PQ4.1
VSENSEN_L: length 3.5
  TOP w0.203: UA4.27 31.85,13.97 31.7,14.13
  TOP w0.508: RA61.2 29.8,15.33 RA79.1 30.67,14.96 31.19,14.45 31.38,14.45 31.7,14.13
VSENSEN_R: length 2.8
  TOP w0.203: UA4.30 29.56,12.01 29.47,12.1
  TOP w0.508: 29.47,12.1 29.41,12.1 29.4,12.1 RA82.1 RA65.2
VTTREF_1.2V: length 1.7
  BOTTOM w0.203: PC210.1 92.91,46.29 93.07,46.13 PU201.4
WAKE#: length 6.8
  TOP w0.089: RH4.2 218.41,34.02 v1(218.53,34.14)
  BOTTOM w0.089: v1(218.53,34.14) 217.77,33.38 216.2,33.38 216.07,33.5 215.76,33.5 215.5,33.76 UH1.BC13
  BOTTOM w0.107: v1(218.53,34.14) 218.71,33.96 218.71,33.34 v2(218.71,33.33) 218.75,33.33 219.16,32.93 219.16,32.47 219.59,32.04 RH453.1
WAKE_PCH#: length 5
  BOTTOM w0.089: 217.28,33.79 217.22,33.73 216.71,33.73 216.31,34.12 216.12,34.12 UH1.BD11
  BOTTOM w0.107: RH545.1 219.59,34.35 219.14,34.8 218.29,34.8 v2(217.81,34.32) 217.28,33.79
WL_OFF#: length 150.9
  TOP w0.089: v1(213.1,16.45) 212.42,15.77 RH520.2
  TOP w0.107: v1(313.19,38.45) 312.84,38.81 RN15.2
  IN4 w0.089: 213.31,16.66 v1(213.1,16.45)
  IN4 w0.097: 213.31,16.66 213.45,16.8 218.39,16.8 218.96,16.22 226.8,16.22 227.54,16.96 236.07,16.96 237.69,15.34 240.06,15.34 240.37,15.03 241.88,15.03 243.68,13.24 246.09,13.24 246.62,12.71 250.46,12.71 250.63,12.54 264.61,12.54 267.88,15.81 292.08,15.81 293.12,14.77 294.2,14.77 295.91,13.06 301.88,13.06 302.61,13.79 309.85,13.79 310.48,13.15 316.61,13.15 v1(318.48,11.28)
  BOTTOM w0.089: v1(213.1,16.45) 212.59,16.96 212.59,17.35 212.64,17.4 212.64,17.94 212.49,18.1 UH1.AU44
  BOTTOM w0.107: v1(313.19,38.45) 314.96,36.68 319.15,36.68 319.19,36.73 320.1,36.73 321.32,35.51 v2(321.32,31.45) 321.32,27.72 319.5,25.9 319.5,17.39 318.48,16.37 v1(318.48,11.28)
WL_OFF#_R: length 6.2
  TOP w0.107: RN15.1 313.43,39.29 RN5.2 314.33,39.45 v2(314.33,40.7) CN9.1 314.03,41.87 v1(313.64,42.26)
  BOTTOM w0.107: v2(313.64,42.83) v1(313.64,42.26) 313.7,42.26 314.07,41.89 JWLAN.48
WOOFER_SEL: length 67.7
  TOP w0.107: JIO.21 325.14,19.85 324.56,19.28 v1(324.56,19.21) ; UE10.7 311.58,49.58 v1(312,50)
  IN3 w0.091: v1(312,50) 312.92,50.92 314.3,50.92 317.87,47.36 330.25,47.36 330.84,46.77 336.05,46.77 336.57,46.25 336.57,21.75 334.03,19.21 v1(324.56,19.21)
XCLK_BIASREF: length 2.1
  TOP w0.107: RH71.2 196.57,40.16 196.56,40.16 v1(196.15,40.16)
  BOTTOM w0.107: UH1.E1 196.61,39.7 v1(196.15,40.16)
XDP_BPM#0: length 5.9
  BOTTOM w0.076: CPU1.BR27 132.68,112.31 132.11,112.31 132.02,112.39 131.63,112.39 131.33,112.09 131.33,111.54 130.67,110.88 129.44,110.88
  BOTTOM w0.107: 129.44,110.88 129.27,110.88 128.79,111.36 T112.1
XDP_BPM#1: length 3.2
  BOTTOM w0.076: 130.23,111.3 130.85,111.3 131.16,111.61 131.16,112.16 131.56,112.56 132.28,112.56 CPU1.BT27
  BOTTOM w0.089: 130.23,111.3 T113.1
XDP_HOOK0: length 11.5
  TOP w0.107: RC355.1 126.12,159.67 125.72,160.07 125,160.07 124.2,160.88 122.97,160.88 122.56,161.28 118.5,161.28 117.81,160.59 117.81,159.48 118.28,159 JPCMC.27
XDP_ITP_PMODE: length 220.3
  TOP w0.107: JPCMC.26 117.4,159.36 v1(117.4,160.17) 117.4,160.51 118.4,161.52 122.66,161.52 123.07,161.11 124.3,161.11 125.04,160.37 127.63,160.37 RC353.2
  IN1 w0.097: v1(214.64,41.9) 214.64,41.9 214.64,45.12 212.41,47.35 212.41,50.34 v1(210.26,52.48)
  IN2 w0.091: v1(210.26,52.48) 209.17,52.48 207.54,54.1 201.56,54.1 199.39,51.93 196.32,51.93 187.32,60.94 186.35,60.94 180,67.29 139.33,67.29 126.98,79.64 126.98,93.94 126.01,94.91 126.01,99.92 129.51,103.42 129.51,112.06 127.01,114.56 127.01,122.28 120,129.29 120,131.58 v1(120.4,131.99)
  BOTTOM w0.089: v1(214.64,41.9) 214.64,41.84 213.27,40.47 212.66,40.47 212.16,39.97 212.16,39.28 212.29,39.14 UH1.AT2
  BOTTOM w0.107: v1(117.4,160.17) 116,160.17 114.51,158.67 114.51,153.62 115.99,152.14 115.99,132.89 117.31,131.58 120,131.58 v1(120.4,131.99)
XDP_PRDY#: length 290
  TOP w0.107: JPCMC.34 121.27,159.65 v1(121.27,159.98)
  IN1 w0.097: v1(121.27,159.98) 121.74,160.45 123.69,160.45 125.16,158.98 125.16,153.56 123.34,151.75 123.34,150.86 123.34,150.68 122.4,149.73 121.89,149.73 121.48,149.31 121.09,149.31 118.54,146.77 118.54,131.92 120.93,129.53 126.25,129.53 129.8,125.98 129.8,124.65 131.42,123.03 131.42,119.68 132.34,118.76 132.34,115.41 133.33,114.43 v1(133.33,113) ; v1(209.53,53.3) 209.53,52.46 212.19,49.8 212.19,47.25 214.41,45.03 214.41,42.24 214.28,42.11 214.28,41.99 v1(213.94,41.65)
  IN3 w0.091: v1(115.58,36.61) 114.82,37.37 114.36,37.37 110.88,40.85 109.63,40.85 108.73,41.76 108.73,57.07 108.97,57.3 108.97,61.34 108.73,61.58 108.73,64.72 122.74,78.73 122.74,82.62 126.55,86.43 126.55,96.92 128.96,99.33 128.96,99.99 129.53,100.56 129.53,102.2 132.72,105.39 132.72,112.39 v1(133.33,113)
  IN4 w0.097: v1(209.53,53.3) 209.53,53.98 209.33,54.17 207.78,54.17 205.88,56.07 201.96,56.07 199.38,58.66 196.46,58.66 192.87,55.08 188.63,55.08 186.4,52.86 186.4,42.54 179.5,35.63 166.35,35.63 161.59,30.87 135.77,30.87 130.03,36.61 v1(115.58,36.61)
  BOTTOM w0.076: CPU1.BP27 133.66,112.67 v1(133.33,113)
  BOTTOM w0.089: UH1.AT4 211.91,38.23 212.02,38.34 212.02,39.17 211.97,39.21 211.97,40.08
  BOTTOM w0.102: 211.97,40.08 212.59,40.7
  BOTTOM w0.127: 212.59,40.7 213.54,41.65 v1(213.94,41.65)
XDP_PREQ#: length 296.6
  TOP w0.107: JPCMC.33 120.68,159.4 v1(120.68,160.03)
  IN1 w0.097: v1(208.46,54.58) 209.15,54.58 212.63,51.1 212.63,47.44 214.86,45.21 214.86,42.89 215.27,42.48 v1(215.27,41.95) ; v1(131.71,114.21) 132.15,114.65 132.15,118.68 131.07,119.77 131.07,122.14 130.58,122.64 130.58,123.56 129.58,124.56 129.58,125.89 126.16,129.31 120.84,129.31 118.32,131.83 118.32,146.86 121,149.54 121.38,149.54 121.8,149.96 122.3,149.96 123.12,150.77 123.12,151.84 124.93,153.65 124.93,158.51 123.94,159.51 121.18,159.51 120.68,160 v1(120.68,160.03)
  IN3 w0.091: v1(114.82,36.61) 110.79,40.64 109.54,40.64 108.52,41.66 108.52,57.16 108.75,57.39 108.75,61.25 108.52,61.49 108.52,64.81 122.52,78.82 122.52,82.71 126.33,86.52 126.33,97.86 129.31,100.84 129.31,102.23 132.54,105.46 132.54,113.38 v1(131.71,114.21)
  IN4 w0.097: v1(208.46,54.58) 207.7,54.58 205.98,56.3 202.06,56.3 199.47,58.88 196.36,58.88 192.78,55.3 188.53,55.3 186.18,52.95 186.18,42.63 179.41,35.85 166.26,35.85 161.5,31.09 135.87,31.09 130.13,36.83 122.69,36.83 122.45,37.07 115.28,37.07 v1(114.82,36.61)
  BOTTOM w0.076: CPU1.BL30 135.23,114.5 132.01,114.5 v1(131.71,114.21) 131.04,114.88 RH156.2
  BOTTOM w0.089: v1(215.27,41.95) 215.27,41.75 213.25,39.73 213.11,39.73 212.53,39.14 212.53,38.71 212.29,38.48 UH1.AT3
XDP_SPI_IO2: length 15.1
  TOP w0.107: RC354.1 128.39,161.09 127.66,161.83 v2(126.56,161.83) 123.01,161.83 122.86,161.98 118.21,161.98 116.57,160.34 116.57,158.93 JPCMC.24
XDP_SPI_SI: length 237.6
  TOP w0.107: RC9.2 125.64,161.34 123.16,161.34 122.76,161.75 118.3,161.75 116.98,160.42 v1(116.98,159.61) 116.98,159.16 117.66,158.48 JPCMC.25
  IN2 w0.091: v1(119.77,131.99) 119.77,129.19 126.79,122.17 126.79,114.47 129.29,111.97 129.29,103.51 125.79,100.01 125.79,94.82 126.76,93.85 126.76,79.55 139.24,67.07 179.9,67.07 186.25,60.72 187.23,60.72 196.23,51.71 199.48,51.71 201.65,53.88 206.4,53.88 209.82,50.47 209.82,48.48 209.97,48.33 v1(210.38,48.33)
  IN3 w0.089: 215.9,42.08 215.9,40.7 216.42,40.18 219.18,40.18
  IN3 w0.091: 219.18,40.18 220.84,40.18 221.48,39.53 v1(221.48,39.32) ; 215.9,42.08 215.9,42.68 210.38,48.2 v1(210.38,48.33)
  BOTTOM w0.107: v1(221.48,39.32) 222.73,39.32 223.34,38.72 v2(223.34,31.9) 224.64,30.59 224.64,23.39 224.53,23.28 RH1.1 ; v1(119.77,131.99) 117.23,131.99 116.23,132.99 116.23,152.23 114.74,153.72 114.74,158.58 115.78,159.61 v1(116.98,159.61)
XDP_TCK: length 218.6
  TOP w0.107: v1(120.4,131.22) v4(119.74,131.22) ; JPCMC.31 119.79,160.15 120.46,160.81 122.37,160.81 v1(123.17,160.02) 123.66,159.52 124.96,159.52 126.14,158.34 RC348.1
  IN2 w0.091: v1(204.49,54.53) 203.92,55.1 202.25,55.1 199.3,52.15 196.41,52.15 187.41,61.15 186.44,61.15 180.09,67.5 139.42,67.5 127.19,79.73 127.19,94.03 126.23,95 126.23,99.83 129.73,103.33 129.73,112.15 127.23,114.65 127.23,122.37 120.4,129.2 v1(120.4,131.22)
  IN3 w0.091: v1(204.49,54.53) 204.49,53.94 208.51,49.92 208.51,45.52 v1(211.78,42.26)
  BOTTOM w0.089: UH1.AN3 210.6,38.74 210.79,38.93 210.79,40.69 211.08,40.98 211.08,41.56 211.6,42.08
  BOTTOM w0.107: v1(120.4,131.22) 117.33,131.22 115.76,132.79 115.76,152.04 114.28,153.52 114.28,158.77 116.58,161.08 122.13,161.08 123.17,160.04 v1(123.17,160.02) ; 211.6,42.08 v1(211.78,42.26)
XDP_TDI: length 218.3
  TOP w0.107: JPCMC.29 119,159.55 118.75,159.8 v1(118.75,160.24) ; v1(131.71,114.78) 130.95,114.78 130.06,113.89 v4(130.06,112.3) v1(130.7,111.65)
  IN2 w0.091: v1(130.7,111.65) 130.7,110.89 132.11,109.48 132.11,105.41 130.53,103.83 130.53,102.92 127.08,99.47 127.08,95.35 128.05,94.38 128.05,80.08 138.57,69.56 181.3,69.56 191.98,58.88 198.65,58.88 201.14,56.39 204.58,56.39 205.34,55.63 v1(205.34,54.52)
  IN3 w0.091: v1(205.34,54.52) 208.95,50.91 208.95,46.03 209.99,44.99 211.95,44.99 v1(212.46,44.48)
  IN4 w0.097: v1(118.75,160.24) 118.43,160.57 117.23,160.57 115.05,158.39 115.05,155.44 115.65,154.84 117.36,154.84 118.83,153.37 118.83,153.19 118.83,152.83 119.58,152.08 119.58,149.26 118.72,148.39 118.72,148.08 118.18,147.55 118.18,130.91 126.72,122.37 126.72,117.6 127.31,117.01 127.31,114.09 129.75,111.65 v1(130.7,111.65)
  BOTTOM w0.089: UH1.AP2 211.16,39.05 211.4,39.28 211.4,40.27 212,40.87 212,41.1 212.23,41.33 212.23,42.08 ; v1(131.71,114.78) 131.81,114.68 135.15,114.68 135.33,114.85 135.33,115.86 135.73,116.26 CPU1.BL32
  BOTTOM w0.107: RH495.2 129.23,111.72 130.64,111.72 v1(130.7,111.65) ; 212.23,42.08 212.23,43.09
  BOTTOM w0.127: 212.23,43.09 212.23,44.02 212.46,44.26 v1(212.46,44.48)
