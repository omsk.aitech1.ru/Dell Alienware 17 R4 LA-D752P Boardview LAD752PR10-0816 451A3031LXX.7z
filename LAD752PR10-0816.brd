# Allegro board LAD752PR10-0816.brd (continued)
## Nets (continued)
GND: C2.2 C3.2 C4.2 C6.2 C7.2 C10.2 C11.2 C29.2 C256.2 C257.2 C258.2 C260.2 C261.2 C262.2 C263.2 C264.2 C265.2 C266.2 C267.2 C268.2 C269.2 C270.2 C617.2 C618.2 C620.2 C621.2 C622.2 C623.2 C624.2 C625.2 C627.2 C628.2 C629.2 C630.2 C631.2 C632.2 C633.2 C634.2 C635.2 C636.2 C637.2 C638.2 C639.2 C640.2 C1240.2 C1241.2 C1242.2 C2498.2 C2499.2 C2506.2 C2507.2 C2508.2 C2509.2 C2512.2 C2513.2 C2514.2 C2515.2 C2516.2 C2518.2 C2519.2 C2520.2 C2521.2 C2522.2 C2523.2 C2524.2 C2525.2 CA1.2 CA2.2 CA3.2 CA4.2 CA5.2 CA6.2 CA7.2 CA8.2 CA9.2 CA10.2 CA11.2 CA12.2 CA13.2 CA18.2 CA23.2 CA34.2 CA35.2 CA36.2 CA37.2 CA38.2 CA39.2 CA40.2 CA41.2 CA52.2 CA53.2 CA54.2 CA55.2 CA56.2 CA57.2 CA58.2 CA59.2 CA60.2 CA61.2 CA62.2 CA63.2 CA64.2 CA65.2 CA66.1 CA71.1 CA74.2 CA77.2 CA78.2 CA79.2 CA80.2 CA81.2 CA82.2 CA83.2 CA84.2 CA85.2 CA254.2 CA255.2 CA256.2 CA257.2 CD1.2 CD2.2 CD3.2 CD4.2 CD5.2 CD6.2 CD7.2 CD8.2 CD9.2 CD10.2 CD11.2 CD12.2 CD13.2 CD14.2 CD15.2 CD16.2 CD17.2 CD18.2 CD19.2 CD20.2 CD21.2 CD22.2 CD23.2 CD24.2 CD25.2 CD26.2 CD27.2 CD28.2 CD29.2 CD30.2 CD31.2 CD32.2 CD33.2 CD34.2 CD35.2 CD69.2 CD70.2 CD71.2 CD72.2 CD73.2 CD74.2 CD75.2 CD76.2 CD77.2 CD78.2 CD79.2 CD80.2 CD81.2 CD82.2 CD83.2 CD84.2 CD85.2 CD86.2 CD87.2 CD88.2 CD89.2 CD90.2 CD91.2 CD92.2 CE1.2 CE3.2 CE4.1 CE6.2 CE7.2 CE9.2 CE13.2 CE14.2 CE15.2 CE16.2 CE17.2 CE18.2 CE19.2 CE20.2 CE22.2 CE24.2 CE25.2 CE27.2 CE28.2 CE29.2 CE30.2 CE31.1 CE32.1 CE34.2 CE36.2 CE38.2 CE40.1 CE41.2 CE42.2 CE43.2 CE44.2 CE45.2 CE46.2 CE51.2 CE55.1 CE56.2 CE57.2 CE58.2 CE59.2 CE60.2 CE61.2 CE62.2 CE63.1 CE64.2 CE65.2 CE79.2 CE80.2 CE81.2 CE82.2 CE84.2 CE85.2 CE86.2 CE87.2 CE168.2 CF4.2 CF5.2 CG17.2 CG18.2 CG19.2 CG20.2 CG21.2 CG22.2 CG23.2 CG24.2 CG25.2 CG26.2 CG27.2 CG28.2 CG29.2 CG30.2 CG31.2 CG32.2 CG33.2 CG34.1 CG35.2 CG41.2 CG42.2 CG43.2 CG44.2 CG45.2 CG46.2 CG47.2 CG48.2 CG49.2 CG50.2 CG51.2 CG52.2 CG53.2 CG54.2 CG55.2 CG56.2 CG57.2 CG58.2 CG59.2 CG60.2 CG61.2 CG62.2 CG63.2 CG64.2 CG65.2 CG66.2 CG67.2 CG68.2 CG69.2 CG70.2 CG71.2 CG72.2 CG73.2 CG74.2 CG75.2 CG76.2 CG77.2 CG78.2 CG79.2 CG80.2 CG81.2 CG82.2 CG83.2 CG84.2 CG85.2 CG86.2 CG87.2 CG88.2 CG89.2 CG90.2 CG91.2 CG92.2 CG93.2 CG94.2 CG95.2 CG96.2 CG97.2 CG98.2 CG99.2 CG100.2 CG101.2 CG102.2 CG103.2 CG104.2 CG105.2 CG106.2 CG107.2 CG108.2 CG109.2 CG110.2 CG111.2 CG112.2 CG113.2 CG114.2 CG115.2 CG116.2 CG117.2 CG118.2 CG119.2 CG120.2 CG121.2 CG122.2 CG123.2 CG124.2 CG125.2 CG126.2 CG127.2 CG128.2 CG129.2 CG130.2 CG131.2 CG132.2 CG133.2 CG134.2 CG135.2 CG136.2 CG137.2 CG140.2 CG141.2 CG144.2 CG145.2 CG146.2 CG147.2 CG148.2 CG149.2 CG150.2 CG151.2 CG152.2 CG153.2 CG154.2 CG155.2 CG156.2 CG157.2 CG158.2 CG159.2 CG160.2 CG161.2 CG162.2 CG163.2 CG164.2 CG165.2 CG166.2 CG167.2 CG168.2 CG169.2 CG170.2 CG171.2 CG172.2 CG173.2 CG174.2 CG175.2 CG176.2 CG177.2 CG178.2 CG179.2 CG182.2 CG183.2 CG186.2 CG187.2 CG188.2 CG189.2 CG190.2 CG191.2 CG192.2 CG193.2 CG194.2 CG195.2 CG196.2 CG197.2 CG198.2 CG199.2 CG200.2 CG201.2 CG202.2 CG203.2 CG204.2 CG205.2 CG206.2 CG207.2 CG208.2 CG209.2 CG210.2 CG211.2 CG212.2 CG213.2 CG214.2 CG215.2 CG216.2 CG217.2 CG218.2 CG219.2 CG220.2 CG221.2 CG224.2 CG225.2 CG228.2 CG229.2 CG230.2 CG231.2 CG232.2 CG233.2 CG234.2 CG235.2 CG236.2 CG237.2 CG238.2 CG239.2 CG240.2 CG241.2 CG242.2 CG243.2 CG244.2 CG245.2 CG246.2 CG247.2 CG248.2 CG249.2 CG250.2 CG251.2 CG252.2 CG253.2 CG254.2 CG255.2 CG256.2 CG257.2 CG258.2 CG259.2 CG260.2 CG261.2 CG262.2 CG263.2 CG266.2 CG267.2 CG270.2 CG271.2 CG272.2 CG273.2 CG274.2 CG275.2 CG276.2 CG277.2 CG278.2 CG279.2 CG280.2 CG281.2 CG282.2 CG283.2 CG284.2 CG285.2 CG286.2 CG287.2 CG288.2 CG289.2 CG290.2 CG291.2 CG292.2 CG293.2 CG294.2 CG295.2 CG296.2 CG297.2 CG298.2 CG299.2 CG300.2 CG301.2 CG302.2 CG303.2 CG304.2 CG305.2 CG306.2 CG3000.2 CH3.2 CH4.2 CH45.2 CH46.2 CH47.2 CH48.2 CH49.2 CH50.2 CH52.2 CH53.2 CH70.2 CH80.2 CH82.2 CH102.2 CH103.2 CH104.2 CH105.2 CH106.2 CH107.2 CH108.2 CH109.2 CH110.2 CH118.2 CH119.2 CH120.2 CH121.2 CH122.2 CH123.2 CH124.2 CH125.2 CH126.2 CH127.2 CH128.2 CH129.2 CH130.2 CH131.2 CH132.2 CH173.2 CH174.2 CH175.2 CH176.2 CH177.2 CH178.2 CH179.2 CH180.2 CH181.2 CH182.2 CH183.2 CH184.2 CH185.2 CH186.2 CH187.2 CH188.2 CH189.2 CH190.2 CH191.2 CH192.2 CH193.2 CH194.2 CH195.2 CH197.2 CH200.2 CH201.2 CL5.2 CL6.2 CL7.2 CL8.1 CL9.1 CL11.2 CL12.2 CL13.2 CL14.2 CL15.2 CL16.2 CL17.2 CL18.2 CL19.2 CL20.2 CL21.2 CL22.2 CL23.2 CL24.2 CL25.2 CL27.2 CL28.2 CL29.2 CL30.1 CL31.2 CL32.1 CL33.2 CL34.1 CL35.2 CL36.1 CL37.2 CL38.1 CL39.2 CL40.2 CL41.2 CL42.2 CL43.2 CL44.2 CLRP1.2 CM9.2 CM10.2 CM11.2 CM12.2 CM13.2 CM14.2 CM15.2 CM16.2 CM17.2 CM18.2 CM19.2 CM20.2 CM21.2 CM23.2 CM29.2 CM30.2 CM31.2 CM32.2 CM33.2 CM34.2 CM35.2 CM36.2 CM70.2 CN9.2 CN25.2 CPU1.A3 CPU1.A4 CPU1.A6 CPU1.A9 CPU1.A10 CPU1.A12 CPU1.A14 CPU1.A16 CPU1.A18 CPU1.A20 CPU1.A22 CPU1.A24 CPU1.A26 CPU1.A28 CPU1.A30 CPU1.A34 CPU1.A36 CPU1.A37 CPU1.AA12 CPU1.AA29 CPU1.AA30 CPU1.AB6 CPU1.AB33 CPU1.AB34 CPU1.AC1 CPU1.AC2 CPU1.AC3 CPU1.AC4 CPU1.AC5 CPU1.AC6 CPU1.AC12 CPU1.AC37 CPU1.AC38 CPU1.AD6 CPU1.AD7 CPU1.AD8 CPU1.AD9 CPU1.AD10 CPU1.AD11 CPU1.AD12 CPU1.AD29 CPU1.AD30 CPU1.AE6 CPU1.AE33 CPU1.AE34 CPU1.AF1 CPU1.AF2 CPU1.AF3 CPU1.AF4 CPU1.AF12 CPU1.AF13 CPU1.AF14 CPU1.AG6 CPU1.AG7 CPU1.AG8 CPU1.AG10 CPU1.AG11 CPU1.AG29 CPU1.AG30 CPU1.AH6 CPU1.AH12 CPU1.AH33 CPU1.AH34 CPU1.AJ1 CPU1.AJ2 CPU1.AJ3 CPU1.AJ4 CPU1.AJ5 CPU1.AJ6 CPU1.AJ37 CPU1.AJ38 CPU1.AK4 CPU1.AK29 CPU1.AK30 CPU1.AL4 CPU1.AL7 CPU1.AL8 CPU1.AL9 CPU1.AL10 CPU1.AL12 CPU1.AL14 CPU1.AL33 CPU1.AL34 CPU1.AM1 CPU1.AM2 CPU1.AM3 CPU1.AM4 CPU1.AM5 CPU1.AM12 CPU1.AM37 CPU1.AM38 CPU1.AN5 CPU1.AN6 CPU1.AN12 CPU1.AN29 CPU1.AN30 CPU1.AP8 CPU1.AP9 CPU1.AP10 CPU1.AP11 CPU1.AP12 CPU1.AP33 CPU1.AP34 CPU1.AR1 CPU1.AR2 CPU1.AR3 CPU1.AR4 CPU1.AR5 CPU1.AR13 CPU1.AR14 CPU1.AR37 CPU1.AR38 CPU1.AT6 CPU1.AT29 CPU1.AT30 CPU1.AU6 CPU1.AU7 CPU1.AU8 CPU1.AU9 CPU1.AU10 CPU1.AU11 CPU1.AU12 CPU1.AU33 CPU1.AU34 CPU1.AV37 CPU1.AV38 CPU1.AW1 CPU1.AW2 CPU1.AW3 CPU1.AW4 CPU1.AW5 CPU1.AW12 CPU1.AW29 CPU1.AW30 CPU1.AY12 CPU1.AY14 CPU1.AY33 CPU1.AY34 CPU1.B3 CPU1.B9 CPU1.B37 CPU1.BA6 CPU1.BA7 CPU1.BA8 CPU1.BA9 CPU1.BA10 CPU1.BA11 CPU1.BA12 CPU1.BA37 CPU1.BA38 CPU1.BB1 CPU1.BB2 CPU1.BB3 CPU1.BB4 CPU1.BB5 CPU1.BB6 CPU1.BB12 CPU1.BB29 CPU1.BB30 CPU1.BC6 CPU1.BC12 CPU1.BC13 CPU1.BC14 CPU1.BC33 CPU1.BC34 CPU1.BD6 CPU1.BD7 CPU1.BD8 CPU1.BD9 CPU1.BD10 CPU1.BD11 CPU1.BD12 CPU1.BD37 CPU1.BD38 CPU1.BE1 CPU1.BE2 CPU1.BE3 CPU1.BE4 CPU1.BE5 CPU1.BE6 CPU1.BE29 CPU1.BE30 CPU1.BF6 CPU1.BF12 CPU1.BF33 CPU1.BF34 CPU1.BG6 CPU1.BG12 CPU1.BG13 CPU1.BG14 CPU1.BG37 CPU1.BG38 CPU1.BH1 CPU1.BH2 CPU1.BH3 CPU1.BH4 CPU1.BH5 CPU1.BH6 CPU1.BH7 CPU1.BH8 CPU1.BH9 CPU1.BH10 CPU1.BH11 CPU1.BH12 CPU1.BH14 CPU1.BJ12 CPU1.BJ15 CPU1.BJ18 CPU1.BJ22 CPU1.BJ25 CPU1.BJ29 CPU1.BJ30 CPU1.BJ31 CPU1.BJ32 CPU1.BK6 CPU1.BK13 CPU1.BK14 CPU1.BK15 CPU1.BK18 CPU1.BK22 CPU1.BK25 CPU1.BK29 CPU1.BL6 CPU1.BL13 CPU1.BL29 CPU1.BL35 CPU1.BL38 CPU1.BM2 CPU1.BM3 CPU1.BM5 CPU1.BM6 CPU1.BM7 CPU1.BM8 CPU1.BM9 CPU1.BM11 CPU1.BM12 CPU1.BM13 CPU1.BM18 CPU1.BM21 CPU1.BM23 CPU1.BM25 CPU1.BM26 CPU1.BM27 CPU1.BM28 CPU1.BM29 CPU1.BM35 CPU1.BM38 CPU1.BN2 CPU1.BN4 CPU1.BN7 CPU1.BN9 CPU1.BN12 CPU1.BN14 CPU1.BN18 CPU1.BN19 CPU1.BN20 CPU1.BN21 CPU1.BN24 CPU1.BN29 CPU1.BN30 CPU1.BN31 CPU1.BN34 CPU1.BP7 CPU1.BP12 CPU1.BP14 CPU1.BP18 CPU1.BP21 CPU1.BP24 CPU1.BP26 CPU1.BP29 CPU1.BP33 CPU1.BP34 CPU1.BR7 CPU1.BR12 CPU1.BR14 CPU1.BR18 CPU1.BR21 CPU1.BR24 CPU1.BR26 CPU1.BR29 CPU1.BR34 CPU1.BR36 CPU1.BR38 CPU1.BT3 CPU1.BT4 CPU1.BT5 CPU1.BT9 CPU1.BT12 CPU1.BT14 CPU1.BT18 CPU1.BT21 CPU1.BT24 CPU1.BT26 CPU1.BT32 CPU1.BT35 CPU1.BT36 CPU1.C2 CPU1.C5 CPU1.C8 CPU1.C9 CPU1.C11 CPU1.C13 CPU1.C15 CPU1.C17 CPU1.C19 CPU1.C21 CPU1.C23 CPU1.C25 CPU1.C27 CPU1.C29 CPU1.C31 CPU1.C37 CPU1.D3 CPU1.D6 CPU1.D9 CPU1.D10 CPU1.D12 CPU1.D14 CPU1.D16 CPU1.D18 CPU1.D20 CPU1.D22 CPU1.D24 CPU1.D26 CPU1.D28 CPU1.D30 CPU1.D33 CPU1.D38 CPU1.E4 CPU1.E9 CPU1.E34 CPU1.E35 CPU1.E38 CPU1.F2 CPU1.F3 CPU1.F4 CPU1.F5 CPU1.F8 CPU1.F9 CPU1.F11 CPU1.F13 CPU1.F15 CPU1.F17 CPU1.F19 CPU1.F21 CPU1.F23 CPU1.F25 CPU1.F27 CPU1.F29 CPU1.F31 CPU1.F36 CPU1.G4 CPU1.G5 CPU1.G6 CPU1.G8 CPU1.G9 CPU1.G10 CPU1.G12 CPU1.G14 CPU1.G16 CPU1.G18 CPU1.G20 CPU1.G22 CPU1.G23 CPU1.G24 CPU1.G26 CPU1.G28 CPU1.H11 CPU1.H12 CPU1.H18 CPU1.H22 CPU1.H25 CPU1.H32 CPU1.H35 CPU1.J4 CPU1.J7 CPU1.J10 CPU1.J18 CPU1.J22 CPU1.J25 CPU1.J32 CPU1.J33 CPU1.J36 CPU1.K1 CPU1.K2 CPU1.K3 CPU1.K4 CPU1.K5 CPU1.K7 CPU1.K8 CPU1.K9 CPU1.K10 CPU1.K11 CPU1.K38 CPU1.L29 CPU1.L30 CPU1.L33 CPU1.L34 CPU1.M6 CPU1.M12 CPU1.M13 CPU1.M14 CPU1.N1 CPU1.N2 CPU1.N3 CPU1.N4 CPU1.N5 CPU1.N6 CPU1.N7 CPU1.N8 CPU1.N9 CPU1.N10 CPU1.N11 CPU1.N12 CPU1.N33 CPU1.N34 CPU1.P6 CPU1.P12 CPU1.P37 CPU1.P38 CPU1.R12 CPU1.R29 CPU1.R30 CPU1.T1 CPU1.T2 CPU1.T3 CPU1.T4 CPU1.T5 CPU1.T7 CPU1.T8 CPU1.T9 CPU1.T10 CPU1.T11 CPU1.T12 CPU1.T13 CPU1.T14 CPU1.T33 CPU1.T34 CPU1.U6 CPU1.U37 CPU1.U38 CPU1.V6 CPU1.V12 CPU1.V29 CPU1.V30 CPU1.W1 CPU1.W2 CPU1.W3 CPU1.W4 CPU1.W5 CPU1.W12 CPU1.W33 CPU1.W34 CPU1.Y7 CPU1.Y8 CPU1.Y9 CPU1.Y10 CPU1.Y11 CPU1.Y13 CPU1.Y14 CPU1.Y37 CPU1.Y38 CS1.2 CS2.2 CS5.2 CS6.2 CS7.2 CS16.2 CT37.2 CT38.2 CT45.2 CT46.2 CT47.2 CT48.2 CT49.2 CT50.2 CT51.2 CT52.2 CT53.2 CT54.2 CT55.2 CT56.2 CT57.2 CT58.2 CT59.2 CT60.2 CT61.2 CT62.2 CT63.2 CT64.2 CT65.2 CT66.2 CT67.2 CT68.2 CT69.2 CT70.2 CT71.2 CT72.2 CT73.2 CT74.2 CT75.2 CT77.2 CT78.2 CT79.2 CT80.2 CT81.2 CT82.2 CT83.2 CT84.2 CT85.2 CT86.2 CT88.2 CT90.2 CT91.2 CT92.2 CT93.2 CT94.1 CT95.1 CT96.2 CT97.2 CT98.2 CT99.2 CT100.2 CT101.2 CT102.2 CT103.2 CT104.2 CT106.2 CT112.2 CT113.2 CU2.2 CU3.2 CU6.2 CU7.2 CU10.2 CU11.2 CU16.2 CU17.2 CU18.2 CU19.2 CU20.2 CU21.2 CU26.2 CU28.2 CU29.2 CU32.2 CU33.2 CU34.2 CU35.2 CU37.2 CU40.2 CU42.2 CU44.2 CU45.2 CU46.2 CU47.2 CU48.2 CV5.2 CV9.2 CV10.2 CV14.2 CV17.2 CV18.2 CV19.2 CV20.2 CV21.2 CV22.2 CV23.2 CV34.2 CV35.2 CV67.2 CV372.2 CV373.2 CV374.2 CV375.2 CV436.2 CV437.2 CV438.2 CV439.2 CV440.2 CV441.2 CV442.2 CV443.2 CV444.2 CV445.2 CV446.2 CV447.2 CV484.2 CV651.2 CV1056.2 CV1068.2 CV1069.2 CV1312.2 CV1313.2 CV1314.2 CX1.2 CX2.2 DA4.1 DA5.1 DA6.1 DA7.1 DA8.1 DT1.2 DT2.2 DT3.2 DT4.2 DT5.2 DT6.2 DT7.2 DT8.2 DT9.2 DT10.3 DT11.2 DT12.2 DT13.2 DT14.2 DT15.1 DU1.1 DU2.3 DU11.1 DU12.3 DU13.3 DU20.1 DU21.1 DV2.1 DV4.1 DV14.1 H1.1(TP-1) H2.1(TP-1) H3.1(TP-1) H4.1(TP-1) H5.1(TP-1) H6.1(TP-1) H7.1(TP-1) H8.1(TP-1) H9.1(TP-1) H10.1(TP-1) H11.1(TP-1) H12.1(TP-1) H13.1(TP-1) H14.1(TP-1) H15.1(TP-1) H16.1(TP-1) H17.1(TP-1) H18.1(TP-1) H19.1(TP-1) H20.1(TP-1) H21.1(TP-1) H22.1(TP-1) H23.1(TP-1) JACK1.7 JACK2.7 JCDRA.5 JCDRA.8 JCDRA.11 JCDRA.14 JCDRA.17 JCDRA.20 JCDRA.23 JCDRA.29 JCDRA.32 JCDRA.35 JCDRA.38 JCDRA.41 JCDRA.44 JCDRA.47 JCDRA.48 JCDRA.49 JCDRA.50 JDIMM1.1 JDIMM1.2 JDIMM1.5 JDIMM1.6 JDIMM1.9 JDIMM1.10 JDIMM1.14 JDIMM1.15 JDIMM1.18 JDIMM1.19 JDIMM1.22 JDIMM1.23 JDIMM1.26 JDIMM1.27 JDIMM1.30 JDIMM1.31 JDIMM1.35 JDIMM1.36 JDIMM1.39 JDIMM1.40 JDIMM1.43 JDIMM1.44 JDIMM1.47 JDIMM1.48 JDIMM1.51 JDIMM1.52 JDIMM1.56 JDIMM1.57 JDIMM1.60 JDIMM1.61 JDIMM1.64 JDIMM1.65 JDIMM1.68 JDIMM1.69 JDIMM1.72 JDIMM1.73 JDIMM1.77 JDIMM1.78 JDIMM1.81 JDIMM1.82 JDIMM1.85 JDIMM1.86 JDIMM1.89 JDIMM1.90 JDIMM1.93 JDIMM1.94 JDIMM1.98 JDIMM1.99 JDIMM1.102 JDIMM1.103 JDIMM1.106 JDIMM1.107 JDIMM1.167 JDIMM1.168 JDIMM1.171 JDIMM1.172 JDIMM1.175 JDIMM1.176 JDIMM1.180 JDIMM1.181 JDIMM1.184 JDIMM1.185 JDIMM1.188 JDIMM1.189 JDIMM1.192 JDIMM1.193 JDIMM1.196 JDIMM1.197 JDIMM1.201 JDIMM1.202 JDIMM1.205 JDIMM1.206 JDIMM1.209 JDIMM1.210 JDIMM1.213 JDIMM1.214 JDIMM1.217 JDIMM1.218 JDIMM1.222 JDIMM1.223 JDIMM1.226 JDIMM1.227 JDIMM1.230 JDIMM1.231 JDIMM1.234 JDIMM1.235 JDIMM1.238 JDIMM1.239 JDIMM1.243 JDIMM1.244 JDIMM1.247 JDIMM1.248 JDIMM1.251 JDIMM1.252 JDIMM1.261 JDIMM1.262 JDIMM2.1 JDIMM2.2 JDIMM2.5 JDIMM2.6 JDIMM2.9 JDIMM2.10 JDIMM2.14 JDIMM2.15 JDIMM2.18 JDIMM2.19 JDIMM2.22 JDIMM2.23 JDIMM2.26 JDIMM2.27 JDIMM2.30 JDIMM2.31 JDIMM2.35 JDIMM2.36 JDIMM2.39 JDIMM2.40 JDIMM2.43 JDIMM2.44 JDIMM2.47 JDIMM2.48 JDIMM2.51 JDIMM2.52 JDIMM2.56 JDIMM2.57 JDIMM2.60 JDIMM2.61 JDIMM2.64 JDIMM2.65 JDIMM2.68 JDIMM2.69 JDIMM2.72 JDIMM2.73 JDIMM2.77 JDIMM2.78 JDIMM2.81 JDIMM2.82 JDIMM2.85 JDIMM2.86 JDIMM2.89 JDIMM2.90 JDIMM2.93 JDIMM2.94 JDIMM2.98 JDIMM2.99 JDIMM2.102 JDIMM2.103 JDIMM2.106 JDIMM2.107 JDIMM2.167 JDIMM2.168 JDIMM2.171 JDIMM2.172 JDIMM2.175 JDIMM2.176 JDIMM2.180 JDIMM2.181 JDIMM2.184 JDIMM2.185 JDIMM2.188 JDIMM2.189 JDIMM2.192 JDIMM2.193 JDIMM2.196 JDIMM2.197 JDIMM2.201 JDIMM2.202 JDIMM2.205 JDIMM2.206 JDIMM2.209 JDIMM2.210 JDIMM2.213 JDIMM2.214 JDIMM2.217 JDIMM2.218 JDIMM2.222 JDIMM2.223 JDIMM2.226 JDIMM2.227 JDIMM2.230 JDIMM2.231 JDIMM2.234 JDIMM2.235 JDIMM2.238 JDIMM2.239 JDIMM2.243 JDIMM2.244 JDIMM2.247 JDIMM2.248 JDIMM2.251 JDIMM2.252 JDIMM2.261 JDIMM2.262 JDP.1 JDP.7 JDP.8 JDP.13 JDP.14 JDP.19 JDP.21 JDP.22 JDP.23 JDP.24 JEC.8 JEC.9 JEC.10 JEDP.3 JEDP.6 JEDP.9 JEDP.12 JEDP.15 JEDP.29 JEDP.30 JEDP.41 JEDP.42 JEDP.43 JEDP.44 JELC.4 JELC.5 JELC.6 JELC.7 JELC.8 JFAN1.4 JFAN1.5 JFAN1.6 JFAN2.4 JFAN2.5 JFAN2.6 JHDD.3 JHDD.6 JHDD.9 JHDD.12 JHDD.15 JHDD.18 JHDD.31 JHDD.32 JHDD.33 JHDD.34 JHDD.35 JHDMI.2 JHDMI.5 JHDMI.8 JHDMI.11 JHDMI.17 JHDMI.20 JHDMI.21 JHDMI.22 JHDMI.23 JIO.10 JIO.13 JIO.22 JIO.25 JIO.28 JIO.31 JIO.32 JIO.33 JIO.34 JKB.31 JKB.32 JKB2.17 JKB2.18 JKB2.19 JKB2.20 JKB3.1 JKB3.7 JKB3.8 JKB3.9 JKB3.10 JKBBL.1 JKBBL.2 JKBBL.21 JKBBL.22 JLAN.14 JLAN.15 JLAN.16 JLAN.17 JLOGO.15 JLOGO.16 JLOGO.17 JLOGO.18 JPCMC.19 JPCMC.36 JPWR.6 JPWR.7 JPWR.8 JPWR.9 JPWR.10 JRTC1.2 JRTC1.3 JRTC1.4 JSPK.6 JSPK.7 JSPK.8 JSSD1.1 JSSD1.3 JSSD1.9 JSSD1.15 JSSD1.21 JSSD1.27 JSSD1.33 JSSD1.39 JSSD1.45 JSSD1.51 JSSD1.57 JSSD1.71 JSSD1.73 JSSD1.75 JSSD1.76 JSSD1.77 JSSD2.1 JSSD2.3 JSSD2.9 JSSD2.15 JSSD2.21 JSSD2.27 JSSD2.33 JSSD2.39 JSSD2.45 JSSD2.51 JSSD2.57 JSSD2.71 JSSD2.73 JSSD2.75 JSSD2.76 JSSD2.77 JSSD3.1 JSSD3.3 JSSD3.9 JSSD3.15 JSSD3.21 JSSD3.27 JSSD3.33 JSSD3.39 JSSD3.45 JSSD3.51 JSSD3.57 JSSD3.71 JSSD3.73 JSSD3.75 JSSD3.76 JSSD3.77 JTOBII.1 JTOBII.5 JTOBII.7 JTOBII.8 JTP.6 JTP.7 JTP.14 JTP.17 JTP.18 JTRONL.6 JTRONL.7 JTRONL.13 JTRONL.14 JTRONR.6 JTRONR.7 JTRONR.13 JTRONR.14 JUSB1.4 JUSB1.7 JUSB1.11 JUSB1.12 JUSB1.13 JUSB1.14 JUSBC1.1 JUSBC1.2 JUSBC1.3 JUSBC1.4 JUSBC1.5 JUSBC1.6 JUSBC1.A1 JUSBC1.A12 JUSBC1.B1 JUSBC1.B12 JUSBC2.1 JUSBC2.2 JUSBC2.3 JUSBC2.4 JUSBC2.5 JUSBC2.6 JUSBC2.A1 JUSBC2.A12 JUSBC2.B1 JUSBC2.B12 JWDB.4 JWDB.5 JWDB.6 JWLAN.1 JWLAN.7 JWLAN.18 JWLAN.25 JWLAN.31 JWLAN.37 JWLAN.43 JWLAN.49 JWLAN.55 JWLAN.61 JWLAN.67 JWLAN.68 JWLAN.69 LE2.1 PBATT1.8 PBATT1.9 PBATT1.10 PBATT1.11 PBATT1.12 PC1.2 PC2.2 PC3.2 PC4.2 PC6.2 PC7.2 PC8.2 PC9.2 PC11.2 PC12.2 PC13.1 PC100.2 PC101.2 PC102.2 PC103.2 PC104.2 PC108.2 PC109.2 PC110.2 PC111.2 PC112.2 PC113.2 PC114.2 PC115.2 PC116.2 PC117.2 PC118.2 PC119.2 PC200.2 PC201.2 PC202.2 PC203.2 PC205.2 PC206.2 PC207.1 PC208.2 PC209.2 PC210.2 PC211.2 PC212.2 PC213.2 PC214.2 PC215.2 PC216.2 PC217.2 PC218.2 PC300.2 PC301.2 PC302.2 PC303.2 PC304.2 PC306.2 PC307.2 PC308.2 PC309.2 PC310.2 PC311.2 PC500.1 PC501.2 PC502.2 PC503.2 PC504.2 PC505.1 PC506.1 PC507.2 PC511.2 PC513.2 PC515.2 PC519.2 PC520.1 PC521.2 PC522.2 PC523.2 PC529.2 PC534.2 PC535.1 PC536.2 PC537.2 PC538.1 PC539.2 PC540.1 PC542.2 PC543.2 PC544.2 PC545.2 PC546.2 PC547.2 PC548.2 PC549.1 PC551.2 PC552.2 PC553.2 PC554.2 PC555.2 PC556.2 PC557.1 PC559.2 PC560.2 PC561.2 PC562.2 PC563.2 PC564.2 PC565.2 PC566.1 PC568.2 PC569.2 PC570.2 PC571.2 PC572.2 PC573.1 PC575.2 PC576.2 PC577.2 PC578.2 PC579.2 PC580.2 PC581.2 PC582.2 PC583.2 PC584.2 PC585.2 PC587.2 PC588.1 PC589.2 PC590.2 PC591.2 PC592.2 PC594.2 PC596.2 PC597.2 PC598.2 PC599.2 PC703.2 PC704.2 PC705.2 PC706.2 PC707.1 PC709.2 PC710.2 PC711.1 PC712.2 PC713.2 PC714.2 PC715.2 PC716.1 PC718.1 PC719.2 PC720.1 PC721.2 PC724.2 PC726.2 PC727.2 PC800.1 PC801.2 PC802.2 PC803.2 PC804.2 PC805.2 PC806.2 PC807.2 PC810.1 PC811.2 PC812.2 PC813.2 PC814.1 PC815.2 PC816.2 PC820.2 PC1000.2 PC1001.2 PC1002.2 PC1003.2 PC1004.2 PC1005.2 PC1006.2 PC1007.2 PC1008.2 PC1009.2 PC1010.2 PC1011.2 PC1012.2 PC1013.2 PC1014.2 PC1015.2 PC1016.2 PC1017.2 PC1018.2 PC1019.2 PC1020.2 PC1021.2 PC1022.2 PC1023.2 PC1024.2 PC1025.2 PC1026.2 PC1027.2 PC1028.2 PC1029.2 PC1030.2 PC1031.2 PC1032.2 PC1033.2 PC1034.2 PC1035.2 PC1036.2 PC1037.2 PC1038.2 PC1039.2 PC1040.2 PC1041.2 PC1042.2 PC1043.2 PC1044.2 PC1045.2 PC1046.2 PC1047.2 PC1048.2 PC1049.2 PC1050.2 PC1051.2 PC1052.2 PC1053.2 PC1054.2 PC1055.2 PC1056.2 PC1057.2 PC1058.2 PC1059.2 PC1060.2 PC1061.2 PC1062.2 PC1063.2 PC1064.2 PC1065.2 PC1066.2 PC1067.2 PC1068.2 PC1069.2 PC1070.2 PC1071.2 PC1072.2 PC1073.2 PC1074.2 PC1075.2 PC1076.2 PC1077.2 PC1078.2 PC1079.2 PC1080.2 PC1081.2 PC1082.2 PC1083.2 PC1084.2 PC1085.2 PC1086.2 PC1087.2 PC1088.2 PC1089.2 PC1090.2 PC1091.2 PC1092.2 PC1093.2 PC1094.2 PC1095.2 PC1096.2 PC1097.2 PC1098.2 PC1099.2 PC1100.2 PC1101.2 PC1102.2 PC1103.2 PC1104.2 PC1105.2 PC1106.2 PC1107.2 PC1108.2 PC1109.2 PC1110.2 PC1111.2 PC1112.2 PC1113.2 PC1114.2 PC1115.2 PC1116.2 PC1117.2 PC1118.2 PC1119.2 PC1120.2 PC1121.2 PC1122.2 PC1123.2 PC1124.2 PC1125.2 PC1126.2 PC1127.2 PC1128.2 PC1129.2 PC1130.2 PC1131.2 PC1132.2 PC1133.2 PC1134.2 PC1135.2 PC1136.2 PC1137.2 PC1138.2 PC1139.2 PC1140.2 PC1141.2 PC1142.2 PC1143.2 PC1144.2 PC1145.2 PC1146.2 PC1147.2 PC1148.2 PC1149.2 PC1150.2 PC1151.2 PC1152.2 PC1153.2 PC1154.2 PC1155.2 PC1156.2 PC1157.2 PC1158.2 PC1159.2 PC1160.2 PC1161.2 PC1162.2 PC1163.2 PC1164.2 PC1165.2 PC1166.2 PC1167.2 PC1168.2 PC1169.2 PC1170.2 PC1171.2 PC1172.2 PC1173.2 PC1174.2 PC1175.2 PC1176.2 PC1177.2 PC1178.2 PC1179.2 PC1180.2 PC1181.2 PC1182.2 PC1183.2 PC1184.2 PC1185.2 PC1186.2 PC1187.2 PC1188.2 PC1189.2 PC1190.2 PC1191.2 PC1192.2 PC1193.2 PC1194.2 PC1195.2 PC1196.2 PC1197.2 PC1198.2 PC1199.2 PC1200.2 PC1201.2 PC1202.2 PC1203.2 PC1204.2 PC1205.2 PC1206.2 PC1207.2 PC1208.2 PC1209.2 PC1210.2 PC1211.2 PC1212.2 PC1213.2 PC1214.2 PC1215.2 PC1216.2 PC1217.2 PC1218.2 PC1219.2 PC1220.2 PC1221.2 PC1222.2 PC1223.2 PC1224.2 PC1225.2 PC1226.2 PC1227.2 PC1228.2 PC1229.2 PC1230.2 PC1231.2 PC1232.2 PC1233.2 PC1234.2 PC1235.2 PC1236.2 PC1237.2 PC1238.2 PC1300.2 PC1301.2 PC1302.2 PC1303.2 PC1304.2 PC1306.2 PC1307.2 PC1308.2 PC1309.2 PC1311.2 PC1312.2 PC1313.2 PC1314.2 PC1315.2 PC5002.1 PC5003.2 PC5005.2 PC5006.2 PC5007.2 PC5008.2 PC5009.2 PC5010.1 PC5011.1 PC5013.2 PC5014.2 PC5015.2 PC5016.2 PC5017.2 PC5018.2 PC5019.2 PC5020.2 PC5021.2 PC5022.2 PC5023.2 PC5024.2 PC5025.2 PC5026.2 PC5027.2 PC6000.2 PC6001.1 PC6002.1 PC6003.1 PC6004.1 PC6012.1 PC6013.1 PC6016.1 PC6018.1 PC6023.1 PC6024.1 PC6027.1 PC6107.2 PC6108.2 PC6109.2 PC6110.2 PC6111.2 PC6112.2 PC6113.2 PC6114.2 PC6117.1 PC6118.2 PC6129.2 PC6131.2 PC6205.1 PC6206.2 PC6207.2 PC6208.2 PC6209.2 PC6210.2 PC6211.2 PC6212.2 PC6213.2 PC6214.2 PC6217.1 PC6218.2 PC6219.2 PC6220.2 PC6221.2 PC6222.2 PC6223.2 PC6224.2 PC6225.2 PC6226.2 PC6305.1 PC6306.2 PC6307.2 PC6308.2 PC6309.2 PC6310.2 PC6311.2 PC6312.2 PC6313.2 PC6314.2 PC6400.1 PC6401.2 PC6402.2 PC6403.2 PC6404.2 PC6405.2 PC6406.2 PC6407.2 PC6408.2 PC6409.2 PC6501.2 PC6502.2 PC6503.2 PC6504.2 PC6505.2 PC6506.2 PC6507.2 PC6508.2 PC6509.2 PC6510.2 PC6511.2 PC6512.2 PC6513.2 PC6514.2 PC6515.2 PC6516.2 PC6517.2 PC6518.2 PC6519.2 PC6520.2 PC6521.2 PC6522.2 PC6523.2 PC6524.2 PC6525.2 PC6526.2 PC6527.2 PC6528.2 PC6529.2 PC6530.2 PC6531.2 PC6532.2 PC6533.2 PC6534.2 PC6535.2 PC6536.2 PC6537.2 PC6538.2 PC6539.2 PC6540.2 PC6541.2 PC6542.2 PC6543.2 PC6544.2 PC6545.2 PC6546.2 PC6547.2 PC6548.2 PC6549.2 PC8200.2 PC8201.2 PC8202.2 PC8203.2 PC8204.2 PC8205.2 PC8207.2 PC8208.2 PC8210.2 PC8211.2 PC8212.2 PC8214.2 PC8215.2 PC8216.2 PC8217.2 PC8218.2 PC8219.2 PC8220.2 PC8221.2 PC8222.2 PC8226.2 PD1.1 PD2.1 PD3.1 PH500.1 PH504.1 PJPDC1.2 PJPDC1.3 PJPDC1.4 PJPDC1.5 PJPDC1.6 PJPDC1.7 PQ2.3 PQ4.3 PQ8.3 PQ101.1 PQ101.2 PQ101.3 PQ103.1 PQ103.2 PQ103.3 PQ201.1 PQ201.2 PQ201.3 PQ202.3 PQ202.6 PQ301.1 PQ301.2 PQ301.3 PQ706.1 PQ706.2 PQ706.3 PQ710.1 PQ710.4 PQ8200.3 PQ8200.4 PQ8200.5 PQ8201.3 PQ8201.4 PQ8201.5 PQ8202.3 PR9.1 PR26.1 PR28.1 PR103.1 PR104.2 PR105.1 PR106.1 PR107.2 PR116.2 PR207.2 PR303.1 PR306.2 PR308.2 PR500.1 PR513.1 PR516.2 PR517.2 PR518.2 PR519.2 PR527.2 PR539.2 PR547.1 PR548.2 PR562.1 PR572.1 PR582.1 PR700.1 PR711.2 PR715.2 PR719.2 PR728.1 PR730.1 PR802.2 PR805.2 PR808.2 PR811.2 PR813.1 PR1302.2 PR1305.2 PR1308.2 PR1309.2 PR5008.2 PR5015.2 PR5018.2 PR5034.1 PR6001.2 PR6002.2 PR6009.2 PR6016.2 PR6023.2 PR6031.2 PR6045.2 PR6049.2 PR6061.2 PR6065.2 PR6073.2 PR6082.1 PR6084.2 PR6086.2 PR6114.2 PR6211.2 PR6214.2 PR6311.2 PR6402.2 PR8206.1 PR8211.2 PR8216.2 PU100.21 PU201.1 PU201.3 PU201.14 PU201.21 PU300.11 PU500.49 PU502.4 PU502.10 PU502.23 PU502.28 PU503.4 PU503.10 PU503.23 PU503.28 PU504.4 PU504.10 PU504.23 PU504.28 PU507.4 PU507.10 PU507.23 PU507.28 PU509.7 PU509.8 PU509.18 PU509.21 PU510.4 PU510.10 PU510.23 PU510.28 PU511.3 PU511.7 PU511.10 PU511.13 PU700.22 PU700.29 PU800.7 PU800.8 PU800.18 PU800.21 PU802.11 PU1300.8 PU1300.9 PU1301.8 PU1301.9 PU6102.5 PU6102.19 PU6102.26 PU6201.5 PU6201.19 PU6201.26 PU6202.5 PU6202.19 PU6202.26 PU6301.5 PU6301.19 PU6301.26 PU6400.5 PU6400.19 PU6400.26 PU8200.5 PU8200.10 PU8200.21 PU8201.53 Q7.1 Q7.4 Q8.1 Q8.4 Q9.1 Q9.4 Q28.1 Q28.4 Q29.1 Q29.4 Q34.1 Q34.4 Q2410.3 QE1.1 QE1.4 QE2.3 QE3.1 QE3.4 QE4.1 QE4.4 QE5.3 QE13.1 QE21.1 QE22.1 QE29.1 QE29.4 QE39.1 QE39.4 QE40.1 QE40.4 QE41.1 QE41.4 QE42.1 QE42.4 QE43.1 QE43.4 QE44.1 QE44.4 QE45.1 QE45.4 QE46.1 QE46.4 QE47.1 QE47.4 QE48.1 QE48.4 QE49.1 QE49.4 QE50.1 QE50.4 QE51.1 QE51.4 QE52.1 QE52.4 QE53.1 QE53.4 QE57.1 QE57.4 QG3.3 QG4.3 QG505.1 QG505.4 QG507.1 QG507.4 QL3.3 QM2.1 QM2.4 QU1.3 QV2.3 QV95.3 R180.2 R185.1 RA1.2 RA4.2 RA6.2 RA7.2 RA9.2 RA16.2 RA22.2 RA52.2 RA62.1 RA67.2 RA73.2 RA74.2 RA75.2 RA76.2 RA77.2 RA78.2 RA79.2 RA80.2 RA81.2 RA82.2 RC35.2 RC348.2 RD28.2 RD29.2 RD30.2 RD38.2 RD39.2 RD40.2 RE27.2 RE29.2 RE30.2 RE31.2 RE37.2 RE42.2 RE44.2 RE66.1 RE75.2 RE83.2 RE162.2 RE163.2 RE164.2 RE167.2 RE397.2 RE401.2 RE453.2 RE456.2 RE458.2 RE462.2 RE465.2 RE468.2 RE472.2 RE473.2 RE478.2 RE479.2 RE484.2 RE485.2 RE490.2 RE491.2 RE496.2 RE497.2 RE501.2 RE504.2 RE508.2 RE509.2 RE512.2 RE515.2 RE519.2 RE523.2 RE527.2 RE638.2 RE641.2 RE645.1 RE649.1 RE650.2 RG1.2 RG2.2 RG3.2 RG8.2 RG23.2 RG24.2 RG25.2 RG26.2 RG38.2 RG43.2 RG45.1 RG46.2 RG60.1 RG61.1 RG67.2 RG68.1 RG69.2 RG78.1 RG79.1 RG85.1 RG86.2 RG87.2 RG88.2 RG90.2 RG91.2 RG92.2 RG93.2 RG96.2 RG97.2 RG100.2 RG101.2 RG102.2 RG103.2 RG105.2 RG106.2 RG107.2 RG110.2 RG111.2 RG114.2 RG115.2 RG117.2 RG118.2 RG119.2 RG120.2 RG121.2 RG124.2 RG125.2 RG128.2 RG129.2 RG131.2 RG132.2 RG133.2 RG134.2 RG135.2 RG138.2 RG139.2 RG142.2 RG143.2 RG144.2 RG147.2 RG148.2 RG150.2 RG154.2 RG155.2 RG159.2 RG161.1 RG163.1 RG165.1 RG166.1 RG168.1 RG396.2 RG401.2 RG403.2 RH9.2 RH22.2 RH24.2 RH26.2 RH28.2 RH30.2 RH57.1 RH58.1 RH59.2 RH88.1 RH90.1 RH109.2 RH135.1 RH148.1 RH149.1 RH150.1 RH166.1 RH184.2 RH185.2 RH186.2 RH187.2 RH188.2 RH199.2 RH209.2 RH210.2 RH211.2 RH212.2 RH455.1 RH466.2 RH469.2 RH472.2 RH497.1 RH580.2 RH581.2 RH585.1 RH589.1 RL3.2 RL4.1 RM6.1 RM17.1 RM21.1 RM23.1 RM25.1 RM29.2 RM31.2 RM38.2 RM42.2 RM62.1 RM64.2 RM70.1 RM72.2 RM75.1 RM82.1 RM84.1 RM87.2 RS3.2 RT3.2 RT4.2 RT5.2 RT11.2 RT17.2 RT18.2 RT19.2 RT22.2 RT24.2 RT34.2 RT35.2 RT36.2 RT37.2 RT38.2 RT39.2 RT40.2 RT41.2 RT42.2 RT43.2 RT44.2 RT45.2 RT46.2 RT47.2 RT62.2 RT63.2 RT64.2 RT65.2 RT68.2 RT69.2 RT71.2 RT72.2 RT73.2 RT75.2 RT78.2 RT79.2 RT80.2 RT83.1 RT108.2 RU2.1 RU3.1 RU25.2 RV1.2 RV8.2 RV10.2 RV15.1 RV17.2 RV18.1 RV20.2 RV22.2 RV23.1 RV24.2 RV193.1 RV197.2 RV199.2 RV203.2 RV537.2 RV600.1 RV622.2 RV624.2 RV626.2 RV628.2 RV630.2 RV669.2 RV670.2 RV1309.2 RX4.2 RX8.2 SW1.1 U1.49 U16.5 U17.11 U17.15 U18.2 U19.5 U20.5 U1302.4 U1302.9 U2407.6 UA1.57 UA4.4 UA4.19 UA4.20 UA4.24 UA4.33 UA4.34 UA4.39 UA4.45 UA4.46 UA4.53 UA4.54 UA4.57 UC1.3 UE1.3 UE2.4 UE3.7 UE3.18 UE3.23 UE3.33 UE4.7 UE4.18 UE4.23 UE4.33 UE5.11 UE5.24 UE5.35 UE5.94 UE5.113 UE6.12 UE6.25 UE8.7 UE8.18 UE8.23 UE8.33 UE9.2 UE10.12 UE10.23 UE10.25 UE12.2 UG1.A2 UG1.A6 UG1.A11 UG1.A15 UG1.A19 UG1.A25 UG1.A29 UG1.A33 UG1.A38 UG1.A42 UG1.AA3 UG1.AA6 UG1.AA9 UG1.AA12 UG1.AA15 UG1.AA18 UG1.AA19 UG1.AA22 UG1.AA23 UG1.AA26 UG1.AA27 UG1.AA32 UG1.AA33 UG1.AA36 UG1.AA40 UG1.AB15 UG1.AB18 UG1.AB19 UG1.AB22 UG1.AB23 UG1.AB26 UG1.AB27 UG1.AC3 UG1.AC6 UG1.AC12 UG1.AC15 UG1.AC18 UG1.AC19 UG1.AC22 UG1.AC23 UG1.AC26 UG1.AC27 UG1.AC32 UG1.AC33 UG1.AC36 UG1.AC40 UG1.AC41 UG1.AD2 UG1.AD5 UG1.AD8 UG1.AD14 UG1.AD18 UG1.AD19 UG1.AD22 UG1.AD23 UG1.AD26 UG1.AD27 UG1.AD32 UG1.AD35 UG1.AD37 UG1.AD40 UG1.AE1 UG1.AE4 UG1.AE10 UG1.AE18 UG1.AE19 UG1.AE22 UG1.AE23 UG1.AE26 UG1.AE27 UG1.AE32 UG1.AE36 UG1.AE40 UG1.AF3 UG1.AF6 UG1.AF8 UG1.AF12 UG1.AF18 UG1.AF19 UG1.AF22 UG1.AF23 UG1.AF26 UG1.AF27 UG1.AF32 UG1.AF36 UG1.AF40 UG1.AF41 UG1.AG2 UG1.AG8 UG1.AG10 UG1.AG14 UG1.AG15 UG1.AG18 UG1.AG19 UG1.AG22 UG1.AG23 UG1.AG26 UG1.AG27 UG1.AG32 UG1.AG35 UG1.AG37 UG1.AG40 UG1.AH16 UG1.AJ1 UG1.AJ4 UG1.AJ10 UG1.AJ14 UG1.AJ15 UG1.AJ17 UG1.AJ29 UG1.AJ32 UG1.AJ36 UG1.AJ40 UG1.AK3 UG1.AK6 UG1.AK12 UG1.AK15 UG1.AK17 UG1.AK18 UG1.AK20 UG1.AK24 UG1.AK27 UG1.AK29 UG1.AK32 UG1.AK36 UG1.AK40 UG1.AK41 UG1.AL23 UG1.AL25 UG1.AL29 UG1.AM2 UG1.AM8 UG1.AM11 UG1.AM14 UG1.AM18 UG1.AM26 UG1.AM32 UG1.AM35 UG1.AM37 UG1.AM40 UG1.AN1 UG1.AN4 UG1.AN12 UG1.AN24 UG1.AN27 UG1.AN33 UG1.AN36 UG1.AN40 UG1.AP15 UG1.AP19 UG1.AP25 UG1.AP29 UG1.AP30 UG1.AR3 UG1.AR6 UG1.AR9 UG1.AR32 UG1.AR33 UG1.AR35 UG1.AR36 UG1.AR40 UG1.AR41 UG1.AT2 UG1.AT5 UG1.AT12 UG1.AT17 UG1.AT21 UG1.AT26 UG1.AT27 UG1.AT35 UG1.AT38 UG1.AT39 UG1.AT40 UG1.AT41 UG1.AT42 UG1.AT43 UG1.AU18 UG1.AU19 UG1.AU23 UG1.AU24 UG1.AU25 UG1.AV1 UG1.AV4 UG1.AV6 UG1.AV9 UG1.AV14 UG1.AV20 UG1.AV29 UG1.AV30 UG1.AV32 UG1.AV33 UG1.AV38 UG1.AV39 UG1.AV40 UG1.AW2 UG1.AW5 UG1.AW8 UG1.AW26 UG1.AW27 UG1.AW29 UG1.AW30 UG1.AW32 UG1.AW33 UG1.AW35 UG1.AW36 UG1.AW38 UG1.AW39 UG1.AW41 UG1.AW43 UG1.AY3 UG1.AY6 UG1.AY11 UG1.AY15 UG1.AY18 UG1.AY19 UG1.AY25 UG1.AY41 UG1.B1 UG1.B2 UG1.B8 UG1.B12 UG1.B17 UG1.B20 UG1.B24 UG1.B27 UG1.B32 UG1.B36 UG1.B39 UG1.B42 UG1.B43 UG1.BA4 UG1.BA9 UG1.BA14 UG1.BA18 UG1.BA21 UG1.BA23 UG1.BA26 UG1.BA27 UG1.BA29 UG1.BA30 UG1.BA32 UG1.BA33 UG1.BA35 UG1.BA36 UG1.BA38 UG1.BA39 UG1.BA40 UG1.BB1 UG1.BB2 UG1.BB5 UG1.BB8 UG1.BB12 UG1.BB17 UG1.BB18 UG1.BB42 UG1.BB43 UG1.BC2 UG1.BC6 UG1.BC11 UG1.BC15 UG1.BC18 UG1.BC42 UG1.C5 UG1.C9 UG1.C14 UG1.C18 UG1.C21 UG1.C23 UG1.C26 UG1.C30 UG1.C35 UG1.C40 UG1.D6 UG1.D11 UG1.D15 UG1.D19 UG1.D25 UG1.D29 UG1.D33 UG1.D38 UG1.D41 UG1.E3 UG1.E5 UG1.E8 UG1.E24 UG1.E36 UG1.E39 UG1.E42 UG1.F1 UG1.F4 UG1.F6 UG1.F9 UG1.F14 UG1.F18 UG1.F21 UG1.F23 UG1.F26 UG1.F30 UG1.F35 UG1.F38 UG1.F40 UG1.F43 UG1.H2 UG1.H5 UG1.H8 UG1.H12 UG1.H17 UG1.H20 UG1.H24 UG1.H26 UG1.H27 UG1.H32 UG1.H39 UG1.H42 UG1.J3 UG1.J6 UG1.J9 UG1.J21 UG1.J35 UG1.J38 UG1.J41 UG1.K15 UG1.K19 UG1.K25 UG1.K27 UG1.K29 UG1.L1 UG1.L4 UG1.L7 UG1.L11 UG1.L12 UG1.L14 UG1.L32 UG1.L40 UG1.L43 UG1.M2 UG1.M8 UG1.M11 UG1.M18 UG1.M21 UG1.M23 UG1.M26 UG1.M30 UG1.M33 UG1.M36 UG1.M42 UG1.P3 UG1.P6 UG1.P9 UG1.P11 UG1.P17 UG1.P18 UG1.P24 UG1.P27 UG1.P29 UG1.P32 UG1.P38 UG1.P41 UG1.R1 UG1.R4 UG1.R10 UG1.R15 UG1.R17 UG1.R21 UG1.R22 UG1.R23 UG1.R27 UG1.R29 UG1.R30 UG1.R34 UG1.R40 UG1.R43 UG1.T18 UG1.T19 UG1.T22 UG1.T23 UG1.T26 UG1.T28 UG1.U2 UG1.U8 UG1.U14 UG1.U15 UG1.U18 UG1.U19 UG1.U22 UG1.U23 UG1.U26 UG1.U27 UG1.U29 UG1.U30 UG1.U36 UG1.U42 UG1.V3 UG1.V6 UG1.V12 UG1.V18 UG1.V19 UG1.V22 UG1.V23 UG1.V26 UG1.V27 UG1.V30 UG1.V32 UG1.V37 UG1.W1 UG1.W4 UG1.W10 UG1.W18 UG1.W19 UG1.W22 UG1.W23 UG1.W26 UG1.W27 UG1.W34 UG1.W36 UG1.W38 UG1.W39 UG1.W40 UG1.W41 UG1.Y2 UG1.Y5 UG1.Y8 UG1.Y18 UG1.Y19 UG1.Y22 UG1.Y23 UG1.Y26 UG1.Y27 UG1.Y30 UG1.Y35 UG1.Y36 UG1.Y37 UG1.Y40 UG2.3 UG3.5 UG4.3 UG13.A1 UG13.A3 UG13.A12 UG13.A14 UG13.B5 UG13.B10 UG13.C1 UG13.C3 UG13.C4 UG13.C11 UG13.C12 UG13.C14 UG13.D10 UG13.E1 UG13.E3 UG13.E12 UG13.E14 UG13.F5 UG13.F10 UG13.G5 UG13.G10 UG13.H1 UG13.H2 UG13.H13 UG13.H14 UG13.K1 UG13.K2 UG13.K13 UG13.K14 UG13.L5 UG13.L10 UG13.M5 UG13.M10 UG13.N1 UG13.N3 UG13.N12 UG13.N14 UG13.P10 UG13.R1 UG13.R3 UG13.R4 UG13.R11 UG13.R12 UG13.R14 UG13.T5 UG13.T10 UG13.U1 UG13.U3 UG13.U12 UG13.U14 UG14.A1 UG14.A3 UG14.A12 UG14.A14 UG14.B5 UG14.B10 UG14.C1 UG14.C3 UG14.C4 UG14.C11 UG14.C12 UG14.C14 UG14.D10 UG14.E1 UG14.E3 UG14.E12 UG14.E14 UG14.F5 UG14.F10 UG14.G5 UG14.G10 UG14.H1 UG14.H2 UG14.H13 UG14.H14 UG14.K1 UG14.K2 UG14.K13 UG14.K14 UG14.L5 UG14.L10 UG14.M5 UG14.M10 UG14.N1 UG14.N3 UG14.N12 UG14.N14 UG14.P10 UG14.R1 UG14.R3 UG14.R4 UG14.R11 UG14.R12 UG14.R14 UG14.T5 UG14.T10 UG14.U1 UG14.U3 UG14.U12 UG14.U14 UG15.A1 UG15.A3 UG15.A12 UG15.A14 UG15.B5 UG15.B10 UG15.C1 UG15.C3 UG15.C4 UG15.C11 UG15.C12 UG15.C14 UG15.D10 UG15.E1 UG15.E3 UG15.E12 UG15.E14 UG15.F5 UG15.F10 UG15.G5 UG15.G10 UG15.H1 UG15.H2 UG15.H13 UG15.H14 UG15.K1 UG15.K2 UG15.K13 UG15.K14 UG15.L5 UG15.L10 UG15.M5 UG15.M10 UG15.N1 UG15.N3 UG15.N12 UG15.N14 UG15.P10 UG15.R1 UG15.R3 UG15.R4 UG15.R11 UG15.R12 UG15.R14 UG15.T5 UG15.T10 UG15.U1 UG15.U3 UG15.U12 UG15.U14 UG16.A1 UG16.A3 UG16.A12 UG16.A14 UG16.B5 UG16.B10 UG16.C1 UG16.C3 UG16.C4 UG16.C11 UG16.C12 UG16.C14 UG16.D10 UG16.E1 UG16.E3 UG16.E12 UG16.E14 UG16.F5 UG16.F10 UG16.G5 UG16.G10 UG16.H1 UG16.H2 UG16.H13 UG16.H14 UG16.K1 UG16.K2 UG16.K13 UG16.K14 UG16.L5 UG16.L10 UG16.M5 UG16.M10 UG16.N1 UG16.N3 UG16.N12 UG16.N14 UG16.P10 UG16.R1 UG16.R3 UG16.R4 UG16.R11 UG16.R12 UG16.R14 UG16.T5 UG16.T10 UG16.U1 UG16.U3 UG16.U12 UG16.U14 UG17.A1 UG17.A3 UG17.A12 UG17.A14 UG17.B5 UG17.B10 UG17.C1 UG17.C3 UG17.C4 UG17.C11 UG17.C12 UG17.C14 UG17.D10 UG17.E1 UG17.E3 UG17.E12 UG17.E14 UG17.F5 UG17.F10 UG17.G5 UG17.G10 UG17.H1 UG17.H2 UG17.H13 UG17.H14 UG17.K1 UG17.K2 UG17.K13 UG17.K14 UG17.L5 UG17.L10 UG17.M5 UG17.M10 UG17.N1 UG17.N3 UG17.N12 UG17.N14 UG17.P10 UG17.R1 UG17.R3 UG17.R4 UG17.R11 UG17.R12 UG17.R14 UG17.T5 UG17.T10 UG17.U1 UG17.U3 UG17.U12 UG17.U14 UG18.A1 UG18.A3 UG18.A12 UG18.A14 UG18.B5 UG18.B10 UG18.C1 UG18.C3 UG18.C4 UG18.C11 UG18.C12 UG18.C14 UG18.D10 UG18.E1 UG18.E3 UG18.E12 UG18.E14 UG18.F5 UG18.F10 UG18.G5 UG18.G10 UG18.H1 UG18.H2 UG18.H13 UG18.H14 UG18.K1 UG18.K2 UG18.K13 UG18.K14 UG18.L5 UG18.L10 UG18.M5 UG18.M10 UG18.N1 UG18.N3 UG18.N12 UG18.N14 UG18.P10 UG18.R1 UG18.R3 UG18.R4 UG18.R11 UG18.R12 UG18.R14 UG18.T5 UG18.T10 UG18.U1 UG18.U3 UG18.U12 UG18.U14 UG19.A1 UG19.A3 UG19.A12 UG19.A14 UG19.B5 UG19.B10 UG19.C1 UG19.C3 UG19.C4 UG19.C11 UG19.C12 UG19.C14 UG19.D10 UG19.E1 UG19.E3 UG19.E12 UG19.E14 UG19.F5 UG19.F10 UG19.G5 UG19.G10 UG19.H1 UG19.H2 UG19.H13 UG19.H14 UG19.K1 UG19.K2 UG19.K13 UG19.K14 UG19.L5 UG19.L10 UG19.M5 UG19.M10 UG19.N1 UG19.N3 UG19.N12 UG19.N14 UG19.P10 UG19.R1 UG19.R3 UG19.R4 UG19.R11 UG19.R12 UG19.R14 UG19.T5 UG19.T10 UG19.U1 UG19.U3 UG19.U12 UG19.U14 UG20.A1 UG20.A3 UG20.A12 UG20.A14 UG20.B5 UG20.B10 UG20.C1 UG20.C3 UG20.C4 UG20.C11 UG20.C12 UG20.C14 UG20.D10 UG20.E1 UG20.E3 UG20.E12 UG20.E14 UG20.F5 UG20.F10 UG20.G5 UG20.G10 UG20.H1 UG20.H2 UG20.H13 UG20.H14 UG20.K1 UG20.K2 UG20.K13 UG20.K14 UG20.L5 UG20.L10 UG20.M5 UG20.M10 UG20.N1 UG20.N3 UG20.N12 UG20.N14 UG20.P10 UG20.R1 UG20.R3 UG20.R4 UG20.R11 UG20.R12 UG20.R14 UG20.T5 UG20.T10 UG20.U1 UG20.U3 UG20.U12 UG20.U14 UH1.A2 UH1.A3 UH1.A4 UH1.A18 UH1.A25 UH1.A32 UH1.A37 UH1.A42 UH1.A44 UH1.AA4 UH1.AA17 UH1.AA18 UH1.AA20 UH1.AA21 UH1.AA25 UH1.AA29 UH1.AA42 UH1.AB4 UH1.AB5 UH1.AB7 UH1.AB8 UH1.AB10 UH1.AB11 UH1.AB14 UH1.AB15 UH1.AB31 UH1.AB32 UH1.AB38 UH1.AC1 UH1.AC18 UH1.AC20 UH1.AC21 UH1.AC25 UH1.AC29 UH1.AC45 UH1.AD4 UH1.AD8 UH1.AD11 UH1.AD14 UH1.AD32 UH1.AD33 UH1.AD36 UH1.AE4 UH1.AE18 UH1.AE20 UH1.AE21 UH1.AE25 UH1.AE28 UH1.AE29 UH1.AE42 UH1.AF18 UH1.AF20 UH1.AF21 UH1.AF23 UH1.AF25 UH1.AF26 UH1.AF28 UH1.AF29 UH1.AG4 UH1.AG11 UH1.AG13 UH1.AG31 UH1.AG32 UH1.AG33 UH1.AG38 UH1.AH1 UH1.AH17 UH1.AH18 UH1.AH20 UH1.AH21 UH1.AH23 UH1.AH25 UH1.AH26 UH1.AH28 UH1.AH29 UH1.AH45 UH1.AJ10 UH1.AJ14 UH1.AJ15 UH1.AJ17 UH1.AJ18 UH1.AJ26 UH1.AJ28 UH1.AJ29 UH1.AJ31 UH1.AJ32 UH1.AJ36 UH1.AK4 UH1.AK42 UH1.AL4 UH1.AL10 UH1.AL11 UH1.AL13 UH1.AL17 UH1.AL19 UH1.AL24 UH1.AL29 UH1.AL32 UH1.AL33 UH1.AL38 UH1.AM15 UH1.AM17 UH1.AM19 UH1.AM22 UH1.AM24 UH1.AM27 UH1.AM29 UH1.AM45 UH1.AN4 UH1.AN7 UH1.AN8 UH1.AN10 UH1.AN11 UH1.AN22 UH1.AN27 UH1.AN31 UH1.AN39 UH1.AP4 UH1.AP11 UH1.AR5 UH1.AR7 UH1.AR9 UH1.AR33 UH1.AR34 UH1.AR42 UH1.AT9 UH1.AT10 UH1.AT15 UH1.AT36 UH1.AU1 UH1.AU7 UH1.AU35 UH1.AU36 UH1.AU39 UH1.AU45 UH1.AV6 UH1.AV17 UH1.AV24 UH1.AV27 UH1.AV31 UH1.AV33 UH1.AW9 UH1.AW13 UH1.AW19 UH1.AW29 UH1.AW37 UH1.AY38 UH1.AY45 UH1.B1 UH1.B2 UH1.B3 UH1.B6 UH1.B25 UH1.B37 UH1.B40 UH1.B44 UH1.B45 UH1.BA1 UH1.BB1 UH1.BB11 UH1.BB16 UH1.BB21 UH1.BB25 UH1.BB30 UH1.BB34 UH1.BC1 UH1.BC2 UH1.BD2 UH1.BD43 UH1.BD44 UH1.BD45 UH1.BE9 UH1.BE14 UH1.BE18 UH1.BE23 UH1.BE28 UH1.BE32 UH1.BE37 UH1.BE40 UH1.BE44 UH1.C1 UH1.C2 UH1.C4 UH1.C10 UH1.C28 UH1.C37 UH1.C42 UH1.D1 UH1.D10 UH1.D12 UH1.D15 UH1.D16 UH1.D17 UH1.D19 UH1.D21 UH1.D24 UH1.D25 UH1.D27 UH1.D29 UH1.D30 UH1.D31 UH1.D33 UH1.D35 UH1.D36 UH1.D45 UH1.E13 UH1.E15 UH1.E31 UH1.E33 UH1.F8 UH1.F44 UH1.G9 UH1.G42 UH1.H3 UH1.H17 UH1.H19 UH1.H22 UH1.H24 UH1.H27 UH1.H29 UH1.H35 UH1.J3 UH1.J5 UH1.J7 UH1.J10 UH1.J11 UH1.J39 UH1.K4 UH1.K10 UH1.K27 UH1.K33 UH1.K36 UH1.K42 UH1.K43 UH1.L4 UH1.L8 UH1.L12 UH1.L13 UH1.L15 UH1.L41 UH1.M35 UH1.M42 UH1.N4 UH1.N5 UH1.N10 UH1.N15 UH1.N19 UH1.N22 UH1.N24 UH1.N35 UH1.N36 UH1.N41 UH1.P17 UH1.P19 UH1.P22 UH1.P45 UH1.R5 UH1.R10 UH1.R14 UH1.R22 UH1.R29 UH1.R33 UH1.R38 UH1.T1 UH1.T2 UH1.T4 UH1.T42 UH1.U4 UH1.U8 UH1.U10 UH1.U11 UH1.U14 UH1.U15 UH1.U17 UH1.U18 UH1.U28 UH1.U29 UH1.U31 UH1.U32 UH1.U33 UH1.U38 UH1.V3 UH1.V18 UH1.V20 UH1.V21 UH1.V23 UH1.V25 UH1.V29 UH1.V45 UH1.W4 UH1.W8 UH1.W14 UH1.W31 UH1.W32 UH1.W33 UH1.W38 UH1.Y17 UH1.Y18 UH1.Y20 UH1.Y21 UH1.Y26 UH1.Y28 UH1.Y29 UH3.3 UH4.4 UH5.4 UL1.27 UL1.41 UL2.2 UM3.3 UM4.6 UM4.15 UM4.19 UM7.3 UM8.25 UM8.55 US1.5 US1.10 US1.12 US1.13 US1.15 US1.16 UT1.A1 UT1.A6 UT1.A8 UT1.A10 UT1.A12 UT1.A14 UT1.A16 UT1.A18 UT1.A20 UT1.A22 UT1.AA22 UT1.AA23 UT1.AB1 UT1.AB2 UT1.AB6 UT1.AB8 UT1.AB10 UT1.AB12 UT1.AB14 UT1.AB16 UT1.AB18 UT1.AB20 UT1.AB22 UT1.AC1 UT1.AC2 UT1.AC6 UT1.AC8 UT1.AC10 UT1.AC12 UT1.AC14 UT1.AC16 UT1.AC18 UT1.AC20 UT1.AC22 UT1.B1 UT1.B2 UT1.B6 UT1.B8 UT1.B10 UT1.B12 UT1.B14 UT1.B16 UT1.B18 UT1.B20 UT1.B22 UT1.C22 UT1.C23 UT1.D5 UT1.D6 UT1.D8 UT1.D9 UT1.D11 UT1.D12 UT1.D13 UT1.D15 UT1.D16 UT1.D18 UT1.E4 UT1.E5 UT1.E6 UT1.E8 UT1.E9 UT1.E11 UT1.E15 UT1.E16 UT1.E22 UT1.E23 UT1.F5 UT1.F6 UT1.F9 UT1.F16 UT1.F20 UT1.G22 UT1.G23 UT1.H1 UT1.H2 UT1.H5 UT1.H8 UT1.H12 UT1.H13 UT1.H15 UT1.H16 UT1.H20 UT1.J5 UT1.J8 UT1.J12 UT1.J13 UT1.J15 UT1.J18 UT1.J19 UT1.J20 UT1.J22 UT1.J23 UT1.K1 UT1.K2 UT1.L5 UT1.L13 UT1.L15 UT1.L20 UT1.L22 UT1.L23 UT1.M1 UT1.M2 UT1.M5 UT1.M11 UT1.M12 UT1.M19 UT1.M20 UT1.N5 UT1.N8 UT1.N9 UT1.N11 UT1.N12 UT1.N13 UT1.N15 UT1.N20 UT1.N22 UT1.N23 UT1.P1 UT1.P2 UT1.R5 UT1.R18 UT1.R19 UT1.R20 UT1.R22 UT1.R23 UT1.T1 UT1.T2 UT1.T5 UT1.T6 UT1.T8 UT1.T9 UT1.T13 UT1.T15 UT1.T16 UT1.T18 UT1.T20 UT1.U22 UT1.U23 UT1.V5 UT1.V6 UT1.V8 UT1.V9 UT1.V15 UT1.V16 UT1.V20 UT1.W5 UT1.W6 UT1.W8 UT1.W9 UT1.W13 UT1.W18 UT1.W20 UT1.W22 UT1.W23 UT1.Y9 UT1.Y13 UT1.Y20 UT2.4 UT4.A1 UT4.B8 UT4.D8 UT4.E5 UT4.E6 UT4.E7 UT4.E8 UT4.F5 UT4.F6 UT4.F7 UT4.F8 UT4.G5 UT4.G6 UT4.G7 UT4.G8 UT4.H4 UT4.H5 UT4.H8 UT4.L1 UT4.L11 UU1.14 UU1.17 UU3.2 UU5.3 UU7.12 UU7.21 UV3.8 UV3.15 UV17.2 UV21.8 UV21.18 UV21.33 UV21.41 UV21.57 UV21.61 UV22.8 UV22.15 UV23.2 UX1.3 UX2.3 UZ21.5 UZ21.9 YG1.2 YH2.2 YH2.4 YL1.2 YL1.4 YT1.2 YT1.4
GNDA: CA14.2 CA15.2 CA16.2 CA17.2 CA24.2 CA25.2 CA26.2 CA27.2 CA28.2 CA29.2 CA30.2 CA31.2 CA32.2 CA33.2 CA42.2 CA43.2 CA44.1 CA45.2 CA46.2 CA48.2 CA50.2 CA51.1 CA91.2 CA92.2 JACK1.5 JACK2.3 JACK2.4 JACK2.6 RA1.1 RA4.1 RA6.1 RA7.1 RA44.2 RA45.2 UA1.20 UA1.30 UA1.42 UA2.A2 UA3.A2
VCC_CORE_PT1: PT1.1(TP-1) PU502.22
VCC_CORE_PT2: PT2.1(TP-1) PU503.22
VCC_CORE_PT3: PT3.1(TP-1) PU504.22
VCC_GT_PT1: PT4.1(TP-1) PU507.22
VCC_GT_PT2: PT5.1(TP-1) PU510.22
VCC_SA_PT1: PT6.1(TP-1) PU511.9
VCCGT_SENSE: CPU1.AH38 PC508.1 PR531.2 RH203.2
VCCIO_PGOOD: PR5016.2 PU509.9
VCCIO_SENSE: CPU1.H14 PR5017.1
VCCSA_SENSE: CPU1.M38 PC514.2 PR533.2 RH201.1
VCCSENSE: CPU1.AG37 PC533.1 PR550.1 RH197.2
VDD_1.2V: PC212.1 PR201.1 PR203.2 PU201.11
VDDC_FB_H: PR6037.2 PR6039.1 UG1.AL21
VDDC_FB_L: PR6041.1 PR6045.1 UG1.AK21
VDDCI_FB: PR6067.2 PR6071.1 UG1.AK23
VIN: PC3.1 PC4.1 PC722.1 PC723.1 PD101.2 PD700.3 PL1.2 PL3.2 PQ701.5 PQ707.5 PR716.1 PR729.2 PR732.1
VSSGT_SENSE: CPU1.AH37 PC513.1 PU500.6 RH472.1
VSSIO_SENSE: CPU1.J14 PR5018.1
VSSSA_SENSE: CPU1.M37 PC515.1 PU500.31 RH469.1
VSSSENSE: CPU1.AG38 PC534.1 PU500.18 RH466.1
+CODEC_AVDD2: CA16.1 CA17.1 LA4.1 RA12.1 UA1.24
+EC_VCCA: CE33.1 LE1.2 UE5.67
+FBA_VREFCH: CG143.2 CG145.1 RG99.2 RG101.1 UG14.J14
+FBA_VREFCL: CG142.2 CG144.1 RG98.2 RG100.1 UG13.J14
+FBA_VREFDH: CG138.2 CG140.1 RG94.2 RG97.1 UG14.A10 UG14.U10
+FBA_VREFDL: CG139.2 CG141.1 RG95.2 RG96.1 UG13.A10 UG13.U10
+FBB_VREFCH: CG184.2 CG186.1 RG112.2 RG114.1 UG16.J14
+FBB_VREFCL: CG185.2 CG187.1 RG113.2 RG115.1 UG15.J14
+FBB_VREFDH: CG180.2 CG182.1 RG108.2 RG110.1 UG16.A10 UG16.U10
+FBB_VREFDL: CG181.2 CG183.1 RG109.2 RG111.1 UG15.A10 UG15.U10
+FBC_VREFCH: CG227.2 CG229.1 RG127.2 RG129.1 UG18.J14
+FBC_VREFCL: CG226.2 CG228.1 RG126.2 RG128.1 UG17.J14
+FBC_VREFDH: CG222.2 CG224.1 RG123.2 RG124.1 UG18.A10 UG18.U10
+FBC_VREFDL: CG223.2 CG225.1 RG122.2 RG125.1 UG17.A10 UG17.U10
+FBD_VREFCH: CG269.2 CG271.1 RG141.2 RG143.1 UG20.J14
+FBD_VREFCL: CG268.2 CG270.1 RG140.2 RG142.1 UG19.J14
+FBD_VREFDH: CG265.2 CG267.1 RG137.2 RG139.1 UG20.A10 UG20.U10
+FBD_VREFDL: CG264.2 CG266.1 RG136.2 RG138.1 UG19.A10 UG19.U10
+HDMI_5V_OUT: CV1068.1 CV1069.1 FV3.2 JHDMI.18
+INV_PWR_SRC: CV14.1 CV375.1 JEDP.37 JEDP.38 JEDP.39 JEDP.40 QV1.1 QV1.2 QV1.5 QV1.6
+LAN_IO: CL11.1 CL12.1 CL13.1 CL14.1 CL15.1 CL16.1 CL17.1 LL1.1 RL1.1 RL2.1 RL8.2 RL14.1 UL1.1 UL1.16 UL2.1
+LCDVDD: CV9.1 CV10.1 CV17.1 CV18.1 CV373.1 JEDP.25 JEDP.26 JEDP.27 UV17.1
+RBIAS: RL3.1 UL1.10
+RTC_CELL: CH80.1 CH173.1 PD5.1 RA25.1 RH83.1 RH84.1 RH531.2 UH1.BA22
+TBTA_VBUS: CT94.2 CT95.2 CT96.1 CT97.1 CT106.1 DT1.1 DT15.2 DT15.3 JUSBC1.A4 JUSBC1.A9 JUSBC1.B4 JUSBC1.B9 UT4.A10 UT4.B10 UT4.H11 UT4.J10 UT4.J11 UT4.K11
+TSVDD: CG42.1 CG43.1 LG1.2 UG1.AR26
+V_DDR_REFA: CD18.1 JDIMM1.164 RH206.2 RH209.1 RH484.2
+V_DDR_REFA_R: CH101.1 CPU1.BN13 RH484.1
+V_DDR_REFB: CD29.1 JDIMM2.164 RH207.2 RH210.1 RH485.2
+V_DDR_REFB_R: CH100.1 CPU1.BR13 RH485.1
+VGA_CORE: CG47.1 CG48.1 CG49.1 CG50.1 CG51.1 CG66.1 CG67.1 CG68.1 CG70.1 CG71.1 CG72.1 CG73.1 CG74.1 CG75.1 CG76.1 CG77.1 CG78.1 CG83.1 CG84.1 CG85.1 CG86.1 CG87.1 CG93.1 CG94.1 CG95.1 CG98.1 CG103.1 CG104.1 CG105.1 CG106.1 CG107.1 CG108.1 CG110.1 CG111.1 CG112.1 CG113.1 CG114.1 CG115.1 CG116.1 CG117.1 CG118.1 CG119.1 CG120.1 CG121.1 CG122.1 CG123.1 PC6510.1 PC6511.1 PC6512.1 PC6513.1 PC6514.1 PC6515.1 PC6516.1 PC6517.1 PC6518.1 PC6519.1 PC6520.1 PC6521.1 PC6522.1 PC6523.1 PC6524.1 PC6525.1 PC6526.1 PC6527.1 PC6528.1 PC6529.1 PC6530.1 PC6531.1 PC6532.1 PC6533.1 PC6534.1 PC6535.1 PC6536.1 PC6537.1 PC6538.1 PC6539.1 PC6540.1 PC6541.1 PC6542.1 PC6543.1 PC6544.1 PC6545.1 PC6546.1 PC6547.1 PC6548.1 PC6549.1 PL6101.4 PL6200.4 PL6201.4 PL6300.4 PR6037.1 RG516.1 UG1.AA16 UG1.AA17 UG1.AA20 UG1.AA21 UG1.AA24 UG1.AA25 UG1.AA28 UG1.AA29 UG1.AB16 UG1.AB17 UG1.AB20 UG1.AB21 UG1.AB24 UG1.AB25 UG1.AB28 UG1.AB29 UG1.AC16 UG1.AC17 UG1.AC20 UG1.AC21 UG1.AC24 UG1.AC25 UG1.AC28 UG1.AC29 UG1.AD16 UG1.AD17 UG1.AD20 UG1.AD21 UG1.AD24 UG1.AD25 UG1.AD28 UG1.AD29 UG1.AE16 UG1.AE17 UG1.AE20 UG1.AE21 UG1.AE24 UG1.AE25 UG1.AE28 UG1.AE29 UG1.AF16 UG1.AF17 UG1.AF20 UG1.AF21 UG1.AF24 UG1.AF25 UG1.AF28 UG1.AF29 UG1.AG17 UG1.AG20 UG1.AG21 UG1.AG24 UG1.AG25 UG1.AG28 UG1.AG29 UG1.AH18 UG1.AH19 UG1.AH20 UG1.AH21 UG1.AH22 UG1.AH23 UG1.AH24 UG1.AH25 UG1.AH26 UG1.AH27 UG1.AH28 UG1.AH29 UG1.AJ19 UG1.AJ20 UG1.AJ21 UG1.AJ22 UG1.AJ23 UG1.AJ24 UG1.AJ25 UG1.AJ26 UG1.AJ27 UG1.AJ28 UG1.T16 UG1.T17 UG1.T20 UG1.T21 UG1.T24 UG1.T25 UG1.U16 UG1.U17 UG1.U20 UG1.U21 UG1.U24 UG1.U25 UG1.V16 UG1.V17 UG1.V20 UG1.V21 UG1.V24 UG1.V25 UG1.V28 UG1.W16 UG1.W17 UG1.W20 UG1.W21 UG1.W24 UG1.W25 UG1.W28 UG1.W29 UG1.Y16 UG1.Y17 UG1.Y20 UG1.Y21 UG1.Y24 UG1.Y25 UG1.Y28 UG1.Y29
+VGA_PCIE: CG21.1 CG22.1 CG23.1 CG24.1 CG25.1 CG26.1 CG27.1 CG28.1 CG29.1 CG30.1 PJP801.2 RG44.1 UG1.AA34 UG1.AA35 UG1.AD36 UG1.AE35 UG1.AF35 UG1.AG36 UG1.AJ30 UG1.AJ35 UG1.AK35 UG1.AM36 UG1.AN35
+VGA_PCIEP: PC804.1 PC805.1 PC809.1 PC815.1 PC816.1 PJP801.1 PL800.2 PR804.1
AC_BATT#: RG39.1 RG40.1 UG1.AJ34 UG4.4
AC_PRESENT: DH1.2 RH533.1 UH1.BB15
ACDET_CHG: PC719.1 PR716.2 PR719.1 PU700.6
ACDRV_CHG: PR705.2 PU700.4
ACIN#: QE3.3 RE17.2 UE1.24
AD0_0: RE43.2 UE3.31
AD0_1: RE27.1 UE4.31
AD0_2: RE164.1 UE8.31
AD1_0: RE40.2 UE3.32
AD1_1: RE26.2 UE4.32
AD1_2: RE163.1 UE8.32
AD2_0: RE42.1 UE3.1
AD2_1: RE29.1 UE4.1
AD2_2: RE165.2 UE8.1
AD3_0: RE44.1 UE3.2
AD3_1: RE30.1 UE4.2
AD3_2: RE162.1 UE8.2
AD_BID: CE28.1 RE64.1 RE66.2 UE5.66
ADP_I: PR23.2 PR717.1 UE5.65
ADPIN: PC1.1 PC2.1 PJPDC1.8 PJPDC1.9 PJPDC1.10 PJPDC1.11 PJPDC1.12 PJPDC1.13 PL1.1 PL3.1
ALIEN_LED_B_DRV#: JLOGO.5 UE3.5
ALIEN_LED_G_DRV#: JLOGO.4 UE3.4
ALIEN_LED_R_DRV#: JLOGO.3 UE3.3
AMD#_NV: UE1.17 UE6.20
AMP_ASEL: RA66.2 RA67.1 UA4.18
AMP_I2S_BCLK: CA38.1 JIO.15 RA29.2 UA4.10
AMP_I2S_BCLK_R: RA29.1 UA1.56
AMP_I2S_MCLK: CA39.1 JIO.14 RA27.2 UA4.9
AMP_I2S_MCLK_R: RA27.1 UA1.55
AMP_LDO_A1.5V: CA77.1 CA78.1 UA4.22
AUD_HP_OUT_L_CN: CA42.1 DA4.3 JACK1.1 LA9.1
AUD_HP_OUT_R_CN: CA43.1 DA4.2 JACK1.2 LA10.1
AUDIO_IRQ: RA24.2 UA1.6
B+: CV15.1 PC10.1 PJP203.1 PJP301.2 PJP504.1 PJP800.1 PJP8200.2 PL100.1 PL500.1 PL701.1 PL6102.1 PQ3.4 PQ703.5 PR12.1 PR702.4 QV1.4 RV9.1
B+_BIAS: JIO.1 PC11.1 PQ3.1 PQ3.2 PQ3.5 PQ3.6 R179.2 RA83.2
B+_VCCIO: PC589.1 PC592.1 PC594.1 PC5025.1 PC5026.1 PJP504.2 PU509.2 PU509.3 PU509.4 PU509.5
BATDRV_CHG: PR733.2 PU700.18
BATLOW#: RT14.1 RT31.2 UT1.F2
BATSRC_CHG: PR734.2 PU700.17
BATT+: PC6.1 PC7.1 PC712.1 PC713.1 PC714.1 PL4.1 PL5.1 PR712.4
BATT++: PBATT1.1 PBATT1.2 PBATT1.3 PBATT1.4 PC8.1 PC9.1 PD700.2 PL4.2 PL5.2
BATT_CHG_LED: QE1.6 RE23.2 UE1.25
BATT_CHG_LED#: QE1.2 UE5.90
BATT_LOW_LED: QE3.6 RE21.2 UE1.22
BATT_LOW_LED#: QE3.2 UE5.93
BATT_PRS: PBATT1.7 PR22.1
BBS_BIT0: RH130.2 UH1.AT29
BEEP#: DA1.2 UE5.23
BKOFF#: DV1.2 UE5.105
BOARD_ID: RH21.1 RH22.1 UH1.AL44
BOOT_1.2V: PR200.2 PU201.18
BST_1.2V: PC204.1 PR200.1
BST_3V: PR108.2 PU100.9
BST_5V: PR109.1 PU100.17
BST_+1VALWP: PR302.1 PU300.10
BST_VCCIO: PR5010.1 PU509.1
BT_OFF#: RH517.2 RN17.2 UH1.AV43
BT_OFF#_R: CN25.1 JWLAN.46 RN16.2 RN17.1
BTST_CHG: PR708.2 PU700.25
BUSPOWER#: RT74.2 UT4.F10
CALDERA_ PWRGD: JCDRA.2 RM42.1 UE6.15
CALDERA_ON: JCDRA.1 RM41.2 UE5.108 UM7.2
CALDERA_PRSNT#: JCDRA.21 RM5.2 RM61.1 UE1.28 UE6.5
CALDERA_RST#: RM6.2 UE6.16 UM3.1
CAPS: JKB.3 RE639.1
CAPS_LED: RE640.1 UE5.91
CDR_BTN#: JCDRA.26 RM17.2 UE5.120
CDR_ON_ELC: UE1.27 UM7.4
CDR_TXRX_GOOD: UE6.18 UM7.1
CDRA_LED RED: JCDRA.28 QM3.1
CDRA_LED RED_MOS: QM2.5 UE5.126
CDRA_LED RED_R: QM3.3 RM93.2
CDRA_LED WHITE: JCDRA.27 QM1.1
CDRA_LED WHITE_MOS: QM2.2 UE5.21
CDRA_LED WHITE_R: QM1.3 RM91.2
CDRA_RST#: JCDRA.22 UM3.4
CFG0: CPU1.BN25 JPCMC.1
CFG1: CPU1.BN27 JPCMC.3
CFG2: CPU1.BN26 JPCMC.5 RH184.1
CFG3: CPU1.BN28 JPCMC.7 JPCMC.23
CFG4: CPU1.BR20 JPCMC.9 RH185.1
CFG5: CPU1.BM20 JPCMC.11 RH186.1
CFG6: CPU1.BT20 JPCMC.13 RH187.1
CFG7: CPU1.BP20 JPCMC.15 RH188.1
CFG8: CPU1.BR23 JPCMC.2
CFG9: CPU1.BR22 JPCMC.4
CFG10: CPU1.BT23 JPCMC.6
CFG11: CPU1.BT22 JPCMC.8
CFG12: CPU1.BM19 JPCMC.10
CFG13: CPU1.BR19 JPCMC.12
CFG14: CPU1.BP19 JPCMC.14
CFG15: CPU1.BT19 JPCMC.16
CFG16: CPU1.BP23 JPCMC.21
CFG17: CPU1.BN23 JPCMC.17
CFG18: CPU1.BN22 JPCMC.20
CFG19: CPU1.BP22 JPCMC.18
CFG_RCOMP: CPU1.BT25 RH59.1
CHG_B+: PC703.1 PC704.1 PC705.1 PC706.1 PC726.1 PC727.1 PL701.2 PQ704.5
CLK_PCI_LPC: RE89.2 RH89.1 UE5.12
CLK_PCIE_DGPU#_C: CM99.2 JCDRA.34
CLK_PCIE_DGPU_C: CM98.2 JCDRA.33
CLK_PCIE_N1: JSSD1.53 UH1.L7
CLK_PCIE_N2: JSSD2.53 UH1.D3
CLK_PCIE_N3: UH1.E5 UT1.T19
CLK_PCIE_N4: UH1.D5 UL1.32
CLK_PCIE_N5: JWLAN.41 UH1.D8
CLK_PCIE_N6: UH1.R8 UM4.3
CLK_PCIE_N7: JSSD3.53 UH1.U5
CLK_PCIE_P1: JSSD1.55 UH1.L5
CLK_PCIE_P2: JSSD2.55 UH1.F2
CLK_PCIE_P3: UH1.G4 UT1.V19
CLK_PCIE_P4: UH1.E6 UL1.33
CLK_PCIE_P5: JWLAN.39 UH1.D7
CLK_PCIE_P6: UH1.R7 UM4.2
CLK_PCIE_P7: JSSD3.55 UH1.U7
CLK_PEG_GPU: UG1.AR42 UH1.N8
CLK_PEG_GPU#: UG1.AR43 UH1.N7
CLK_SMB: PBATT1.5 PR19.1
CLKDET#: RH558.1 UH1.BB22
CLKREQ#_DGPU: RP5.5 UE5.19 UH1.AT33 UM4.17
CLKREQ#_GPU: RG22.1 RG27.1 RP3.5 UH1.BC24
CLKREQ_PCIE#1: JSSD1.52 RP3.6 UH1.AW24
CLKREQ_PCIE#2: JSSD2.52 RP3.7 UH1.AT24
CLKREQ_PCIE#3: RT2.2 RT24.1 UH1.BD25
CLKREQ_PCIE#3_R: RT2.1 RT20.2 UT1.AC5
CLKREQ_PCIE#4: RP3.8 UH1.BB24 UL1.4
CLKREQ_PCIE#5: JWLAN.45 RP5.6 UH1.BE25
CLKREQ_PCIE#7: JSSD3.52 R366.1 UH1.AR31
CLKRUN#: RH85.1 UH1.AW22
CMSRC_CHG: PR706.2 PU700.3
CODEC_MUTE#: DA3.1 JIO.19 RA70.2 UA4.15
CPU_24MHZ_N: CPU1.D31 UH1.F1
CPU_24MHZ_P: CPU1.E31 UH1.G1
CPU_B+: PC539.1 PC542.1 PC543.1 PC544.1 PC545.1 PC546.1 PC547.1 PC551.1 PC552.1 PC553.1 PC554.1 PC555.1 PC559.1 PC560.1 PC561.1 PC562.1 PC563.1 PC565.1 PC568.1 PC569.1 PC571.1 PC572.1 PC575.1 PC576.1 PC577.1 PC578.1 PC579.1 PC581.1 PC582.1 PC583.1 PC584.1 PC585.1 PC5013.1 PC5014.1 PC5015.1 PC5016.1 PC5017.1 PC5018.1 PC5019.1 PC5020.1 PC5021.1 PC5022.1 PC5023.1 PC5024.1 PL500.2 PR506.2 PU502.8 PU502.9 PU503.8 PU503.9 PU504.8 PU504.9 PU507.8 PU507.9 PU510.8 PU510.9 PU511.6
CPU_DDC1CLK: RPT1.3 UH1.BA5 UT1.Y5
CPU_DDC1DATA: RPT1.4 UH1.BC4 UT1.R4
CPU_DDC2CLK: RPT1.1 UH1.BB3 UT1.Y8
CPU_DDC2DATA: RPT1.2 UH1.BD6 UT1.N4
CPU_DDI1HPD: RT38.1 UH1.AW4 UT1.AA2
CPU_DDI2HPD: RT39.1 UH1.AY2 UT1.Y6
CPU_DISPA_BCLK: CPU1.G27 RH38.1
CPU_DISPA_BCLK_R: RH38.2 UH1.AM2
CPU_DISPA_SDI: RC66.2 UH1.AN2
CPU_DISPA_SDI_R: CPU1.G29 RC66.1
CPU_DISPA_SDO: CPU1.G25 RH39.1
CPU_DISPA_SDO_R: RH39.2 UH1.AM1
CPU_DP1_AUXN: CPU1.E27 CT26.1
CPU_DP1_AUXN_C: CT26.2 RT76.1 UT1.W11
CPU_DP1_AUXP: CPU1.D27 CT25.1
CPU_DP1_AUXP_C: CT25.2 RT78.1 UT1.Y11
CPU_DP1_N0: CPU1.K37 CT7.1
CPU_DP1_N0_C: CT7.2 UT1.AC7
CPU_DP1_N1: CPU1.J34 CT9.1
CPU_DP1_N1_C: CT9.2 UT1.AC9
CPU_DP1_N2: CPU1.H36 CT23.1
CPU_DP1_N2_C: CT23.2 UT1.AC11
CPU_DP1_N3: CPU1.J38 CT24.1
CPU_DP1_N3_C: CT24.2 UT1.AC13
CPU_DP1_P0: CPU1.K36 CT6.1
CPU_DP1_P0_C: CT6.2 UT1.AB7
CPU_DP1_P1: CPU1.J35 CT8.1
CPU_DP1_P1_C: CT8.2 UT1.AB9
CPU_DP1_P2: CPU1.H37 CT10.1
CPU_DP1_P2_C: CT10.2 UT1.AB11
CPU_DP1_P3: CPU1.J37 CT11.1
CPU_DP1_P3_C: CT11.2 UT1.AB13
CPU_DP2_AUXN: CPU1.E26 CT36.1
CPU_DP2_AUXN_C: CT36.2 RT77.1 UT1.W12
CPU_DP2_AUXP: CPU1.F26 CT35.1
CPU_DP2_AUXP_C: CT35.2 RT79.1 UT1.Y12
CPU_DP2_N0: CPU1.H33 CT28.1
CPU_DP2_N0_C: CT28.2 UT1.AC15
CPU_DP2_N1: CPU1.G38 CT30.1
CPU_DP2_N1_C: CT30.2 UT1.AC17
CPU_DP2_N2: CPU1.F35 CT32.1
CPU_DP2_N2_C: CT32.2 UT1.AC19
CPU_DP2_N3: CPU1.E36 CT34.1
CPU_DP2_N3_C: CT34.2 UT1.AC21
CPU_DP2_P0: CPU1.H34 CT27.1
CPU_DP2_P0_C: CT27.2 UT1.AB15
CPU_DP2_P1: CPU1.F37 CT29.1
CPU_DP2_P1_C: CT29.2 UT1.AB17
CPU_DP2_P2: CPU1.F34 CT31.1
CPU_DP2_P2_C: CT31.2 UT1.AB19
CPU_DP2_P3: CPU1.E37 CT33.1
CPU_DP2_P3_C: CT33.2 UT1.AB21
CPU_EDP_AUX: CPU1.C26 CV434.2
CPU_EDP_AUX#: CPU1.B26 CV435.2
CPU_EDP_AUX#_C: CV435.1 UV21.29
CPU_EDP_AUX_C: CV434.1 UV21.30
CPU_EDP_N0_C: CV427.1 UV21.12
CPU_EDP_N1_C: CV429.1 UV21.15
CPU_EDP_N2_C: CV431.1 UV21.17
CPU_EDP_N3_C: CV433.1 UV21.20
CPU_EDP_P0_C: CV426.1 UV21.11
CPU_EDP_P1_C: CV428.1 UV21.14
CPU_EDP_P2_C: CV430.1 UV21.16
CPU_EDP_P3_C: CV432.1 UV21.19
CPU_EDP_TX0N: CPU1.E29 CV427.2
CPU_EDP_TX0P: CPU1.D29 CV426.2
CPU_EDP_TX1N: CPU1.E28 CV429.2
CPU_EDP_TX1P: CPU1.F28 CV428.2
CPU_EDP_TX2N: CPU1.B29 CV431.2
CPU_EDP_TX2P: CPU1.A29 CV430.2
CPU_EDP_TX3N: CPU1.B28 CV433.2
CPU_EDP_TX3P: CPU1.C28 CV432.2
CPU_FAN_FB: DF1.2 RF1.1 UE5.28
CPU_FAN_PWM: JFAN1.2 RF2.1 UE5.26
CPU_ID: RH23.1 RH24.1 UH1.AL35
CPU_TRIGGER: RH192.1 UH1.AK1
CPU_XDP_TRST#: CPU1.BP30 JPCMC.28 RH497.2 UH1.AY5
CRX_N8: JCDRA.16 UM8.42
CRX_N9: JCDRA.19 UM8.37
CRX_N10: JCDRA.25 UM8.39
CRX_N11: JCDRA.31 UM8.44
CRX_P8: JCDRA.15 UM8.43
CRX_P9: JCDRA.18 UM8.38
CRX_P10: JCDRA.24 UM8.40
CRX_P11: JCDRA.30 UM8.45
CS1: PR106.2 PU100.1
CS2: PR105.2 PU100.5
CS_1.2V: PR201.2 PU201.13
CSN1: PL6101.3 PR6013.2 PR6057.1
CSN2: PL6200.3 PR6033.2 PR6054.1
CSN3: PL6201.3 PR6020.2 PR6058.1
CSN4: PL6300.3 PR6026.2 PR6055.1
CSN_VDDCI: PL6400.3 PR6064.1
CSON_1: PC717.2 PC721.1 PR712.3 PR723.2
CSOP_1: PC716.2 PC717.1 PR712.2 PR722.2
CSP1: PL6101.2 PR6015.1 PR6046.2
CSP2: PL6200.2 PR6021.1 PR6040.2
CSP3: PL6201.2 PR6022.1 PR6048.2
CSP4: PL6300.2 PR6029.1 PR6044.2
CSP_VDDCI: PL6400.2 PR6066.2 PR6068.1
CSSN_1: PR702.3 PR704.1
CSSN_2: PC708.2 PC709.1 PR704.2 PU700.1
CSSP_1: PR702.2 PR703.1
CSSP_2: PC707.2 PC708.1 PR703.2 PU700.2
CTL1: UE6.7 UU1.6
CTL2: UE6.8 UU1.7
DAT_SMB: PBATT1.6 PR21.1
DBGDATA_6: RG166.2 RG169.1 UG1.AT20
DBGDATA_7: RG167.1 RG168.2 UG1.AY20
DDR4_DRAMRST#: CD91.1 CD92.1 JDIMM1.108 JDIMM2.108 RD31.1
DDR_A_ACT#: CPU1.AU3 JDIMM1.114
DDR_A_ALERT#: CPU1.AU5 JDIMM1.116
DDR_A_BG0: CPU1.AU1 JDIMM1.115
DDR_A_BG1: CPU1.AU2 JDIMM1.113
DDR_A_BS0: CPU1.AH5 JDIMM1.150
DDR_A_BS1: CPU1.AH1 JDIMM1.145
DDR_A_CAS#: CPU1.AD1 JDIMM1.156
DDR_A_D0: CPU1.BR6 JDIMM1.4
DDR_A_D1: CPU1.BT6 JDIMM1.3
DDR_A_D2: CPU1.BP3 JDIMM1.20
DDR_A_D3: CPU1.BR3 JDIMM1.17
DDR_A_D4: CPU1.BN5 JDIMM1.8
DDR_A_D5: CPU1.BP6 JDIMM1.7
DDR_A_D6: CPU1.BP2 JDIMM1.16
DDR_A_D7: CPU1.BN3 JDIMM1.21
DDR_A_D8: CPU1.BL4 JDIMM1.29
DDR_A_D9: CPU1.BL5 JDIMM1.25
DDR_A_D10: CPU1.BL2 JDIMM1.41
DDR_A_D11: CPU1.BM1 JDIMM1.42
DDR_A_D12: CPU1.BK4 JDIMM1.24
DDR_A_D13: CPU1.BK5 JDIMM1.28
DDR_A_D14: CPU1.BK1 JDIMM1.38
DDR_A_D15: CPU1.BK2 JDIMM1.37
DDR_A_D16: CPU1.BG4 JDIMM1.45
DDR_A_D17: CPU1.BG5 JDIMM1.49
DDR_A_D18: CPU1.BF4 JDIMM1.63
DDR_A_D19: CPU1.BF5 JDIMM1.59
DDR_A_D20: CPU1.BG2 JDIMM1.50
DDR_A_D21: CPU1.BG1 JDIMM1.46
DDR_A_D22: CPU1.BF1 JDIMM1.62
DDR_A_D23: CPU1.BF2 JDIMM1.58
DDR_A_D24: CPU1.BD2 JDIMM1.67
DDR_A_D25: CPU1.BD1 JDIMM1.70
DDR_A_D26: CPU1.BC4 JDIMM1.79
DDR_A_D27: CPU1.BC5 JDIMM1.83
DDR_A_D28: CPU1.BD5 JDIMM1.66
DDR_A_D29: CPU1.BD4 JDIMM1.71
DDR_A_D30: CPU1.BC1 JDIMM1.80
DDR_A_D31: CPU1.BC2 JDIMM1.84
DDR_A_D32: CPU1.AB1 JDIMM1.174
DDR_A_D33: CPU1.AB2 JDIMM1.169
DDR_A_D34: CPU1.AA4 JDIMM1.186
DDR_A_D35: CPU1.AA5 JDIMM1.182
DDR_A_D36: CPU1.AB5 JDIMM1.170
DDR_A_D37: CPU1.AB4 JDIMM1.173
DDR_A_D38: CPU1.AA2 JDIMM1.183
DDR_A_D39: CPU1.AA1 JDIMM1.187
DDR_A_D40: CPU1.V5 JDIMM1.190
DDR_A_D41: CPU1.V2 JDIMM1.195
DDR_A_D42: CPU1.U1 JDIMM1.207
DDR_A_D43: CPU1.U2 JDIMM1.203
DDR_A_D44: CPU1.V1 JDIMM1.191
DDR_A_D45: CPU1.V4 JDIMM1.194
DDR_A_D46: CPU1.U5 JDIMM1.208
DDR_A_D47: CPU1.U4 JDIMM1.204
DDR_A_D48: CPU1.R2 JDIMM1.211
DDR_A_D49: CPU1.P5 JDIMM1.228
DDR_A_D50: CPU1.R4 JDIMM1.212
DDR_A_D51: CPU1.P4 JDIMM1.224
DDR_A_D52: CPU1.R5 JDIMM1.216
DDR_A_D53: CPU1.P2 JDIMM1.225
DDR_A_D54: CPU1.R1 JDIMM1.215
DDR_A_D55: CPU1.P1 JDIMM1.229
DDR_A_D56: CPU1.M4 JDIMM1.233
DDR_A_D57: CPU1.M1 JDIMM1.236
