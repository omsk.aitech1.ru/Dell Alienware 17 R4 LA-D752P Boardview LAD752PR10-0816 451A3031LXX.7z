# Allegro board LAD752PR10-0816.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_B_D37: length 66.2
  IN1 w0.089: v1(158.89,98.47) 158.95,98.41 158.95,98.3 159.38,97.86 159.38,96.94 159.78,96.55 159.78,91.53 162.87,88.44 162.87,83.85
  IN1 w0.097: 162.87,83.85 162.87,71.39 159.55,68.07 159.55,58.59 160.1,58.03 160.1,53.89 159.59,53.38 159.59,49.98 158.95,49.34 158.95,47.91 158.59,47.56 158.59,42.01 158.69,41.91 159.01,41.91 159.14,42.03 159.14,42.39 159.28,42.53 v1(159.63,42.53)
  BOTTOM w0.076: v1(158.89,98.47) CPU1.AA8
  BOTTOM w0.107: v1(159.63,42.53) 160.09,42.07 160.09,40.84 159.95,40.7 159.95,39 JDIMM2.186
DDR_B_D38: length 65.7
  IN1 w0.089: 160.92,83.85 160.92,88.14 158.2,90.85 158.2,97.04 157.61,97.63 157.61,98.1 v1(157.98,98.47)
  IN1 w0.097: v1(156.46,43.78) 155.82,44.43 155.82,45.2 155.92,45.3 156.1,45.3 156.2,45.4 156.2,45.59 156.1,45.69 155.92,45.69 155.82,45.79 155.82,45.99 155.92,46.09 156.03,46.09 156.13,46.19 156.13,46.39 156.03,46.49 155.92,46.49 155.82,46.59 155.82,47.29 156.68,48.15 156.68,50.58 157.36,51.26 157.36,68.57 160.59,71.79 160.59,79.61 160.92,79.94 160.92,81.45 160.82,81.55 160.69,81.55 160.59,81.65 160.59,81.84 160.69,81.94 160.82,81.94 160.92,82.04 160.92,82.24 160.82,82.34 160.69,82.34 160.59,82.44 160.59,82.64 160.69,82.74 160.82,82.74 160.92,82.83 160.92,83.03 160.82,83.13 160.69,83.13 160.59,83.23 160.59,83.43 160.69,83.53 160.82,83.53 160.92,83.63 160.92,83.85
  BOTTOM w0.076: v1(157.98,98.47) CPU1.AC8
  BOTTOM w0.107: JDIMM2.169 155.69,46.14 155.46,45.91 155.46,44.16 155.84,43.78 v1(156.46,43.78)
DDR_B_D39: length 65.6
  IN1 w0.089: 161.22,83.85 161.22,88.09 158.41,90.9 158.41,97.13 157.98,97.55 v1(157.98,97.91)
  IN1 w0.097: v1(156.46,45.05) 156.46,45.24 156.56,45.34 156.82,45.34 156.92,45.43 156.92,45.64 156.82,45.73 156.49,45.73 156.39,45.83 156.39,46.03 156.49,46.13 156.69,46.13 156.79,46.23 156.79,46.42 156.69,46.51 156.51,46.51 156.41,46.61 156.41,47.45 156.98,48.02 156.98,49.74 157.67,50.42 157.67,51.06 157.77,51.16 157.92,51.16 158.02,51.26 158.02,51.45 157.92,51.55 157.77,51.55 157.67,51.65 157.67,53.84 157.77,53.94 157.92,53.94 158.02,54.04 158.02,54.24 157.92,54.34 157.77,54.34 157.67,54.44 157.67,54.64 157.77,54.73 157.92,54.73 158.02,54.83 158.02,55.03 157.92,55.13 157.77,55.13 157.67,55.23 157.67,68.44 161.22,72 161.22,72.55 161.12,72.65 160.99,72.65 160.89,72.75 160.89,72.95 160.99,73.05 161.12,73.05 161.22,73.15 161.22,73.34 161.12,73.44 160.99,73.44 160.89,73.54 160.89,73.74 160.99,73.84 161.12,73.84 161.22,73.94 161.22,74.14 161.12,74.24 160.99,74.24 160.89,74.33 160.89,74.53 160.99,74.63 161.12,74.63 161.22,74.73 161.22,74.93 161.12,75.03 160.99,75.03 160.89,75.13 160.89,75.33 160.99,75.42 161.12,75.42 161.22,75.52 161.22,75.72 161.12,75.82 160.99,75.82 160.89,75.92 160.89,76.12 160.99,76.22 161.12,76.22 161.22,76.32 161.22,76.51 161.12,76.61 160.99,76.61 160.89,76.71 160.89,76.91 160.99,77.01 161.12,77.01 161.22,77.11 161.22,77.31 161.12,77.41 160.99,77.41 160.89,77.5 160.89,77.7 160.99,77.8 161.12,77.8 161.22,77.9 161.22,78.1 161.12,78.2 160.99,78.2 160.89,78.3 160.89,78.5 160.99,78.59 161.12,78.59 161.22,78.69 161.22,78.89 161.12,78.99 160.99,78.99 160.89,79.09 160.89,79.29 160.99,79.39 161.12,79.39 161.22,79.49 161.22,83.85
  BOTTOM w0.107: v1(156.46,45.05) 156.46,45.49 156.69,45.72 JDIMM2.173
  BOTTOM w0.127: v1(157.98,97.91) 157.56,97.5 CPU1.AC7
DDR_B_D40: length 66.2
  IN1 w0.089: 164.84,83.85 164.84,87.96 160.8,92 160.8,96.79 160.33,97.25 160.33,97.54 v1(160.72,97.93)
  IN1 w0.097: 164.84,83.85 164.84,70.64 161.91,67.7 161.91,64.55 162.01,64.45 162.49,64.45 162.59,64.36 162.59,64.11 162.49,64.01 162.01,64.01 161.91,63.92 161.91,63.67 162.01,63.57 162.49,63.57 162.59,63.47 162.59,63.22 162.49,63.13 161.99,63.13 161.91,63.04 161.91,62.8 162.01,62.71 162.49,62.71 162.59,62.61 162.59,60.68 162.49,60.59 162.01,60.59 161.91,60.49 161.91,60.29 162.01,60.19 162.49,60.19 162.59,60.09 162.59,59.89 162.49,59.79 162.01,59.79 161.91,59.69 161.91,59.5 162.01,59.4 162.49,59.4 162.59,59.3 162.59,58.56 162.8,58.35 162.8,53.83 162.52,53.55 162.52,48.07 162.42,47.97 162.16,47.97 162.06,47.87 162.06,47.67 162.16,47.57 162.42,47.57 162.52,47.47 162.52,47.25 162.42,47.15 161.84,47.15 161.74,47.05 161.74,46.84 161.84,46.74 162.26,46.74 162.36,46.65 162.36,46.38 161.66,45.69 v1(161.66,45.13)
  BOTTOM w0.076: CPU1.W8 160.51,98.15 v1(160.72,97.93)
  BOTTOM w0.107: v1(161.66,45.13) 161.2,45.6 JDIMM2.191
DDR_B_D41: length 66
  IN1 w0.089: v1(160.72,97.37) 160.98,97.12 160.98,92.08 165.14,87.91 165.14,83.85
  IN1 w0.097: 165.14,83.85 165.14,70.36 162.89,68.1 162.89,67.63 162.79,67.53 162.4,67.53 162.31,67.43 162.31,67.23 162.4,67.13 162.79,67.13 162.89,67.03 162.89,66.83 162.79,66.74 162.31,66.74 162.21,66.64 162.21,66.44 162.31,66.34 162.79,66.34 162.89,66.24 162.89,66.04 162.79,65.94 162.31,65.94 162.21,65.84 162.21,65.65 162.31,65.55 162.79,65.55 162.89,65.45 162.89,65.25 162.79,65.15 162.31,65.15 162.21,65.05 162.21,64.85 162.31,64.75 162.79,64.75 162.89,64.66 162.89,58.71 163.1,58.49 163.1,53.7 162.82,53.42 162.82,46.42 162.25,45.85 162.25,43.72 162.13,43.6 161.93,43.6 v1(161.66,43.86)
  BOTTOM w0.076: CPU1.W7 160.6,97.5 v1(160.72,97.37)
  BOTTOM w0.107: v1(161.66,43.86) 162.2,44.39 JDIMM2.195
DDR_B_D42: length 66.6
  IN1 w0.089: 166.95,84.06 166.95,87.66 167.08,87.79 167.08,88.29 162.54,92.83 162.54,96.97 162.2,97.31 162.2,98.03 162,98.22 162,99.37 v1(161.6,99.77)
  IN1 w0.097: v1(165.34,43.8) 164.85,44.28 164.85,47.82 165.25,48.22 165.25,53.4 165.75,53.89 165.75,58.03 165.24,58.54 165.24,65.11 165.34,65.2 165.65,65.2 165.75,65.3 165.75,65.49 165.65,65.59 165.34,65.59 165.24,65.69 165.24,65.88 165.34,65.98 165.65,65.98 165.75,66.07 165.75,66.27 165.65,66.36 165.34,66.36 165.24,66.46 165.24,66.65 165.34,66.75 165.65,66.75 165.75,66.85 165.75,67.04 165.65,67.13 165.34,67.13 165.24,67.23 165.24,67.46 166.95,69.17 166.95,84.06
  BOTTOM w0.076: CPU1.V10 161.18,99.47 v1(161.6,99.77)
  BOTTOM w0.107: JDIMM2.203 164.19,44.94 v1(165.34,43.8)
DDR_B_D43: length 66.3
  IN1 w0.089: 167.32,84.42 167.32,85.23 167.71,85.62 167.71,87.6 167.33,87.98 167.33,88.29 162.72,92.91 162.72,97.04 162.49,97.27 162.49,98.08 162.18,98.38 162.18,99.85 v1(161.61,100.42)
  IN1 w0.097: v1(165.34,45.07) 165.49,45.22 165.49,47.97 165.55,48.04 165.55,53.27 166.05,53.76 166.05,60.4 165.95,60.5 165.64,60.5 165.54,60.6 165.54,60.79 165.64,60.89 165.95,60.89 166.05,60.98 166.05,61.21 165.95,61.3 165.64,61.3 165.54,61.4 165.54,61.59 165.64,61.69 165.95,61.69 166.05,61.79 166.05,61.98 165.95,62.08 165.64,62.08 165.54,62.17 165.54,62.36 165.64,62.46 165.95,62.46 166.05,62.56 166.05,62.75 165.95,62.85 165.64,62.85 165.54,62.94 165.54,63.14 165.64,63.23 165.95,63.23 166.05,63.33 166.05,63.55 165.95,63.65 165.64,63.65 165.54,63.75 165.54,63.94 165.64,64.04 165.95,64.04 166.05,64.13 166.05,64.33 165.95,64.42 165.64,64.42 165.54,64.52 165.54,64.71 165.64,64.81 165.95,64.81 166.05,64.9 166.05,67.84 167.32,69.11 167.32,84.42
  BOTTOM w0.076: v1(161.61,100.42) 161.18,100.12 CPU1.V11
  BOTTOM w0.107: JDIMM2.207 165.19,45.21 v1(165.34,45.07)
DDR_B_D44: length 66.5
  IN1 w0.089: v1(160.72,99.77) 160.29,99.34 160.29,98.14 160.14,97.99 160.14,97.19 160.6,96.74 160.6,91.95 164.54,88.01 164.54,83.85
  IN1 w0.097: 164.54,83.85 164.54,70.76 161.61,67.83 161.61,62.65 162.15,62.11 162.15,61.14 161.87,60.87 161.72,60.87 161.61,60.76 161.61,58.99 162.5,58.1 162.5,53.95 162.22,53.67 162.22,48.45 161.26,47.5 161.26,43 v1(161.66,42.59)
  BOTTOM w0.076: CPU1.W11 160.4,100.1 v1(160.72,99.77)
  BOTTOM w0.107: JDIMM2.190 160.94,41.87 v1(161.66,42.59)
DDR_B_D45: length 66.5
  IN1 w0.089: v1(159.82,99.23) 159.96,99.09 159.96,97.12 160.39,96.69 160.39,91.9 164.24,88.06 164.24,83.85
  IN1 w0.097: v1(161.66,41.32) 160.96,42.03 160.96,48.02 161.21,48.27 161.21,49.69 161.92,50.39 161.92,52.06 161.82,52.15 161.56,52.15 161.46,52.25 161.46,52.44 161.56,52.54 161.82,52.54 161.92,52.64 161.92,52.83 161.82,52.93 161.56,52.93 161.46,53.02 161.46,53.22 161.56,53.31 161.82,53.31 161.92,53.41 161.92,53.8 162.19,54.08 162.19,57.97 161.31,58.86 161.31,67.95 164.24,70.88 164.24,83.85
  BOTTOM w0.076: CPU1.W10 160.04,99.45 v1(159.82,99.23)
  BOTTOM w0.107: v1(161.66,41.32) 161.94,41.04 JDIMM2.194
DDR_B_D46: length 66.5
  IN1 w0.089: 166.35,83.85 166.35,87.67 161.55,92.47 161.55,97.73 v1(161.64,97.82)
  IN1 w0.097: v1(165.34,41.26) 164.52,41.26 164.09,41.69 164.09,47.91 164.62,48.44 164.62,59.68 164.09,60.21 164.09,64.04 164.19,64.13 164.44,64.13 164.54,64.23 164.54,64.42 164.44,64.52 164.19,64.52 164.09,64.62 164.09,64.81 164.19,64.91 164.44,64.91 164.54,65 164.54,65.2 164.44,65.29 164.19,65.29 164.09,65.39 164.09,65.58 164.19,65.68 164.44,65.68 164.54,65.78 164.54,65.97 164.44,66.06 164.19,66.06 164.09,66.16 164.09,66.35 164.19,66.45 164.44,66.45 164.54,66.55 164.54,66.74 164.44,66.84 164.19,66.84 164.09,66.93 164.09,67.16 166.35,69.42 166.35,83.85
  BOTTOM w0.076: v1(161.64,97.82) CPU1.V7
  BOTTOM w0.107: JDIMM2.208 165.44,41.15 v1(165.34,41.26)
DDR_B_D47: length 66.5
  IN1 w0.089: 166.65,83.85 166.65,87.61 166.89,87.85 166.89,88.23 162.35,92.77 162.35,96.9 162.02,97.22 162.02,97.96 161.64,98.34 v1(161.64,98.47)
  IN1 w0.097: v1(165.34,42.53) 164.47,43.39 164.47,47.87 164.92,48.31 164.92,60.33 164.82,60.42 164.51,60.42 164.41,60.52 164.41,60.71 164.51,60.81 164.85,60.81 164.94,60.91 164.94,62.58 164.85,62.68 164.49,62.68 164.39,62.78 164.39,62.97 164.49,63.07 164.85,63.07 164.94,63.16 164.94,63.35 164.85,63.45 164.49,63.45 164.39,63.55 164.39,63.74 164.49,63.84 164.85,63.84 164.94,63.93 164.94,67.58 166.65,69.29 166.65,83.85
  BOTTOM w0.076: v1(161.64,98.47) CPU1.V8
  BOTTOM w0.107: v1(165.34,42.53) 164.44,41.63 JDIMM2.204
DDR_B_D48: length 65.7
  IN1 w0.089: v1(163.47,100.42) 163.07,100.03 163.07,99.63 162.92,99.48 162.92,98.3 162.74,98.12 162.74,97.48 163.1,97.13 163.1,92.78 168.05,87.83 168.05,85.16
  IN1 w0.097: v1(167.18,41.32) 166.25,42.25 166.25,47.79 166.72,48.26 166.72,52.88 166.78,52.95 166.78,66.29 168.05,67.55 168.05,85.16
  BOTTOM w0.076: v1(163.47,100.42) CPU1.R11
  BOTTOM w0.107: v1(167.18,41.32) 167.44,41.06 JDIMM2.216
DDR_B_D49: length 66
  IN1 w0.089: 170.94,88.11 165.66,93.4 165.66,96.05 165.1,96.61 165.1,98.64 164.93,98.82 164.93,99.88 v1(164.38,100.42)
  IN1 w0.097: 170.94,88.11 171.86,87.19 171.86,59.23 171.81,59.19 171.81,53.62 171.17,52.97 171.17,46.69 171.51,46.35 171.51,41.96 v1(170.8,41.26)
  BOTTOM w0.076: v1(164.38,100.42) CPU1.P11
  BOTTOM w0.107: JDIMM2.228 170.44,40.9 v1(170.8,41.26)
DDR_B_D50: length 65.4
  IN1 w0.089: 170.26,87.37 170.26,88.04 165.01,93.29 165.01,95.94 164.38,96.58 v1(164.38,97.82)
  IN1 w0.097: v1(170.8,43.8) 170.39,43.8 170.25,43.66 170.25,42.96 170.13,42.83 169.78,42.83 169.68,42.93 169.68,44.82 170.06,45.2 170.06,46.26 169.55,46.77 169.55,48.12 169.89,48.46 169.89,49.3 169.79,49.4 169.65,49.4 169.55,49.5 169.55,49.7 169.65,49.8 169.79,49.8 169.89,49.9 169.89,50.45 170.26,50.82 170.26,51.7 169.68,52.28 169.68,54.01 170.4,54.72 170.4,67.96 170.26,68.1 170.26,87.37
  BOTTOM w0.076: v1(164.38,97.82) CPU1.P7
  BOTTOM w0.107: v1(170.8,43.8) 169.69,44.9 JDIMM2.225
DDR_B_D51: length 65.4
  IN1 w0.089: v1(163.47,98.47) 163.47,98.34 163.1,97.97 163.1,97.63 163.45,97.27 163.45,92.92 168.76,87.62 168.76,85.87
  IN1 w0.097: v1(167.18,45.13) 166.89,45.43 166.89,46.22 167.05,46.39 167.87,46.39 167.97,46.49 167.97,46.7 167.87,46.8 167.27,46.8 167.17,46.9 167.17,47.09 167.27,47.19 167.87,47.19 167.97,47.29 167.97,47.49 167.87,47.59 167.52,47.59 167.42,47.69 167.42,47.89 167.52,47.98 167.87,47.98 167.97,48.08 167.97,48.83 167.87,48.93 167.52,48.93 167.42,49.03 167.42,49.23 167.52,49.33 167.71,49.33 167.97,49.59 167.97,57.56 168.09,57.68 168.09,62.66 168.19,62.76 168.36,62.76 168.46,62.85 168.46,63.04 168.36,63.14 168.19,63.14 168.09,63.24 168.09,63.43 168.19,63.53 168.36,63.53 168.46,63.62 168.46,63.82 168.36,63.91 168.19,63.91 168.09,64.01 168.09,64.24 168.19,64.34 168.35,64.34 168.45,64.43 168.45,64.62 168.35,64.72 168.19,64.72 168.09,64.82 168.09,65.01 168.19,65.11 168.35,65.11 168.45,65.2 168.45,65.4 168.35,65.49 168.19,65.49 168.09,65.59 168.09,65.78 168.19,65.88 168.35,65.88 168.45,65.98 168.45,66.17 168.35,66.27 168.19,66.27 168.09,66.36 168.09,66.56 168.19,66.65 168.35,66.65 168.45,66.75 168.45,67.11 168.76,67.41 168.76,85.87
  BOTTOM w0.076: v1(163.47,98.47) CPU1.R8
  BOTTOM w0.107: JDIMM2.215 167.19,46.07 v1(167.18,45.13)
DDR_B_D52: length 66.1
  IN1 w0.089: 168.35,85.46 168.35,87.78 163.28,92.85 163.28,97.2 162.92,97.56 162.92,98.05 163.1,98.23 163.1,99.4 v1(163.47,99.77)
  IN1 w0.097: 168.35,85.46 168.35,70.32 168.35,70.32 168.35,67.43 167.79,66.87 167.79,58.02 167.67,57.9 167.67,52.63 167.57,52.54 167.11,52.54 167.02,52.44 167.02,52.24 167.11,52.14 167.57,52.14 167.67,52.04 167.67,51.84 167.57,51.74 167.11,51.74 167.02,51.64 167.02,51.45 167.11,51.35 167.57,51.35 167.67,51.25 167.67,51 167.6,50.92 167.22,50.92 167.12,50.82 167.12,48.24 166.55,47.67 166.55,44.49 v1(167.18,43.86)
  BOTTOM w0.076: v1(163.47,99.77) CPU1.R10
  BOTTOM w0.107: v1(167.18,43.86) 166.19,44.85 JDIMM2.211
DDR_B_D53: length 65.8
  IN1 w0.089: v1(164.38,99.77) 164.75,99.4 164.75,98.75 164.93,98.57 164.93,96.53 165.42,96.04 165.42,93.38 170.76,88.04 170.76,87.87
  IN1 w0.097: v1(170.8,42.53) 171.21,42.93 171.21,46.22 170.87,46.56 170.87,53.1 171.51,53.74 171.51,58.46 171,58.97 171,67.33 171.51,67.84 171.51,87.12 170.76,87.87
  BOTTOM w0.076: v1(164.38,99.77) CPU1.P10
  BOTTOM w0.107: JDIMM2.224 169.44,41.17 v1(170.8,42.53)
DDR_B_D54: length 65.7
  IN1 w0.089: 169.06,86.17 169.06,87.57 163.63,93 163.63,97.66 v1(163.47,97.82)
  IN1 w0.097: v1(167.18,42.59) 167.6,42.59 167.71,42.7 167.71,45.41 168.27,45.97 168.27,57.43 168.39,57.55 168.39,58.32 168.49,58.42 168.7,58.42 168.79,58.52 168.79,58.71 168.7,58.81 168.49,58.81 168.39,58.9 168.39,59.13 168.49,59.22 168.63,59.22 168.73,59.32 168.73,59.51 168.63,59.61 168.49,59.61 168.39,59.7 168.39,59.93 168.51,60.05 168.66,60.05 168.76,60.14 168.76,60.34 168.66,60.43 168.49,60.43 168.39,60.53 168.39,60.72 168.49,60.82 168.66,60.82 168.76,60.91 168.76,61.11 168.66,61.2 168.49,61.2 168.39,61.3 168.39,61.49 168.49,61.59 168.66,61.59 168.76,61.69 168.76,61.88 168.66,61.98 168.49,61.98 168.39,62.07 168.39,62.27 168.49,62.36 168.66,62.36 168.76,62.46 168.76,66.99 169.06,67.29 169.06,86.17
  BOTTOM w0.076: v1(163.47,97.82) CPU1.R7
  BOTTOM w0.107: JDIMM2.212 166.44,41.85 v1(167.18,42.59)
DDR_B_D55: length 65.4
  IN1 w0.089: v1(164.38,98.47) 164.75,98.1 164.75,96.46 165.22,95.99 165.22,93.34 170.55,88 170.55,87.66
  IN1 w0.097: v1(170.8,45.07) 170.56,45.07 170.44,45.18 170.44,45.46 170.54,45.56 170.81,45.56 170.91,45.66 170.91,45.85 170.81,45.95 170.67,45.95 170.51,46.11 170.51,46.67 170.33,46.85 169.95,46.85 169.85,46.95 169.85,47.15 169.95,47.25 170.47,47.25 170.56,47.35 170.56,47.54 170.47,47.64 169.95,47.64 169.85,47.74 169.85,47.94 169.95,48.04 170.47,48.04 170.56,48.14 170.56,48.43 170.47,48.53 170.29,48.53 170.19,48.62 170.19,48.82 170.29,48.92 170.47,48.92 170.56,49.02 170.56,49.22 170.47,49.32 170.29,49.32 170.19,49.42 170.19,49.62 170.29,49.71 170.47,49.71 170.56,49.81 170.56,52.16 170.44,52.29 170.16,52.29 170.06,52.39 170.06,52.64 170.16,52.74 170.47,52.74 170.56,52.84 170.56,53.1 170.47,53.2 170.09,53.2 170,53.29 170,53.56 170.09,53.65 170.97,53.65 171.21,53.89 171.21,58.32 170.7,58.83 170.7,68.08 170.56,68.22 170.56,87.65 170.55,87.66
  BOTTOM w0.076: v1(164.38,98.47) CPU1.P8
  BOTTOM w0.107: JDIMM2.229 170.69,45.17 v1(170.8,45.07)
DDR_B_D56: length 67.8
  IN1 w0.089: 173.77,90.87 172.68,91.96 170.83,91.96 169.74,93.05 169.74,93.87 169.97,94.1 169.97,94.78 169.41,95.34 169.41,96.76 168.47,97.7 168.47,97.96 167.69,98.74 167.69,99.5 167.56,99.63 167.56,99.95 v1(167.09,100.42)
  IN1 w0.097: v1(176.83,43.8) 177.66,44.62 177.66,53.14 177.47,53.33 177.47,59.57 177.9,60 177.9,63.63 176.79,64.74 176.79,86.99 176.05,87.73 176.05,88.59 173.77,90.87
  BOTTOM w0.076: v1(167.09,100.42) CPU1.L11
  BOTTOM w0.107: JDIMM2.245 174.69,45.94 v1(176.83,43.8)
DDR_B_D57: length 67.9
  IN1 w0.089: v1(166.21,100.42) 165.66,99.87 165.66,98.9 165.55,98.79 165.55,96.51 166.01,96.05 166.01,93.45 168.36,91.09
  IN1 w0.097: 168.36,91.09 168.99,91.09 172.59,87.5 172.59,61.13 172.85,60.88 173.11,60.88 173.21,60.78 173.21,60.59 173.11,60.49 172.85,60.49 172.75,60.39 172.75,60.2 172.85,60.1 173.11,60.1 173.21,60.01 173.21,59.81 173.11,59.72 172.85,59.72 172.75,59.62 172.75,58.6 172.75,58.6 172.75,53.51 172.16,52.92 172.16,46.69 172.4,46.45 172.4,43.86 172.67,43.59 172.67,41.74 v1(173.15,41.26)
  BOTTOM w0.076: v1(166.21,100.42) CPU1.M11
  BOTTOM w0.107: v1(173.15,41.26) 172.44,40.55 JDIMM2.236
DDR_B_D58: length 67.9
  IN1 w0.089: 173.13,90.24 172.09,91.28 170.76,91.28 168.16,93.87 168.16,96.58 167.08,97.67 v1(167.08,97.91)
  IN1 w0.097: v1(176.83,41.26) 175.97,42.12 175.97,49.5 175.87,49.6 175.49,49.6 175.4,49.7 175.4,49.9 175.49,50 175.87,50 175.96,50.1 175.96,50.81 175.87,50.91 175.55,50.91 175.45,51.01 175.45,51.21 175.55,51.31 175.87,51.31 175.96,51.4 175.96,51.6 175.87,51.7 175.55,51.7 175.45,51.8 175.45,52 175.55,52.1 175.87,52.1 175.97,52.2 175.97,59.72 176.49,60.24 176.49,63.64 175.81,64.32 175.81,86.7 175.15,87.36 175.15,88.22 173.13,90.24
  BOTTOM w0.076: CPU1.L7 166.59,97.55 v1(167.08,97.91)
  BOTTOM w0.107: JDIMM2.250 175.95,39 175.95,40.69 176.51,41.26 v1(176.83,41.26)
DDR_B_D59: length 68.1
  IN1 w0.089: 172.23,89.34 171.25,90.33 170.95,90.33 167.55,93.73 167.55,96.43 167.11,96.87 166.93,96.87 166.14,97.67 v1(166.14,97.79)
  IN1 w0.097: 172.23,89.34 173.95,87.63 173.95,63.87 174.7,63.11 174.7,61.43 174.6,61.34 174.4,61.34 174.3,61.24 174.3,61.05 174.4,60.95 174.6,60.95 174.7,60.85 174.7,60.63 174.6,60.53 174.4,60.53 174.3,60.44 174.3,60.25 174.4,60.15 174.6,60.15 174.7,60.05 174.7,59.86 174.6,59.76 174.4,59.76 174.3,59.67 174.3,59.47 174.4,59.38 174.6,59.38 174.7,59.28 174.7,59.09 174.6,58.99 174.4,58.99 174.3,58.89 174.3,58.7 174.4,58.6 174.6,58.6 174.7,58.51 174.7,58.31 174.6,58.22 174.4,58.22 174.3,58.12 174.3,57.93 174.4,57.83 174.6,57.83 174.7,57.74 174.7,57.54 174.6,57.45 174.4,57.45 174.3,57.35 174.3,57.16 174.4,57.06 174.6,57.06 174.7,56.96 174.7,56.76 174.6,56.66 174.42,56.66 174.32,56.56 174.32,53.05 173.87,52.61 173.87,44.43 173.56,44.12 173.56,42.93 v1(173.15,42.53)
  BOTTOM w0.076: v1(166.14,97.79) 165.75,98.18 CPU1.M8
  BOTTOM w0.107: JDIMM2.232 171.44,40.82 v1(173.15,42.53)
DDR_B_D60: length 67.9
  IN1 w0.089: 173.55,90.66 172.43,91.79 170.75,91.79 169.56,92.98 169.56,93.95 169.79,94.18 169.79,94.71 169.23,95.27 169.23,96.69 168.29,97.63 168.29,97.89 167.45,98.73 167.45,99.42 v1(167.09,99.77)
  IN1 w0.097: 173.55,90.66 175.75,88.47 175.75,87.61 176.41,86.95 176.41,64.57 177.6,63.38 177.6,60.13 177.15,59.68 177.15,53.22 177.36,53.01 177.36,52 177.26,51.9 176.67,51.9 176.57,51.8 176.57,51.6 176.67,51.5 177.26,51.5 177.36,51.4 177.36,51.21 177.26,51.11 176.67,51.11 176.57,51.01 176.57,50.01 176.67,49.91 177.2,49.91 177.3,49.81 177.3,49.61 177.2,49.52 176.67,49.52 176.57,49.42 176.57,49.22 176.67,49.12 177.14,49.12 177.24,49.02 177.24,45.47 v1(176.83,45.07)
  BOTTOM w0.076: v1(167.09,99.77) CPU1.L10
  BOTTOM w0.107: v1(176.83,45.07) 176.32,45.07 175.69,45.69 JDIMM2.249
DDR_B_D61: length 67.6
  IN1 w0.089: 171.81,88.92 168.73,91.99 167.71,91.99 166.24,93.46 166.24,96.18 165.75,96.67 165.75,98.74 165.83,98.82 165.83,99.4 v1(166.21,99.77)
  IN1 w0.097: 171.81,88.92 172.89,87.84 172.89,64.85 172.99,64.76 173.2,64.76 173.3,64.66 173.3,64.47 173.2,64.37 172.99,64.37 172.89,64.27 172.89,64.08 172.99,63.98 173.2,63.98 173.3,63.89 173.3,63.69 173.2,63.6 172.99,63.6 172.89,63.5 172.89,63.28 172.99,63.18 173.33,63.18 173.43,63.08 173.43,62.89 173.33,62.8 172.99,62.8 172.89,62.7 172.89,62.21 173.7,61.4 173.7,53.58 172.49,52.37 172.49,46.79 172.7,46.58 172.7,44.25 v1(173.15,43.8)
  BOTTOM w0.076: v1(166.21,99.77) CPU1.M10
  BOTTOM w0.107: v1(173.15,43.8) 171.46,45.49 171.46,46.05 171.69,46.29 JDIMM2.233
DDR_B_D62: length 67.8
  IN1 w0.089: 172.02,89.13 171.08,90.08 170.95,90.08 167.37,93.66 167.37,94.71 167.12,94.96 166.6,94.96 166.51,95.05 166.51,96.16 166.15,96.53 v1(166.15,97.15)
  IN1 w0.097: v1(173.15,45.07) 173.51,45.43 173.51,45.84 173.05,46.3 173.05,47.21 172.86,47.4 172.86,51.42 172.95,51.52 173.27,51.52 173.36,51.61 173.36,51.81 173.27,51.9 172.95,51.9 172.86,52 172.86,52.23 174,53.37 174,61.66 174.1,61.75 174.3,61.75 174.4,61.85 174.4,62.04 174.3,62.14 174.1,62.14 174,62.24 174,62.43 174.1,62.52 174.3,62.52 174.4,62.62 174.4,62.81 174.3,62.91 174.1,62.91 174,63.01 174,63.39 173.65,63.74 173.65,65.05 173.55,65.15 173.29,65.15 173.19,65.25 173.19,65.45 173.29,65.55 173.55,65.55 173.65,65.65 173.65,65.85 173.55,65.95 173.29,65.95 173.19,66.04 173.19,66.24 173.29,66.34 173.55,66.34 173.65,66.44 173.65,66.64 173.55,66.74 173.29,66.74 173.19,66.84 173.19,67.03 173.29,67.13 173.55,67.13 173.65,67.23 173.65,67.43 173.55,67.53 173.29,67.53 173.19,67.63 173.19,67.83 173.29,67.93 173.55,67.93 173.65,68.03 173.65,68.22 173.55,68.32 173.29,68.32 173.19,68.42 173.19,68.62 173.29,68.72 173.55,68.72 173.65,68.82 173.65,69.02 173.55,69.11 173.29,69.11 173.19,69.21 173.19,69.41 173.29,69.51 173.55,69.51 173.65,69.61 173.65,69.81 173.55,69.91 173.29,69.91 173.19,70.01 173.19,70.2 173.29,70.3 173.55,70.3 173.65,70.4 173.65,70.6 173.55,70.7 173.29,70.7 173.19,70.8 173.19,71 173.29,71.1 173.55,71.1 173.65,71.2 173.65,71.39 173.55,71.49 173.29,71.49 173.19,71.59 173.19,71.79 173.29,71.89 173.55,71.89 173.65,71.99 173.65,87.51 172.02,89.13
  BOTTOM w0.076: CPU1.M7 165.79,97.5 v1(166.15,97.15)
  BOTTOM w0.107: v1(173.15,45.07) 172.82,45.07 172.54,45.35 172.54,45.92 172.69,46.08 JDIMM2.237
DDR_B_D63: length 67.7
  IN1 w0.089: v1(167.09,98.47) 167.44,98.13 167.44,97.56 168.07,96.93 168.74,96.93 169.02,96.64 169.02,93.26 170.71,91.57 172.22,91.57 173.34,90.45
  IN1 w0.097: v1(176.83,42.53) 176.43,42.93 176.43,47.13 176.27,47.29 176.27,48.29 176.37,48.38 176.84,48.38 176.94,48.48 176.94,48.67 176.84,48.77 176.37,48.77 176.27,48.87 176.27,59.39 176.79,59.91 176.79,63.77 176.11,64.45 176.11,86.82 175.45,87.48 175.45,88.34 173.34,90.45
  BOTTOM w0.076: v1(167.09,98.47) CPU1.L8
  BOTTOM w0.107: JDIMM2.246 174.95,39 174.95,40.16 176.18,41.4 176.18,41.88 v1(176.83,42.53)
DDR_B_DQS0: length 73.4
  IN1 w0.089: v1(133.38,99.66) 133.52,99.52 133.52,99.27 133.43,99.19 132.86,99.19 132.2,99.85 131.15,99.85 130.73,99.43 130.73,98.89 129.81,97.98 129.81,97.98 129.77,97.94 129.76,97.94 129.75,97.93
  IN1 w0.097: 129.75,97.93 129.55,97.73
  IN1 w0.099: v1(114.01,43.42) 113.78,43.65 113.57,43.65 113.33,43.89 113.33,46.46 113.58,46.7 114.14,46.7 114.24,46.8 114.24,47.18 114.14,47.28 114.14,47.28 114.08,47.33 113.76,47.33 113.54,47.55 113.54,47.87 114.18,48.5 114.18,49.47 113.93,49.72 113.93,50.85 114.56,51.49 114.56,63.03 119.9,68.37 119.9,81.34 128.59,90.04 128.59,95.86 129.36,96.63 129.36,97.54 129.55,97.73
  BOTTOM w0.076: v1(133.38,99.66) 133.05,99.25 CPU1.BR9
  BOTTOM w0.107: JDIMM2.13 114.69,43.96 114.41,43.67 114.26,43.67 v1(114.01,43.42)
DDR_B_DQS1: length 71.6
  IN1 w0.089: v1(136.1,99.12) 135.97,99.12 135.87,99.03 135.87,97.17 134.72,96.02 134.72,95.01 135.76,93.97 135.76,92.47 133.17,89.88 133.17,88.25 129.71,84.79 129.71,84.78 129.69,84.76
  IN1 w0.099: v1(119.04,42.79) 118.6,42.35 118.53,42.35 118.37,42.5 118.37,43.47 119.33,44.42 119.33,45.86 120.3,46.83 120.3,53.63 120.09,53.84 120.09,57.94 120.74,58.6 120.74,63.13 124.81,67.2 124.81,79.16 125.45,79.8 125.45,80.52 129.69,84.76
  BOTTOM w0.076: CPU1.BJ9 136.34,98.65 136.09,98.65 135.91,98.83 135.91,98.93 v1(136.1,99.12)
  BOTTOM w0.107: v1(119.04,42.79) 119.25,42.58 119.71,42.58 119.96,42.32 119.96,41.51 119.82,41.37 119.82,40.16 119.94,40.03 JDIMM2.34
DDR_B_DQS2: length 68.5
  IN1 w0.089: 134.89,83.85 134.89,83.87 134.88,83.88 134.88,84.8 136.07,85.99 136.07,85.99 136.08,86 ; v1(139.67,99.12) 139.33,98.78 139.33,96.67 139.96,96.04 139.96,91.54 138.87,90.45 138.87,88.79 138.76,88.67
  IN1 w0.097: 138.76,88.67 137.74,87.66 136.08,86
  IN1 w0.099: 134.89,83.85 134.89,83.54 129.36,78.02 129.36,66.44 125.94,63.02 125.94,45.64 125.42,45.12 125.42,44.76 125.93,44.25 125.93,43.77 125.59,43.42 v1(124.63,43.42)
  BOTTOM w0.076: v1(139.67,99.12) CPU1.BF9
  BOTTOM w0.107: v1(124.63,43.42) 124.8,43.59 125.16,43.59 125.4,43.84 125.4,45.07 125.1,45.37 125.1,46.07 125.19,46.16 JDIMM2.55
DDR_B_DQS3: length 68
  IN1 w0.089: 138.76,83.85 138.76,84.24 142.09,87.57 142.09,89.86 142.89,90.66 142.89,96.84 142.06,97.67 142.06,98.75 v1(142.43,99.12)
  IN1 w0.099: v1(130.8,42.15) 131.03,42.39 131.52,42.39 131.75,42.61 131.75,44.33 131.54,44.55 131.24,44.55 131.14,44.64 131.14,45.01 131.25,45.12 131.54,45.12 131.75,45.33 131.75,58.03 132.22,58.49 132.22,63.21 133.17,64.17 133.17,76.51 138.76,82.11 138.76,83.85
  BOTTOM w0.076: v1(142.43,99.12) CPU1.BB9
  BOTTOM w0.107: v1(130.8,42.15) 130.65,42.3 130.44,42.3 130.31,42.17 130.31,40.15 130.45,40.01 JDIMM2.76
DDR_B_DQS4: length 66
  IN1 w0.089: 162,83.85 162,83.87 161.99,83.88 161.99,87.9 158.79,91.1 158.79,97.34 158.53,97.6 158.53,98.7 158.43,98.8 158.43,99.27 158.56,99.4 158.77,99.4 158.89,99.28 v1(158.89,99.12)
  IN1 w0.099: 162,83.85 162,71.79 158.37,68.15 158.37,58.57 158.72,58.21 158.72,50.3 158.13,49.7 158.13,49.05 157.74,48.67 157.74,47.55 157.53,47.33 157.33,47.33 157.23,47.24 157.23,47 157.33,46.9 157.61,46.9 157.79,46.72 157.79,45.29 157.23,44.74 157.23,44.01 157.4,43.85 157.58,43.85 v1(157.84,44.1)
  BOTTOM w0.076: v1(158.89,99.12) CPU1.AA9
  BOTTOM w0.107: v1(157.84,44.1) 157.65,43.91 157.49,43.91 157.3,44.1 157.3,44.93 158.06,45.69 158.06,46.07 158.2,46.2 JDIMM2.179
DDR_B_DQS5: length 66.5
  IN1 w0.089: v1(160.71,98.49) 160.8,98.58 161,98.58 161.1,98.49 161.1,97.49 161.17,97.42 161.17,92.2 165.66,87.71 165.66,83.88 165.65,83.87 165.65,83.85 165.65,83.85
  IN1 w0.099: v1(163.51,42.27) 163.51,42.34 163.27,42.57 162.97,42.57 162.76,42.79 162.76,44.9 163.33,45.46 163.33,51.63 163.54,51.85 163.71,51.85 163.84,51.98 163.84,52.26 163.74,52.36 163.6,52.36 163.39,52.57 163.39,53.12 163.92,53.64 163.92,59.39 163.39,59.92 163.39,67.45 165.65,69.71 165.65,83.85
  BOTTOM w0.076: CPU1.V9 161.23,98.75 161.23,98.51 161.16,98.44 160.76,98.44 v1(160.71,98.49)
  BOTTOM w0.107: v1(163.51,42.27) 163.25,42.53 163.09,42.53 162.82,42.26 162.82,41.18 163.35,40.66 163.35,40.1 163.44,40 JDIMM2.200
DDR_B_DQS6: length 65.9
  IN1 w0.089: 169.72,86.83 169.72,87.41 164.02,93.11 164.02,98.68 163.93,98.77 163.93,99.28 164.03,99.38 164.22,99.38 164.38,99.21 v1(164.38,99.12)
  IN1 w0.099: 169.72,86.83 169.73,86.82 169.73,86.73 169.76,86.7 169.76,67 169.46,66.7 169.46,60.45 169.89,60.02 169.89,55.09 169.11,54.31 169.11,51.88 169.27,51.72 169.43,51.72 169.69,51.46 169.69,51.09 169.42,50.83 169.15,50.83 168.98,50.66 168.98,46.36 169.14,46.2 169.36,46.2 169.55,46 169.55,45.56 169.25,45.26 168.64,45.26 168.48,45.1 168.48,44.08 168.58,43.98 168.83,43.98 v1(169.02,44.18)
  BOTTOM w0.076: v1(164.38,99.12) CPU1.P9
  BOTTOM w0.107: v1(169.02,44.18) 168.8,43.96 168.64,43.96 168.54,44.06 168.54,46.04 168.69,46.2 JDIMM2.221
DDR_B_DQS7: length 67.9
  IN1 w0.089: v1(166.16,98.41) 166.45,98.41 166.54,98.33 166.54,97.6 167.08,97.06 167.18,97.06 167.8,96.45 167.8,93.74 170.94,90.6 171.79,90.6 172.62,89.76 172.62,89.75 172.63,89.74
  IN1 w0.099: v1(174.74,42.21) 174.74,42.27 174.13,42.89 174.13,43.89 174.34,44.1 174.8,44.1 175.2,44.5 175.2,44.72 175,44.92 174.59,44.92 174.37,45.14 174.37,52.03 174.75,52.41 174.75,52.41 175.2,52.86 175.2,63.32 174.63,63.9 174.63,77.26 174.45,77.44 174.45,87.93 172.63,89.74
  BOTTOM w0.076: CPU1.L9 166.54,98.8 v1(166.16,98.41)
  BOTTOM w0.107: v1(174.74,42.21) 174.34,42.61 174.18,42.61 174,42.43 174,40.99 173.68,40.67 173.68,40.23 173.94,39.96 JDIMM2.242
DDR_B_DQS#0: length 73.4
  IN1 w0.089: 129.88,97.79 130.91,98.82 130.91,99.36 131.22,99.68 132.12,99.68 132.79,99.01 133.51,99.01 133.7,99.2 133.7,99.48 133.86,99.64 v1(133.98,99.64)
  IN1 w0.097: 129.69,97.6 129.75,97.66 129.75,97.66 129.88,97.79
  IN1 w0.099: 129.69,97.6 129.69,97.59 129.55,97.45 129.55,96.55 128.79,95.78 128.79,89.96 120.09,81.26 120.09,68.29 114.75,62.95 114.75,51.41 114.12,50.77 114.12,49.8 114.37,49.55 114.37,48.42 113.74,47.79 113.74,47.63 113.84,47.53 114.17,47.53 114.34,47.36 114.34,47.36 114.44,47.26 114.44,46.72 114.23,46.51 113.66,46.51 113.53,46.38 113.53,43.97 113.65,43.85 113.8,43.85 v1(114.01,44.06)
  BOTTOM w0.076: v1(133.98,99.64) 133.98,99.04 133.89,98.95 133.75,98.95 133.66,99.04 CPU1.BP9
  BOTTOM w0.107: v1(114.01,44.06) 114.16,43.91 114.31,43.91 114.46,44.06 114.46,46.01 114.19,46.28 JDIMM2.11
DDR_B_DQS#1: length 71.6
  IN1 w0.089: 129.55,84.9 129.57,84.92 129.58,84.92 132.99,88.32 132.99,89.95 135.58,92.54 135.58,93.9 134.54,94.93 134.54,96.09 135.69,97.24 135.69,99.23 136.06,99.59 v1(136.06,99.77)
  IN1 w0.099: 129.55,84.9 125.26,80.6 125.26,79.88 124.62,79.24 124.62,67.28 120.54,63.21 120.54,58.68 119.89,58.02 119.89,53.76 120.1,53.55 120.1,46.91 119.13,45.94 119.13,44.5 118.18,43.55 118.18,42.42 118.45,42.15 119.04,42.15 v1(119.04,42.15)
  BOTTOM w0.076: v1(136.06,99.77) CPU1.BL9
  BOTTOM w0.107: v1(119.04,42.15) 119.23,42.34 119.61,42.34 119.72,42.22 119.72,41.61 119.58,41.47 119.58,40.16 119.45,40.03 JDIMM2.32
DDR_B_DQS#2: length 68.5
  IN1 w0.089: 135.99,86.17 135.99,86.16 134.7,84.87 134.7,83.88 134.69,83.87 134.69,83.85 ; v1(138.78,99.12) 138.93,99.27 139.08,99.27 139.2,99.16 139.2,98.91 139.15,98.86 139.15,96.6 139.78,95.96 139.78,91.61 138.69,90.52 138.69,88.87 138.65,88.82 138.64,88.82 138.63,88.81
  IN1 w0.097: 138.63,88.81 137.61,87.79 135.99,86.17
  IN1 w0.099: 134.69,83.85 134.69,83.62 129.17,78.1 129.17,66.52 125.75,63.1 125.75,45.72 125.23,45.2 125.23,44.68 125.74,44.16 125.74,43.85 125.51,43.62 125.07,43.62 v1(124.63,44.06)
  BOTTOM w0.076: v1(138.78,99.12) CPU1.BG9
  BOTTOM w0.107: v1(124.63,44.06) 124.85,43.83 125.06,43.83 125.17,43.94 125.17,44.97 124.87,45.27 124.87,46.02 124.69,46.2 JDIMM2.53
DDR_B_DQS#3: length 68.1
  IN1 w0.089: v1(141.52,99.12) 141.89,98.76 141.89,97.6 142.71,96.77 142.71,90.73 141.92,89.94 141.92,87.65 138.57,84.3 138.57,83.85
  IN1 w0.099: 138.57,83.85 138.57,82.19 132.98,76.6 132.98,64.25 132.02,63.3 132.02,58.57 131.55,58.11 131.55,45.41 131.46,45.31 131.17,45.31 130.95,45.09 130.95,44.56 131.16,44.35 131.46,44.35 131.55,44.25 131.55,42.69 131.44,42.58 131,42.58 v1(130.8,42.79)
  BOTTOM w0.076: v1(141.52,99.12) CPU1.BC9
  BOTTOM w0.107: v1(130.8,42.79) 130.55,42.54 130.34,42.54 130.07,42.27 130.07,40.14 129.94,40.01 JDIMM2.74
DDR_B_DQS#4: length 65.9
  IN1 w0.089: v1(157.98,99.12) 158.25,98.85 158.25,98.73 158.35,98.62 158.35,97.53 158.61,97.27 158.61,91.03 161.82,87.82 161.82,83.88 161.81,83.87 161.81,83.85
  IN1 w0.099: 161.81,83.85 161.81,71.87 158.17,68.23 158.17,58.49 158.53,58.13 158.53,50.38 157.93,49.79 157.93,49.13 157.55,48.75 157.55,47.63 157.45,47.53 157.25,47.53 157.04,47.32 157.04,46.92 157.25,46.7 157.53,46.7 157.59,46.64 157.59,45.37 157.04,44.82 157.04,43.93 157.32,43.65 157.65,43.65 v1(157.84,43.46)
  BOTTOM w0.076: v1(157.98,99.12) CPU1.AC9
  BOTTOM w0.107: JDIMM2.177 157.69,46.2 157.82,46.07 157.82,46.07 157.82,45.79 157.06,45.02 157.06,44 157.39,43.67 157.63,43.67 v1(157.84,43.46)
DDR_B_DQS#5: length 66.6
  IN1 w0.089: 165.84,83.85 165.84,83.87 165.84,83.88 165.84,87.79 161.35,92.27 161.35,97.49 161.27,97.57 161.27,98.56 v1(160.71,99.13)
  IN1 w0.099: v1(163.51,42.91) 163.37,42.77 163.05,42.77 162.95,42.87 162.95,44.81 163.52,45.38 163.52,51.55 163.62,51.65 163.79,51.65 164.03,51.89 164.03,52.34 163.82,52.55 163.69,52.55 163.59,52.65 163.59,53.04 164.11,53.56 164.11,59.47 163.58,60 163.58,67.37 165.84,69.63 165.84,83.85
  BOTTOM w0.076: CPU1.W9 160.38,98.8 v1(160.71,99.13)
  BOTTOM w0.107: v1(163.51,42.91) 163.37,42.77 163,42.77 162.59,42.36 162.59,41.08 163.11,40.56 163.11,40.13 162.94,39.96 JDIMM2.198
DDR_B_DQS#6: length 65.9
  IN1 w0.089: v1(163.47,99.12) 163.76,98.83 163.76,98.7 163.84,98.61 163.84,93.04 169.55,87.33 169.55,86.91 169.54,86.91 169.54,86.85 169.54,86.84 169.54,86.65
  IN1 w0.099: v1(169.02,43.54) 168.78,43.78 168.5,43.78 168.28,44 168.28,45.18 168.55,45.45 169.17,45.45 169.36,45.64 169.36,45.92 169.28,46 169.06,46 168.79,46.28 168.79,50.74 169.07,51.02 169.34,51.02 169.49,51.17 169.49,51.38 169.35,51.53 169.19,51.53 168.92,51.79 168.92,54.39 169.7,55.17 169.7,59.94 169.26,60.37 169.26,66.78 169.56,67.08 169.56,86.62 169.54,86.65
  BOTTOM w0.076: v1(163.47,99.12) CPU1.R9
  BOTTOM w0.107: JDIMM2.219 168.19,46.2 168.3,46.1 168.3,43.96 168.54,43.72 168.85,43.72 v1(169.02,43.54)
DDR_B_DQS#7: length 68
  IN1 w0.089: v1(166.2,99.09) 166.2,98.92 166.72,98.4 166.72,97.68 167.16,97.24 167.26,97.24 167.97,96.52 167.97,93.81 171.01,90.78 171.86,90.78 172.75,89.89 172.75,89.89 172.76,89.89 172.76,89.9 172.77,89.88
  IN1 w0.099: v1(174.74,42.84) 174.44,42.84 174.32,42.97 174.32,43.81 174.42,43.91 174.88,43.91 175.4,44.42 175.4,44.8 175.08,45.12 174.67,45.12 174.57,45.22 174.57,51.95 174.83,52.21 174.83,52.21 175.4,52.77 175.4,63.4 174.82,63.98 174.82,77.34 174.65,77.52 174.65,88.01 172.77,89.88
  BOTTOM w0.076: CPU1.M9 165.91,98.8 v1(166.2,99.09)
  BOTTOM w0.107: JDIMM2.240 173.44,40.77 173.76,41.09 173.76,42.52 174.08,42.84 174.44,42.84 174.44,42.84 v1(174.74,42.84)
DDR_B_MA0: length 69.5
  IN1 w0.089: 153.2,83.85 153.2,93.57 152.95,93.82 152.95,96.58 152.02,97.51 152.02,98.65 v1(152.49,99.12)
  IN1 w0.152: 153.2,83.85 153.2,77.31 151.27,75.37 151.27,73.2 151,72.94 150.62,72.94 150.38,73.18 150.38,73.19 149.84,73.73 149.59,73.73 149.4,73.54 149.4,73.29 150.18,72.51 150.18,72.29 149.96,72.07 149.74,72.07 149.1,72.71 148.89,72.71 147.59,71.41 147.59,58.45 147.79,58.25 147.79,52.26 147.06,51.54 147.06,50.3 146.75,49.99 146.75,46.51 147.19,46.07 147.19,44.34 147.44,44.09 147.44,43.68 v1(148.47,42.65)
  BOTTOM w0.076: CPU1.AJ9 152.17,98.8 v1(152.49,99.12)
  BOTTOM w0.175: v1(148.47,42.65) 147.44,41.62 JDIMM2.144
DDR_B_MA1: length 66.3
  IN1 w0.089: 150.35,83.85 150.35,85.47 150.34,85.48 150.34,95.05 151.03,95.74 v1(151.03,96.53)
  IN1 w0.152: 150.35,83.85 150.35,83.01 150.01,82.67 150.01,82.36 150.17,82.2 150.38,82.2 150.53,82.05 150.53,81.74 150.38,81.58 149.56,81.58 149.4,81.43 149.4,81.12 149.56,80.96 150.38,80.96 150.53,80.81 150.53,80.49 150.34,80.3 150,80.3 149.81,80.11 149.81,77.91 149.59,77.69 148.98,77.69 148.5,77.22 148.5,77 148.85,76.65 148.85,76.43 148.64,76.22 148.42,76.22 148.07,76.57 147.86,76.57 147.67,76.38 147.67,76.16 148.02,75.81 148.02,75.6 147.82,75.4 147.6,75.4 147.32,75.69 147.1,75.69 146.92,75.5 146.92,75.22 147.17,74.97 147.17,74.75 145.13,72.71 145.13,64.75 144.97,64.59 144.65,64.59 144.5,64.44 144.5,64.13 144.65,63.97 145.02,63.97 145.17,63.82 145.17,63.51 145.02,63.35 144.65,63.35 144.5,63.2 144.5,62.89 144.65,62.73 144.95,62.73 145.11,62.58 145.11,61.42 144.85,61.16 144.85,60.85 145.13,60.57 145.13,60.23 144.97,60.08 144.65,60.08 144.5,59.92 144.5,59.61 144.65,59.46 144.97,59.46 145.13,59.3 145.13,59.02 144.94,58.83 144.85,58.83 144.48,58.46 144.48,52.81 144,52.32 144,45.08 v1(143.98,45.07)
  BOTTOM w0.076: CPU1.AK6 151.55,96.76 151.55,96.61 151.41,96.47 151.09,96.47 v1(151.03,96.53)
  BOTTOM w0.175: v1(143.98,45.07) 143.98,45.28 144.69,46 JDIMM2.133
DDR_B_MA2: length 66.2
  IN1 w0.089: v1(151.8,95.85) 150.68,94.73 150.68,85.94 150.99,85.63 150.99,83.85
  IN1 w0.152: 150.99,83.85 150.99,80.21 150.26,79.48 150.26,77.2 145.63,72.56 145.63,58.74 145.19,58.3 145.19,52.75 144.45,52.02 144.45,43.74 144.64,43.55 145.01,43.55 145.17,43.4 145.17,43.09 145.01,42.93 144.63,42.93 144.47,42.78 144.47,41.11 144.63,40.96 144.95,40.96 145.11,41.11 145.11,42.31 145.32,42.53 v1(145.62,42.53)
  BOTTOM w0.076: v1(151.8,95.85) 151.75,95.85 CPU1.AK5
  BOTTOM w0.175: JDIMM2.132 144.44,39.95 144.63,40.13 144.63,41.55 145.61,42.53 v1(145.62,42.53)
DDR_B_MA3: length 66.5
  IN1 w0.089: 149.89,83.85 149.89,86.16 150.16,86.43 150.16,95.78 v1(150.24,95.86)
  IN1 w0.152: v1(143.98,43.8) 143.54,44.24 143.54,58.09 144.04,58.59 144.04,64.9 144.19,65.05 144.51,65.05 144.67,65.21 144.67,65.52 144.51,65.67 144.19,65.67 144.04,65.83 144.04,66.14 144.19,66.29 144.51,66.29 144.67,66.45 144.67,66.76 144.51,66.91 144.19,66.91 144.04,67.07 144.04,67.38 144.19,67.53 144.51,67.53 144.67,67.69 144.67,68 144.51,68.15 144.19,68.15 144.04,68.31 144.04,68.62 144.19,68.77 144.51,68.77 144.67,68.93 144.67,69.24 144.51,69.39 144.19,69.39 144.04,69.55 144.04,69.94 144.19,70.1 144.51,70.1 144.67,70.25 144.67,70.56 144.51,70.72 144.19,70.72 144.04,70.87 144.04,71.18 144.19,71.34 144.46,71.34 144.61,71.49 144.61,73.77 144.76,73.92 144.95,73.92 145.2,73.66 145.43,73.66 145.69,73.91 145.69,74.13 145.34,74.48 145.34,74.69 145.54,74.9 145.75,74.9 146.09,74.56 146.33,74.56 146.53,74.76 146.53,74.98 146.18,75.33 146.18,75.54 148.94,78.3 148.94,81.62 149.55,82.23 149.55,82.86 149.89,83.2 149.89,83.85
  BOTTOM w0.076: CPU1.AL5 150.57,96.19 v1(150.24,95.86)
  BOTTOM w0.175: v1(143.98,43.8) 143.45,44.33 143.45,45.48 144.19,46.22 JDIMM2.131
DDR_B_MA4: length 65.2
  IN1 w0.089: 148.63,83.85 148.63,84.65 148.99,85.01 148.99,96.61 149.25,96.87 149.88,96.87 v1(150.24,96.51)
  IN1 w0.152: v1(143.98,41.3) 143.64,41.3 143.46,41.12 143.46,40.61 143.3,40.46 142.91,40.46 142.76,40.61 142.76,42.01 142.62,42.14 142.62,58.48 143.12,58.97 143.12,74.54 148.02,79.44 148.02,82 148.63,82.61 148.63,83.85
  BOTTOM w0.076: CPU1.AL6 150.57,96.84 v1(150.24,96.51)
  BOTTOM w0.175: JDIMM2.128 143.44,40.48 143.98,41.02 v1(143.98,41.3)
DDR_B_MA5: length 64.6
  IN1 w0.089: 149.43,83.85 149.43,94.4 149.77,94.73 149.77,96.15 v1(149.4,96.51)
  IN1 w0.152: 149.43,83.85 149.43,83.39 149.09,83.05 149.09,82.42 148.48,81.81 148.48,79.25 143.58,74.35 143.58,73.86 143.73,73.7 144,73.7 144.15,73.55 144.15,73.25 144,73.09 143.73,73.09 143.58,72.94 143.58,72.57 143.73,72.42 144,72.42 144.15,72.26 144.15,71.95 144,71.8 143.73,71.8 143.58,71.64 143.58,58.78 143.08,58.28 143.08,42.57 143.37,42.28 143.74,42.28 v1(143.98,42.53)
  BOTTOM w0.076: v1(149.4,96.51) 149.72,96.51 149.8,96.59 CPU1.AM6
  BOTTOM w0.175: v1(143.98,42.53) 143.28,42.53 142.94,42.19 JDIMM2.126
DDR_B_MA6: length 66
  IN1 w0.089: v1(149.75,97.32) 149.35,97.32 148.77,96.74 148.77,85.16 148.17,84.57 148.17,83.85
  IN1 w0.152: v1(141.59,43.72) 141.79,43.72 142.14,44.07 142.14,47.21 141.68,47.67 141.68,50.91 141.84,51.07 141.99,51.07 142.14,51.22 142.14,51.6 141.99,51.75 141.84,51.75 141.68,51.91 141.68,52.2 141.84,52.36 142.03,52.36 142.14,52.47 142.14,52.8 142.01,52.93 141.81,52.93 141.68,53.05 141.68,53.42 141.81,53.55 142.01,53.55 142.17,53.71 142.17,59.38 142.32,59.53 142.51,59.53 142.66,59.68 142.66,60 142.5,60.15 142.32,60.15 142.17,60.31 142.17,60.62 142.32,60.77 142.5,60.77 142.66,60.92 142.66,63.05 142.5,63.21 142.32,63.21 142.17,63.36 142.17,63.67 142.32,63.82 142.5,63.82 142.66,63.98 142.66,64.29 142.5,64.44 142.32,64.44 142.17,64.6 142.17,64.91 142.32,65.06 142.5,65.06 142.66,65.22 142.66,74.72 147.56,79.63 147.56,82.19 148.17,82.8 148.17,83.85
  BOTTOM w0.076: CPU1.AN7 149.29,97.2 149.37,97.12 149.55,97.12 v1(149.75,97.32)
  BOTTOM w0.175: v1(141.59,43.72) 142.94,45.06 142.94,45.82 143.19,46.07 JDIMM2.127
DDR_B_MA7: length 67.8
  IN1 w0.089: 146.35,83.85 146.35,84.08 146.44,84.17 147.01,84.17 148.39,85.54 148.39,96.96 149,97.57 149,97.96 149.38,98.34 149.38,99.41 v1(149.75,99.77)
  IN1 w0.152: 146.35,83.85 146.35,79.71 141.25,74.61 141.25,58.66 140.74,58.15 140.74,52.71 140.63,52.61 140.47,52.61 140.35,52.49 140.35,52.16 140.47,52.04 140.61,52.04 140.76,51.88 140.76,51.62 140.61,51.47 140.5,51.47 140.35,51.31 140.35,51.01 140.5,50.85 140.64,50.85 140.76,50.72 140.76,47.17 141.13,46.8 141.13,42.32 141.26,42.19 141.47,42.19 141.59,42.32 v1(141.59,42.37)
  BOTTOM w0.076: v1(149.75,99.77) CPU1.AN10
  BOTTOM w0.175: v1(141.59,42.37) 141.86,42.37 142.26,41.97 142.26,40.34 141.94,40.03 JDIMM2.122
DDR_B_MA8: length 65.7
  IN1 w0.089: 147.71,83.85 147.75,83.88 147.75,84.59 148.56,85.4 148.56,96.88 149.58,97.89 v1(149.73,97.89)
  IN1 w0.152: 147.71,83.85 147.59,83.73 146.95,83.73 146.81,83.58 146.81,83.3 146.96,83.15 147.31,83.15 147.46,82.99 147.46,82.74 147.31,82.59 146.96,82.59 146.81,82.43 146.81,82.15 147.1,81.86 147.1,81.53 146.8,81.23 146.8,79.51 141.71,74.42 141.71,72.62 141.86,72.46 142.04,72.46 142.2,72.31 142.2,72 142.04,71.84 141.86,71.84 141.71,71.69 141.71,71.38 141.86,71.22 142.04,71.22 142.2,71.07 142.2,70.76 142.04,70.6 141.86,70.6 141.71,70.45 141.71,70.14 141.86,69.98 142.04,69.98 142.2,69.83 142.2,69.52 142.04,69.36 141.86,69.36 141.71,69.21 141.71,68.9 141.86,68.74 142.04,68.74 142.2,68.59 142.2,68.28 142.04,68.12 141.86,68.12 141.71,67.97 141.71,67.66 141.86,67.5 142.04,67.5 142.2,67.35 142.2,67.04 142.04,66.88 141.86,66.88 141.71,66.73 141.71,66.42 141.86,66.26 142.04,66.26 142.2,66.11 142.2,65.8 142.04,65.64 141.86,65.64 141.71,65.49 141.71,58.47 141.22,57.98 141.22,47.48 141.68,47.02 141.68,45.16 v1(141.61,45.08)
  BOTTOM w0.076: v1(149.73,97.89) 149.47,98.15 CPU1.AN8
  BOTTOM w0.175: v1(141.61,45.08) 141.78,44.9 142.06,44.9 142.44,45.28 142.44,45.48 142.25,45.67 142.25,45.92 142.69,46.37 JDIMM2.125
DDR_B_MA9: length 66.1
  IN1 w0.089: v1(147.91,99.72) 148.47,99.16 148.47,97.55 147.93,97.01 147.93,86.21 146.31,84.59 145.66,84.59 145.43,84.36 145.43,83.85
  IN1 w0.152: v1(139.72,43.59) 140.21,44.08 140.21,46.42 139.4,47.24 139.4,58.11 140.33,59.04 140.33,74.98 145.43,80.08 145.43,83.85
  BOTTOM w0.076: CPU1.AR11 147.53,100.1 v1(147.91,99.72)
  BOTTOM w0.175: JDIMM2.121 141.69,46.13 140.36,44.79 140.36,44.23 v1(139.72,43.59)
DDR_B_MA10: length 67.6
  IN1 w0.089: 154.78,83.85 154.78,85.61 153.88,86.51 153.88,93.66 153.49,94.06 153.49,97.74 v1(153.41,97.82)
  IN1 w0.152: 154.78,83.85 154.78,74.49 149.25,68.96 149.25,59.66 149.75,59.17 149.75,52 148.82,51.07 148.82,46.04 148.91,45.95 148.91,41.46 149.49,40.88 149.49,40.29 149.23,40.04 148.15,40.04 147.99,40.2 147.99,40.64 v1(148.47,41.13)
  BOTTOM w0.076: v1(153.41,97.82) CPU1.AH7
  BOTTOM w0.175: JDIMM2.146 149.95,39 149.95,40.04 148.86,41.13 v1(148.47,41.13)
DDR_B_MA11: length 70.3
  IN1 w0.089: v1(149.75,100.42) 149.2,99.88 149.2,98.41 148.82,98.03 148.82,97.65 148.11,96.93 148.11,86.03 146.49,84.41 146.11,84.41 145.89,84.19 145.89,83.85
  IN1 w0.152: 145.89,83.85 145.89,79.9 140.79,74.8 140.79,58.85 140.28,58.34 140.28,53.49 139.89,53.1 139.89,47.4 140.67,46.61 140.67,40.49 140.83,40.33 142.15,40.33 142.28,40.46 142.28,40.99 142.15,41.11 v1(141.61,41.11)
  BOTTOM w0.076: v1(149.75,100.42) CPU1.AN11
  BOTTOM w0.175: JDIMM2.120 141.44,40.95 v1(141.61,41.11)
DDR_B_MA12: length 64.4
  IN1 w0.089: 144.97,83.85 144.97,84.47 145.8,85.31 145.8,88.28 146.01,88.49 146.44,88.49 147.04,87.89 147.45,87.89 147.7,88.14 147.7,97.03 147.75,97.08 147.91,97.24 147.91,97.28 147.99,97.35 147.99,97.92 148.3,98.22 148.3,98.99 148.18,99.11 v1(147.92,99.11)
  IN1 w0.152: 144.97,83.85 144.97,80.27 139.45,74.75 139.45,60.92 139.6,60.76 139.71,60.76 139.87,60.61 139.87,60.3 139.71,60.14 139.6,60.14 139.45,59.99 139.45,58.81 138.94,58.3 138.94,47.05 139.72,46.27 v1(139.72,44.94)
  BOTTOM w0.076: CPU1.AR10 147.59,99.45 v1(147.92,99.11)
  BOTTOM w0.175: JDIMM2.119 141.19,46.31 139.82,44.94 v1(139.72,44.94)
DDR_B_MA13: length 68
  IN1 w0.089: v1(155.24,99.12) 154.65,98.54 154.65,97.63 154.98,97.3 154.98,94.58 155.77,93.8 155.77,87.6 157.28,86.09 157.28,83.85
  IN1 w0.152: 157.28,83.85 157.28,73.44 151.75,67.91 151.75,62.52 152.37,61.9 152.37,60.06 153.32,59.12 153.32,55.48 153.94,54.87 153.94,52.51 152.65,51.23 152.65,49.49 151.73,48.57 151.73,41.35 152.41,40.67 v1(153.61,40.67)
  BOTTOM w0.076: v1(155.24,99.12) CPU1.AF9
  BOTTOM w0.175: v1(153.61,40.67) 153.38,40.67 152.95,40.24 152.95,39 JDIMM2.158
DDR_B_PAR: length 67.5
  IN1 w0.089: v1(152.49,97.82) 152.49,97.29 153.13,96.66 153.13,93.91 153.48,93.56 153.48,84.12 153.76,83.85
  IN1 w0.152: v1(148.47,44.17) 148.16,44.17 147.8,44.53 147.8,47.62 147.65,47.77 147.46,47.77 147.31,47.93 147.31,48.23 147.46,48.38 147.65,48.38 147.8,48.54 147.8,48.87 147.65,49.02 147.46,49.02 147.31,49.17 147.31,49.48 147.46,49.63 147.65,49.63 147.8,49.78 147.8,51.49 148.34,52.03 148.34,58.58 148.15,58.78 148.15,70.92 148.74,71.51 150.36,71.51 151.82,72.97 151.82,73.56 151.98,73.71 152.38,73.71 152.54,73.87 152.54,74.17 152.38,74.32 151.98,74.32 151.82,74.48 151.82,75.14 152.14,75.46 152.36,75.46 153.19,74.63 153.44,74.63 153.66,74.84 153.66,75.06 152.81,75.91 152.81,76.13 153.76,77.07 153.76,83.85
  BOTTOM w0.076: v1(152.49,97.82) CPU1.AJ7
  BOTTOM w0.175: JDIMM2.143 147.2,46.27 147.42,46.05 147.42,44.83 148.07,44.17 v1(148.47,44.17)
DDR_B_RAS#: length 67.8
  IN1 w0.089: 155.7,83.85 155.7,85.64 154.34,87 154.34,93.71 153.84,94.2 153.84,97.39 154.01,97.55 154.01,98.62 153.78,98.85 153.78,99.4 v1(153.41,99.77)
  IN1 w0.152: v1(150.99,42.65) 150.9,42.65 149.98,43.57 149.98,46.16 149.74,46.41 149.74,48.82 150.76,49.84 150.76,51.84 150.95,52.03 151.22,52.03 151.34,52.16 151.34,52.46 151.19,52.61 150.89,52.61 150.76,52.74 150.76,53.05 150.89,53.18 151.2,53.18 151.34,53.32 151.34,58.87 150.17,60.04 150.17,68.56 155.7,74.09 155.7,83.85
  BOTTOM w0.076: v1(153.41,99.77) CPU1.AH10
  BOTTOM w0.175: v1(150.99,42.65) 151.64,41.99 151.64,40.28 151.44,40.08 JDIMM2.152
DDR_B_WE#: length 65
  IN1 w0.089: v1(153.41,100.42) 153.95,99.88 153.95,99.08 154.21,98.82 154.21,97.5 154.02,97.31 154.02,94.62 155.26,93.38 155.26,86.84 156.16,85.94 156.16,83.85
  IN1 w0.152: 156.16,83.85 156.16,73.9 150.63,68.37 150.63,62.05 151.25,61.43 151.25,59.6 151.8,59.05 151.8,51.97 151.22,51.39 151.22,49.65 150.6,49.03 150.6,45.98 150.55,45.93 150.55,44.61 v1(150.99,44.17)
  BOTTOM w0.076: v1(153.41,100.42) CPU1.AH11
  BOTTOM w0.175: v1(150.99,44.17) 151.58,44.77 151.58,45.87 151.2,46.26 JDIMM2.151
DDR_CKE0_DIMMA: length 46
  IN4 w0.152: v1(137.61,58.07) 137.8,58.07 137.97,58.23 137.97,59.4 137.84,59.53 137.72,59.53 137.56,59.69 137.56,59.97 137.72,60.13 137.81,60.13 137.97,60.28 137.97,60.59 137.81,60.75 137.72,60.75 137.56,60.9 137.56,62.22 137.97,62.62 137.97,63.41 139.16,64.6 139.16,70.1 143.78,74.72 143.78,88.37 144.15,88.74 v1(144.44,88.74)
  BOTTOM w0.076: CPU1.AT1 146.39,90.08 146.32,90.01 145.88,90.01 145.8,89.93 145.8,89.78 145.88,89.7 146.32,89.7 146.39,89.63 146.39,89.47 146.32,89.4 145.88,89.4 145.8,89.32 145.8,89.17 145.88,89.09 146.32,89.09 146.39,89.02 146.39,88.82 146.31,88.74 v1(144.44,88.74)
  BOTTOM w0.175: v1(137.61,58.07) 137.99,58.07 138.69,58.78 JDIMM1.109
DDR_CKE1_DIMMA: length 46.6
  IN4 w0.152: v1(137.72,54.03) 138.43,54.74 138.43,63.22 139.62,64.41 139.62,69.91 144.24,74.53 144.24,86.35 144.83,86.95 144.83,89.89 v1(144.71,90.01)
  BOTTOM w0.076: v1(144.71,90.01) 146.1,91.4 146.1,93.94 CPU1.AT2
  BOTTOM w0.175: JDIMM1.110 138.94,52.8 v1(137.72,54.03)
DDR_CKE2_DIMMB: length 67
  IN1 w0.089: v1(147.01,97.86) 146.74,97.86 145.62,96.74 145.62,89.4 144.28,88.06 144.28,86.34 142.37,84.43 142.37,83.85
  IN1 w0.152: v1(136.66,43.67) 135.53,44.81 135.53,45.75 135.68,45.91 135.8,45.91 135.95,46.06 135.95,46.37 135.8,46.53 135.68,46.53 135.53,46.68 135.53,46.99 135.68,47.15 135.8,47.15 135.95,47.3 135.95,47.61 135.8,47.77 135.68,47.77 135.53,47.92 135.53,50.6 135.95,51.02 135.95,59.2 136.54,59.79 136.54,62.64 136.75,62.85 136.75,75.72 142.37,81.34 142.37,83.85
  BOTTOM w0.076: CPU1.AT8 146.72,98.15 v1(147.01,97.86)
  BOTTOM w0.175: JDIMM2.109 138.69,46.31 138.48,46.09 136.5,46.09 136.2,45.79 136.2,44.13 v1(136.66,43.67)
DDR_CKE3_DIMMB: length 68.1
  IN1 w0.089: v1(146.07,99.15) 145.16,98.25 145.16,91.52 143.65,90.01 143.65,86.65 141.45,84.45 141.45,83.85
  IN1 w0.152: v1(136.66,41.13) 134.61,43.18 134.61,50.98 135.03,51.4 135.03,59.58 135.62,60.17 135.62,63.02 135.84,63.24 135.84,76.11 141.45,81.72 141.45,83.85
  BOTTOM w0.076: CPU1.AT10 146.36,99.45 v1(146.07,99.15)
  BOTTOM w0.175: JDIMM2.110 138.94,40.2 138.01,41.13 v1(136.66,41.13)
DDR_CS0_DIMMA#: length 50.5
  IN4 w0.089: 156.15,83.85 156.15,84.36 153.85,86.67 153.85,93.8 154.76,94.71 154.76,95.66 154.96,95.86 v1(156.09,95.86)
  IN4 w0.152: v1(150.91,56.72) 151.19,56.72 151.34,56.88 151.34,57.6 151.5,57.75 151.78,57.75 151.94,57.91 151.94,61.91 152.4,62.38 152.4,64.64 156.15,68.39 156.15,83.85
  BOTTOM w0.076: CPU1.AD5 156.41,96.19 v1(156.09,95.86)
  BOTTOM w0.175: JDIMM1.149 150.69,58.9 150.39,58.6 150.39,57.78 149.49,56.88 149.49,56.55 149.93,56.1 150.29,56.1 v1(150.91,56.72)
DDR_CS1_DIMMA#: length 52.8
  IN4 w0.089: v1(154.82,91.13) 154.36,91.13 154.2,90.98 154.2,87.04 155.1,86.14 155.58,86.14 157.62,84.11 157.62,83.85
  IN4 w0.152: 157.62,83.85 157.62,83.5 157.46,83.34 157.22,83.34 157.07,83.19 157.07,82.88 157.22,82.72 157.46,82.72 157.62,82.57 157.62,82.26 157.46,82.1 157.22,82.1 157.07,81.95 157.07,81.64 157.22,81.48 157.46,81.48 157.62,81.33 157.62,81.02 157.46,80.86 157.22,80.86 157.07,80.71 157.07,80.3 157.22,80.15 157.46,80.15 157.62,79.99 157.62,79.68 157.46,79.53 157.22,79.53 157.07,79.37 157.07,79.06 157.22,78.91 157.46,78.91 157.62,78.75 157.62,78.44 157.46,78.29 157.22,78.29 157.07,78.13 157.07,77.82 157.22,77.67 157.46,77.67 157.62,77.51 157.62,77.2 157.46,77.05 157.22,77.05 157.07,76.89 157.07,76.48 157.22,76.33 157.46,76.33 157.62,76.17 157.62,75.87 157.46,75.71 157.22,75.71 157.07,75.55 157.07,75.27 157.22,75.12 157.46,75.12 157.62,74.96 157.62,74.65 157.46,74.5 157.22,74.5 157.07,74.34 157.07,74.03 157.22,73.88 157.46,73.88 157.62,73.72 157.62,73.41 157.46,73.26 157.22,73.26 157.07,73.1 157.07,72.82 157.22,72.67 157.46,72.67 157.62,72.51 157.62,72.2 157.46,72.05 157.22,72.05 157.07,71.89 157.07,71.55 157.22,71.39 157.46,71.39 157.62,71.24 157.62,68.55 153.32,64.26 153.32,62 152.86,61.53 152.86,60.92 153.01,60.76 153.24,60.76 153.39,60.61 153.39,60.3 153.24,60.14 153.01,60.14 152.86,59.99 152.86,58.53 v1(152.89,58.5)
  BOTTOM w0.076: CPU1.AE2 155.43,93.96 155.43,93.14 155.51,93.06 155.63,93.06 155.71,92.98 155.71,92.74 155.63,92.66 155.28,92.66 155.2,92.59 155.2,92.37 155.28,92.29 155.63,92.29 155.71,92.22 155.71,92 155.63,91.93 v2(155.46,91.93) 155.28,91.93 155.2,91.85 155.2,91.63 155.28,91.56 155.63,91.56 155.71,91.48 155.71,91.03 155.46,90.77 155.19,90.77 v1(154.82,91.13)
  BOTTOM w0.175: JDIMM1.157 152.69,58.69 v1(152.89,58.5)
