# Allegro board LAD752PR10-0816.brd (continued)
## Placement (name value [footprint] x y rotation side) (continued)
PR8203  100K_0402_1%  [R_0402]  275.19 159.47 270 bottom
PR8204  4.7_1206_5%  [R_1206]  272.11 161.77 270 bottom
PR8205  2.2_0603_5%  [R_0603]  274.77 154.53 0 top
PR8206  8.66K_0402_1%  [R_0402]  272.93 156.88 0 top
PR8207  2.2_0603_5%  [R_0603]  276.49 162.34 0 bottom
PR8208  10K_0402_1%  [R_0402]  281.09 158.01 0 top
PR8209  100_0402_5%  [R_0402]  278.14 160.48 90 top
PR8210  4.7_1206_5%  [R_1206]  268.49 171.8 180 top
PR8211  34.8K_0402_1%  [R_0402]  281.07 155.96 0 top
PR8212  10K_0402_1%  [R_0402]  277.82 153.65 0 top
PR8213  1K_0402_1%  [R_0402]  281.82 149.55 180 top
PR8214  52.3K_0402_1%  [R_0402]  281.99 155.07 180 top
PR8215  10K_0402_1%  [R_0402]  278.27 151.05 270 top
PR8216  10K_0402_1%  [R_0402]  279.22 150.13 90 top
PT1  PAD~D  [TPC12]  156.05 142.74 180 bottom
PT2  PAD~D  [TPC12]  164.38 142.15 180 bottom
PT3  PAD~D  [TPC12]  172.73 142.4 180 bottom
PT4  PAD~D  [TPC12]  139.9 144.69 180 bottom
PT5  PAD~D  [TPC12]  148.47 145.45 180 bottom
PT6  PAD~D  [TPC12]  180.54 141.39 90 bottom
PU100  TPS51225CRUKR_QFN20_3X3  [TPS51225CRUKR_QFN20_3X3-S]  53.06 47.23 0 bottom
PU201  RT8207PGQW_WQFN20_3X3  [RT8207PGQW_WQFN20_3X3-S]  91.87 45.55 0 bottom
PU300  TPS51212DSCR_SON10_3X3  [TPS51212DSCR_SON10_3X3-S]  247.11 19.52 0 top
PU500  ISL95829HRTZ-T_TQFN48_6X6  [ISL95855HRTZ-T_TQFN48_6X6-S]  123.45 138.88 0 bottom
PU502  -  [SIC632CDT1GE3_POWERPAK31_5X5]  158.08 144.95 270 bottom
PU503  -  [SIC632CDT1GE3_POWERPAK31_5X5]  166.41 144.9 270 bottom
PU504  -  [SIC632CDT1GE3_POWERPAK31_5X5]  174.75 144.92 270 bottom
PU507  -  [SIC632CDT1GE3_POWERPAK31_5X5]  142.06 148.19 270 bottom
PU509  -  [SY8286RAC_QFN20_3X3]  120.01 115.89 0 bottom
PU510  -  [SIC632CDT1GE3_POWERPAK31_5X5]  150.39 148.21 270 bottom
PU511  -  [SIC531CDT1GE3_POWERPAK22_4X3]  182.43 143.38 270 bottom
PU700  BQ24780SRUYR_QFN28_4X4  [BQ24780RUYR_WQFN28_4X4-S]  58.64 24.28 270 top
PU800  -  [SY8286RAC_QFN20_3X3]  198.42 76.45 180 bottom
PU802  -  [RT8061AZQW_WDFN10_3X3]  232.33 37.07 90 bottom
PU1300  -  [RT9059GSP_SO8]  98.98 49 0 bottom
PU1301  -  [RT9059GSP_SO8]  203.68 73.86 90 bottom
PU6102  -  [NCP81382MNTXG_QFN38_4X6]  247.7 53.9 0 bottom
PU6201  -  [NCP81382MNTXG_QFN38_4X6]  239.14 53.91 0 bottom
PU6202  -  [NCP81382MNTXG_QFN38_4X6]  230.56 53.91 0 bottom
PU6301  -  [NCP81382MNTXG_QFN38_4X6]  221.87 54.9 0 bottom
PU6400  -  [NCP81382MNTXG_QFN38_4X6]  267.78 52.88 0 bottom
PU8200  RT8812AGQW-GP  [RT8812AGQW_WQFN20_3X3-S]  276.84 156.07 0 top
PU8201  -  [NCP81022MNTXG_QFN52_6X6]  289.47 59.14 180 bottom
Q7  -  [DMN65D8LDW-7_SOT363-6]  321.19 45 180 top
Q8  -  [DMN65D8LDW-7_SOT363-6]  322.54 41.05 180 top
Q9  -  [DMN65D8LDW-7_SOT363-6]  327.72 41.05 180 top
Q28  -  [DMN66D0LDW-7_SOT363-6]  118.16 31 0 top
Q29  -  [DMN66D0LDW-7_SOT363-6]  113.96 30.96 0 top
Q34  -  [DMN66D0LDW-7_SOT363-6]  107.3 31 0 top
Q2407  S TR METR3904W-G NPN SOT323-3  [MMST3904-7-F_SOT323-3]  141.29 131.54 0 bottom
Q2408  S TR METR3904W-G NPN SOT323-3  [MMST3904-7-F_SOT323-3]  277 66.84 0 top
Q2409  SI3456DDV-T1-GE3_TSOP6~D  [SI3456DDV-T1-GE3_TSOP6]  194.26 16.74 180 top
Q2410  L2N7002WT1G 1N SC-70-3  [SSM3K7002FU_SC70-3]  194.19 18.92 270 top
Q2411  S TR METR3904W-G NPN SOT323-3  [MMST3904-7-F_SOT323-3]  286.14 33.12 180 bottom
QE1  -  [DMN66D0LDW-7_SOT363-6]  325.25 41.05 180 top
QE2  2N7002W-T/R7_SOT323-3  [2N7002W-T-R7_SOT323-3]  309.75 7.69 180 top
QE3  -  [DMN66D0LDW-7_SOT363-6]  326.48 44.99 180 top
QE4  -  [DMN66D0LDW-7_SOT363-6]  323.94 44.99 180 top
QE5  2N7002W-T/R7_SOT323-3  [2N7002W-T-R7_SOT323-3]  293.56 41.13 0 top
QE8  LP2301ALT1G 1P SOT-23-3  [SI2301CDS-T1-GE3_SOT23-3]  207.23 149.02 90 bottom
QE13  DMN66D0LDW-7_SOT363-6~D  [DMN66D0LDW-7_SOT363-6]  203.24 173.35 180 top
QE21  DMN66D0LDW-7_SOT363-6~D  [DMN66D0LDW-7_SOT363-6]  200.76 173.35 180 top
QE22  DMN66D0LDW-7_SOT363-6~D  [DMN66D0LDW-7_SOT363-6]  205.71 173.35 180 top
QE29  -  [MMDT3904-7-F_SOT363-6]  233.95 30.62 90 bottom
QE39  -  [MMDT3904-7-F_SOT363-6]  228.04 20.91 90 bottom
QE40  -  [MMDT3904-7-F_SOT363-6]  228.04 24.15 90 bottom
QE41  -  [MMDT3904-7-F_SOT363-6]  228.04 27.39 90 bottom
QE42  -  [MMDT3904-7-F_SOT363-6]  228.04 30.62 90 bottom
QE43  -  [MMDT3904-7-F_SOT363-6]  233.95 27.39 90 bottom
QE44  -  [MMDT3904-7-F_SOT363-6]  233.95 24.15 90 bottom
QE45  -  [MMDT3904-7-F_SOT363-6]  233.95 20.91 90 bottom
QE46  -  [MMDT3904-7-F_SOT363-6]  235.85 30.62 90 top
QE47  -  [MMDT3904-7-F_SOT363-6]  235.85 27.39 90 top
QE48  -  [MMDT3904-7-F_SOT363-6]  235.85 24.15 90 top
QE49  -  [DMN66D0LDW-7_SOT363-6]  228.02 25.45 270 top
QE50  -  [DMN66D0LDW-7_SOT363-6]  225.94 22.57 180 top
QE51  -  [DMN66D0LDW-7_SOT363-6]  228.02 28.69 270 top
QE52  -  [DMN66D0LDW-7_SOT363-6]  228.02 22.21 270 top
QE53  -  [DMN66D0LDW-7_SOT363-6]  228.02 31.92 270 top
QE54  -  [BC857BS_SOT363-6]  225.94 25.94 180 top
QE55  -  [BC857BS_SOT363-6]  225.94 29.01 180 top
QE56  -  [BC857BS_SOT363-6]  224.54 32.16 180 top
QE57  -  [DMN66D0LDW-7_SOT363-6]  255.87 16.98 270 bottom
QG1  DMN66D0LDW-7 2N SOT363-6  [2N7002KDWH_SOT363-6]  213.93 121.62 180 bottom
QG2  -  [AO3413_SOT23-3]  204.97 84.32 90 bottom
QG3  -  [2N7002K_SOT23-3]  208.48 90.77 270 bottom
QG4  -  [2N7002K_SOT23-3]  203 86.73 180 bottom
QG505  DMN53D0LDW-7 2N SOT363-6  [2N7002DW-7-F_SOT363-6]  259.14 48.45 180 bottom
QG507  DMN53D0LDW-7 2N SOT363-6  [2N7002DW-7-F_SOT363-6]  261.76 48.38 180 bottom
QH5  DMN66D0LDW-7  [DMN66D0LDW-7_SOT363-6]  210.57 15.48 270 bottom
QL3  -  [2N7002K_SOT23-3]  260.04 160.65 180 top
QM1  LP2301ALT1G 1P SOT-23-3  [SI2301CDS-T1-GE3_SOT23-3]  143.68 164.99 90 bottom
QM2  -  [DMN66D0LDW-7_SOT363-6]  151.58 166.42 270 bottom
QM3  LP2301ALT1G 1P SOT-23-3  [SI2301CDS-T1-GE3_SOT23-3]  154.19 163.71 180 bottom
QS3  DMN65D8LW-7_SOT323-3  [SSM3K7002FU_SC70-3]  186.7 71.35 0 top
QU1  2N7002W-T/R7_SOT323-3  [2N7002W-T-R7_SOT323-3]  306.61 55.23 0 top
QV1  -  [SI3457CDV-T1-GE3_TSOP6]  159.84 170.59 270 bottom
QV2  2N7002W-T/R7_SOT323-3  [2N7002W-T-R7_SOT323-3]  158.56 165.74 270 bottom
QV95  SSM3K7002FU_SC70-3~D  [SSM3K7002FU_SC70-3]  191.32 108.27 0 bottom
QX2  S TR METR3904W-G NPN SOT323-3  [MMST3904-7-F_SOT323-3]  225.93 166.44 90 bottom
QX3  S TR METR3904W-G NPN SOT323-3  [MMST3904-7-F_SOT323-3]  209.61 160.53 90 bottom
R2  0_0603_5%  [R0603_0OHM]  193.56 13.43 180 bottom
R144  2.2K_0402_5%  [R_0402]  117.09 30.16 90 top
R145  2.2K_0402_5%  [R_0402]  109.6 30.16 90 top
R146  2.2K_0402_5%  [R_0402]  117.09 32.06 90 top
R147  2.2K_0402_5%  [R_0402]  109.6 32.06 90 top
R150  2.2K_0402_5%  [R_0402]  112.84 29.93 90 top
R154  2.2K_0402_5%  [R_0402]  112.84 31.68 90 top
R174  10K_0402_5%  [R_0402]  64.44 17.84 270 bottom
R179  300K_0402_5%~D  [R_0402]  193 20.05 180 top
R180  1.5M_0402_5%~D  [R_0402]  193 19.15 180 top
R181  10K_0402_5%  [R_0402]  186.7 44.87 90 bottom
R182  0_0402_5%  [R_0402]  63.48 17.84 270 bottom
R183  10K_0402_5%  [R_0402]  204.06 108.07 90 bottom
R184  0_0402_5%  [R0402_0OHM]  186.7 55.44 270 bottom
R185  0_0402_5%  [R0402_0OHM]  188.48 47.16 90 bottom
R307  100K_0402_1%  [R_0402]  321.19 37.17 90 top
R325  100K_0402_1%  [R_0402]  326.53 37.17 90 top
R363  10K_0201_5%  [R_0201]  327.84 31.26 0 top
R364  10K_0201_5%  [R_0201]  236.28 7.31 0 top
R365  10K_0201_5%  [R_0201]  274.01 7.27 0 top
R366  10K_0201_5%  [R_0201]  207.5 25.11 180 top
R367  10K_0402_5%  [R_0402]  199.59 60.64 0 top
RA1  0_0603_5%  [R0603_0OHM]  16.79 27.78 90 top
RA2  22_0402_1%  [R_0402]  37.47 27.65 0 bottom
RA3  0_0603_5%  [R0603_0OHM]  27.25 40.23 270 top
RA4  0_0603_5%  [R0603_0OHM]  25.54 16.92 270 top
RA5  0_0603_5%  [R_0603]  33.8 22.95 0 bottom
RA6  0_0603_5%  [R0603_0OHM]  28.65 33.43 0 top
RA7  0_0603_5%  [R0603_0OHM]  15.07 1.8 0 top
RA8  0_0603_5%  [R0603_0OHM]  29.17 36.79 0 top
RA9  10K_0402_5%  [R_0402]  36.6 25.1 90 top
RA10  22_0402_1%  [R_0402]  36.03 25.31 270 bottom
RA11  0_0603_5%  [R0603_0OHM]  40.79 29.94 270 top
RA12  0_0201_5%  [R_0201]  31.28 22.7 0 bottom
RA13  10K_0402_5%  [R_0402]  20.85 25.31 180 top
RA15  1K_0402_1%  [R_0402]  35.14 20.97 90 top
RA16  10K_0402_5%  [R_0402]  34.25 21.88 270 top
RA17  0_0201_5%  [R_0201]  37.16 26.25 0 bottom
RA18  22_0402_5%  [R_0402]  38.07 25.36 180 bottom
RA19  0_0201_5%  [R0201_0OHM]  35.9 35.72 180 bottom
RA21  100K_0201_1%  [R_0201]  34.2 33.46 90 top
RA22  1K_0402_1%  [R_0402]  34.22 34.77 90 top
RA24  10K_0402_5%  [R_0402]  38.39 31.46 180 top
RA25  0_0201_5%  [R0201_0OHM]  38.06 28.79 180 top
RA26  2.2K_0201_5%  [R_0201]  25.69 19.63 0 bottom
RA27  33_0402_5%  [R_0402]  37.28 34.42 90 top
RA28  2.2K_0201_5%  [R_0201]  27.68 22 0 top
RA29  33_0402_5%  [R_0402]  35.82 34.63 90 top
RA30  33_0402_5%  [R_0402]  37.28 33.61 90 bottom
RA31  33_0402_5%  [R_0402]  37.22 32.6 0 bottom
RA32  100K_0402_1%  [R_0402]  38.39 28.79 180 bottom
RA33  33_0402_5%  [R_0402]  38.55 32.59 90 top
RA34  200K_0402_1%  [R_0402]  37.47 29.68 0 top
RA35  2_0402_1%  [R_0402]  26.04 17.76 270 bottom
RA36  100K_0402_1%  [R_0402]  37.47 30.57 0 top
RA37  2_0402_1%  [R_0402]  20.19 20.69 180 top
RA38  0_0201_5%  [R0201_0OHM]  23.62 20.73 180 top
RA39  0_0201_5%  [R0201_0OHM]  19.34 21.43 0 top
RA40  2.2K_0201_5%  [R_0201]  25.37 25.11 180 top
RA41  2.2K_0201_5%  [R_0201]  25.37 26.57 180 top
RA42  8.2_0402_5%~D  [R_0402]  25.37 24.22 180 top
RA43  8.2_0402_5%~D  [R_0402]  25.37 27.52 180 top
RA44  22K_0201_5%  [R_0201]  22.75 24.99 180 top
RA45  22K_0201_5%  [R_0201]  23.61 21.38 180 top
RA46  0_0201_5%  [R0201_0OHM]  24.43 28.86 180 top
RA47  0_0201_5%  [R0201_0OHM]  22.68 26.22 90 top
RA50  1K_0402_5%  [R_0402]  40.15 10.52 180 bottom
RA51  0_0402_5%  [R0402_0OHM]  37.53 10.53 270 bottom
RA52  1K_0201_1%  [R_0201]  37.6 11.3 90 bottom
RA53  1K_0402_5%  [R_0402]  40.15 9.63 180 bottom
RA55  0_0402_5%  [R0402_0OHM]  40.45 16.31 270 top
RA56  0_0402_5%  [R0402_0OHM]  39.57 16.31 270 top
RA57  0.2_0805_1%  [R_0805]  38.17 1.78 90 bottom
RA58  39K_0402_0.1%  [R_0402]  33.34 16.31 270 top
RA59  39K_0402_0.1%  [R_0402]  32.46 16.24 270 top
RA60  0.2_0805_1%  [R_0805]  32.39 3.46 180 bottom
RA61  39K_0402_0.1%  [R_0402]  29.79 16.24 270 top
RA62  22.1K_0402_1%  [R_0402]  38.38 7.84 180 bottom
RA63  39K_0402_0.1%  [R_0402]  28.84 15.79 270 top
RA64  39K_0402_0.1%  [R_0402]  27.74 13.95 0 top
RA65  39K_0402_0.1%  [R_0402]  27.74 11.22 0 top
RA66  10K_0402_5%  [R_0402]  35.64 15.92 270 bottom
RA67  10K_0402_5%  [R_0402]  34.74 15.01 90 bottom
RA68  0_0603_5%  [R0603_0OHM]  29.22 38.51 180 bottom
RA69  0_0603_5%  [R_0603]  34.44 36.79 90 top
RA70  10K_0402_5%  [R_0402]  37.79 16.3 270 top
RA73  10_0402_1%  [R_0402]  40.2 5.11 45 bottom
RA74  10_0402_1%  [R_0402]  35.81 1.62 0 top
RA75  10_0402_1%  [R_0402]  33.73 2.52 270 bottom
RA76  10_0402_1%  [R_0402]  31.07 1.56 180 top
RA77  10K_0402_0.1%  [R_0402]  34.23 15.39 90 top
RA78  10K_0402_0.1%  [R_0402]  31.56 15.33 90 top
RA79  10K_0402_0.1%  [R_0402]  30.67 15.33 90 top
RA80  10K_0402_0.1%  [R_0402]  27.96 15.08 180 top
RA81  10K_0402_0.1%  [R_0402]  28.65 13.06 180 top
RA82  10K_0402_0.1%  [R_0402]  28.65 12.1 180 top
RA83  0_0805_5%  [R_0805]  28.77 4.82 270 bottom
RA84  0_0201_5%  [R0201_0OHM]  21.31 28.15 180 top
RA85  0_0201_5%  [R_0201]  21.31 27.57 180 top
RC2  24.9_0402_1%  [R_0402]  170.95 89.92 180 bottom
RC9  1K_0402_5%  [R_0402]  127.02 160.88 180 top
RC30  24.9_0402_1%  [R_0402]  176.2 124.8 0 bottom
RC35  51_0402_1%  [R_0402]  126.62 156.56 0 top
RC62  49.9K_0402_1%  [R_0402]  213.31 14.46 270 bottom
RC63  49.9K_0402_1%  [R_0402]  207.72 15.92 270 top
RC65  49.9K_0402_1%  [R_0402]  215.1 13.24 180 bottom
RC66  20_0402_5%  [R_0402]  175.72 114.6 270 bottom
RC348  51_0402_1%  [R_0402]  126.55 158.34 0 top
RC353  1K_0402_5%  [R_0402]  129.24 159.67 180 top
RC354  1K_0402_1%  [R_0402]  128.39 161.07 0 top
RC355  1K_0402_1%  [R_0402]  126.55 159.67 0 top
RD1  0_0402_5%  [R_0402]  178.25 52.18 270 top
RD2  0_0402_5%  [R_0402]  178.57 53.23 90 top
RD3  0_0402_5%  [R_0402]  156.55 47.69 270 top
RD4  0_0402_5%  [R_0402]  176.67 39.61 270 top
RD5  0_0402_5%  [R_0402]  177.55 39.61 270 top
RD6  0_0402_5%  [R_0402]  157.12 39.43 270 top
RD28  0_0402_5%  [R_0402]  177.36 51.26 90 top
RD29  0_0402_5%  [R_0402]  177.68 54.25 90 top
RD30  0_0402_5%  [R_0402]  155.66 46.77 90 top
RD31  0_0402_5%  [R_0402]  138.32 51.35 90 top
RD35  470_0402_1%  [R_0402]  136.54 51.35 90 top
RD38  0_0402_5%  [R_0402]  176.35 36.75 270 top
RD39  0_0402_5%  [R_0402]  177.24 36.75 270 top
RD40  0_0402_5%  [R_0402]  156.23 39.43 270 top
RE1  4.7K_0402_5%  [R_0402]  311.56 20.63 270 top
RE2  4.7K_0402_5%  [R_0402]  312.45 20.63 270 top
RE7  1K_0402_1%~D  [R_0402]  323.67 10.7 180 top
RE8  10K_0402_5%  [R_0402]  315.1 20.62 270 top
RE9  15_0402_5%  [R_0402]  96.02 12.94 270 bottom
RE10  15_0402_5%  [R_0402]  98.43 12.94 270 bottom
RE11  15_0402_5%  [R_0402]  95.69 10.51 0 bottom
RE12  10K_0402_5%~D  [R_0402]  97.1 12.02 90 bottom
RE13  10K_0402_5%~D  [R_0402]  97.68 20.1 180 bottom
RE14  10K_0402_5%~D  [R_0402]  104.59 17.38 270 bottom
RE15  100K_0402_5%  [R_0402]  290.72 28.3 270 top
RE16  100K_0402_5%  [R_0402]  322.65 47.03 270 top
RE17  100K_0402_5%  [R_0402]  325.13 47.03 270 top
RE20  10K_0402_5%  [R_0402]  95.91 20.61 180 bottom
RE21  100K_0402_5%  [R_0402]  326.34 47.03 270 top
RE23  100K_0402_5%  [R_0402]  325.26 37.17 90 top
RE24  0_0603_5%  [R0603_0OHM]  309.17 20.75 0 top
RE25  4.7K_0402_1%  [R_0402]  220.56 151.77 90 top
RE26  4.7K_0402_1%~D  [R_0402]  185.63 24.97 270 top
RE27  4.7K_0402_1%  [R_0402]  186.58 24.06 90 top
RE28  100K_0402_5%  [R_0402]  207.39 152.56 180 bottom
RE29  4.7K_0402_1%~D  [R_0402]  183.87 22.17 180 top
RE30  4.7K_0402_1%  [R_0402]  183.87 21.21 180 top
RE31  10K_0402_5%~D  [R_0402]  223.16 156.81 0 top
RE32  4.7K_0402_1%  [R_0402]  191.03 24.72 270 top
RE37  10K_0402_5%  [R_0402]  187.54 24.06 90 top
RE40  4.7K_0402_1%~D  [R_0402]  223.53 159.58 180 top
RE42  4.7K_0402_1%~D  [R_0402]  221.38 161.47 90 top
RE43  4.7K_0402_1%~D  [R_0402]  224.08 157.69 180 top
RE44  4.7K_0402_1%~D  [R_0402]  220.49 161.47 90 top
RE63  100K_0402_5%  [R_0402]  310.02 14.93 180 top
RE64  100K_0402_1%  [R_0402]  288.11 6.59 270 top
RE66  0_0402_1%  [R_0402]  288.1 8.43 270 top
RE70  10K_0402_5%  [R_0402]  310.02 16.84 180 top
RE74  43_0402_1%  [R_0402]  310.02 12.9 180 top
RE75  10K_0402_5%  [R_0402]  292.16 25.48 90 top
RE76  43_0402_1%  [R_0402]  309.11 18.62 0 top
RE78  0_0402_5%  [R0402_0OHM]  307.78 5.67 90 top
RE79  10K_0402_5%  [R_0402]  310.02 9.98 180 top
RE83  10K_0402_5%  [R_0402]  309.11 23.95 0 top
RE84  10K_0402_5%  [R_0402]  310.02 12.01 180 top
RE85  53.6K_0402_5%  [R_0402]  310.02 11 180 top
RE89  0_0402_5%  [R_0402]  302.13 26.82 270 top
RE90  2.2K_0804_8P4R_5%  [RP_0804_8P4R]  299.7 6.07 270 top
RE91  47K_0402_5%  [R_0402]  330.46 38.31 90 top
RE100  4.7K_0402_5%  [R_0402]  302.67 4.6 90 top
RE101  4.7K_0402_5%  [R_0402]  303.56 4.6 90 top
RE102  100K_0402_5%  [R_0402]  288.36 12.41 180 top
RE154  10K_0402_5%  [R_0402]  201.91 175.19 270 top
RE155  1K_0402_1%  [R_0402]  200.53 174.3 90 top
RE156  10K_0402_5%  [R_0402]  198.41 172.03 90 top
RE157  1K_0402_1%  [R_0402]  205.74 174.3 90 top
RE158  10K_0402_5%  [R_0402]  204.31 175.23 270 top
RE160  1K_0402_1%  [R_0402]  203.32 174.3 90 top
RE161  10K_0402_5%  [R_0402]  152.47 164.13 270 top
RE162  4.7K_0402_1%  [R_0402]  290.65 47.33 90 bottom
RE163  4.7K_0402_1%  [R_0402]  286.76 46.13 180 bottom
RE164  4.7K_0402_1%  [R_0402]  286.76 45.12 180 bottom
RE165  4.7K_0402_1%  [R_0402]  289.63 48.24 270 bottom
RE166  4.7K_0402_1%  [R_0402]  285.77 40.52 0 bottom
RE167  10K_0402_5%~D  [R_0402]  286.76 44.1 180 bottom
RE300  10K_0201_1%  [R_0201]  155.11 167.8 180 bottom
RE396  10K_0201_1%  [R_0201]  236.74 30.35 90 bottom
RE397  1M_0201_1%  [R_0201]  236.74 31.62 90 bottom
RE398  1M_0201_1%  [R_0201]  234.62 32.86 180 bottom
RE399  10K_0201_1%  [R_0201]  233.05 32.2 270 bottom
RE400  1M_0201_1%  [R_0201]  235.3 32.86 0 bottom
RE401  1M_0201_1%  [R_0201]  233.05 30.93 270 bottom
RE449  10K_0201_1%  [R_0201]  227.15 25.72 270 top
RE451  1M_0201_1%  [R_0201]  229.4 23.15 0 bottom
RE452  1M_0201_1%  [R_0201]  228.71 23.15 180 bottom
RE453  1M_0201_1%  [R_0201]  227.15 21.28 270 bottom
RE454  10K_0201_1%  [R_0201]  227.15 22.49 270 bottom
RE455  10K_0201_1%  [R_0201]  230.83 20.63 90 bottom
RE456  1M_0201_1%  [R_0201]  230.83 21.9 90 bottom
RE457  1M_0201_1%  [R_0201]  229.4 26.38 0 bottom
RE458  1M_0201_1%  [R_0201]  227.15 24.52 270 bottom
RE459  1M_0201_1%  [R_0201]  228.71 26.38 180 bottom
RE460  10K_0201_1%  [R_0201]  227.15 25.72 270 bottom
RE461  10K_0201_1%  [R_0201]  230.83 23.87 90 bottom
RE462  1M_0201_1%  [R_0201]  230.83 25.14 90 bottom
RE463  1M_0201_1%  [R_0201]  229.4 29.62 0 bottom
RE464  1M_0201_1%  [R_0201]  228.71 29.62 180 bottom
RE465  1M_0201_1%  [R_0201]  227.15 27.76 270 bottom
RE466  10K_0201_1%  [R_0201]  230.83 27.11 90 bottom
RE467  10K_0201_1%  [R_0201]  227.15 28.96 270 bottom
RE468  1M_0201_1%  [R_0201]  230.83 28.38 90 bottom
RE469  1M_0201_1%  [R_0201]  228.71 32.86 180 bottom
RE470  1M_0201_1%  [R_0201]  229.4 32.86 0 bottom
RE471  10K_0201_1%  [R_0201]  230.83 30.35 90 bottom
RE472  1M_0201_1%  [R_0201]  227.15 30.99 270 bottom
RE473  1M_0201_1%  [R_0201]  230.83 31.62 90 bottom
RE474  10K_0201_1%  [R_0201]  227.15 32.2 270 bottom
RE475  1M_0201_1%  [R_0201]  234.62 29.62 180 bottom
RE476  10K_0201_1%  [R_0201]  236.74 27.11 90 bottom
RE477  1M_0201_1%  [R_0201]  235.3 29.62 0 bottom
RE478  1M_0201_1%  [R_0201]  236.74 28.38 90 bottom
RE479  1M_0201_1%  [R_0201]  233.05 27.69 270 bottom
RE480  10K_0201_1%  [R_0201]  233.05 28.96 270 bottom
RE481  1M_0201_1%  [R_0201]  234.62 26.38 180 bottom
RE482  10K_0201_1%  [R_0201]  236.74 23.87 90 bottom
RE483  1M_0201_1%  [R_0201]  235.3 26.38 0 bottom
RE484  1M_0201_1%  [R_0201]  236.74 25.14 90 bottom
RE485  1M_0201_1%  [R_0201]  233.05 24.45 270 bottom
RE486  10K_0201_1%  [R_0201]  233.05 25.72 270 bottom
RE487  1M_0201_1%  [R_0201]  234.62 23.15 180 bottom
RE488  10K_0201_1%  [R_0201]  236.74 20.63 90 bottom
RE489  1M_0201_1%  [R_0201]  235.3 23.15 0 bottom
RE490  1M_0201_1%  [R_0201]  236.74 21.9 90 bottom
RE491  1M_0201_1%  [R_0201]  233.05 21.22 270 bottom
RE492  10K_0201_1%  [R_0201]  233.05 22.49 270 bottom
RE493  1M_0201_1%  [R_0201]  235.3 32.86 0 top
RE494  1M_0201_1%  [R_0201]  234.62 32.86 180 top
RE495  10K_0201_1%  [R_0201]  233.05 30.41 90 top
RE496  1M_0201_1%  [R_0201]  236.74 30.93 270 top
RE497  1M_0201_1%  [R_0201]  233.05 31.62 90 top
RE498  10K_0201_1%  [R_0201]  236.74 32.2 270 top
RE499  1M_0201_1%  [R_0201]  234.62 29.62 180 top
RE500  1M_0201_1%  [R_0201]  235.3 29.62 0 top
RE501  1M_0201_1%  [R_0201]  236.74 27.69 270 top
RE502  10K_0201_1%  [R_0201]  233.05 27.17 90 top
RE503  10K_0201_1%  [R_0201]  236.74 28.96 270 top
RE504  1M_0201_1%  [R_0201]  233.05 28.38 90 top
RE505  1M_0201_1%  [R_0201]  235.3 26.38 0 top
RE506  1M_0201_1%  [R_0201]  234.62 26.38 180 top
RE507  10K_0201_1%  [R_0201]  233.05 23.93 90 top
RE508  1M_0201_1%  [R_0201]  236.74 24.52 270 top
RE509  1M_0201_1%  [R_0201]  233.05 25.14 90 top
RE510  10K_0201_1%  [R_0201]  236.74 25.79 270 top
RE511  10K_0201_1%  [R_0201]  227.15 24.45 270 top
RE512  1M_0201_1%  [R_0201]  230.83 24.45 270 top
RE513  1K_0201_1%  [R_0201]  230.83 25.72 270 top
RE514  10K_0201_1%  [R_0201]  223.4 24.33 270 top
RE515  1M_0201_1%  [R_0201]  223.4 21.34 270 top
RE516  1K_0201_1%  [R_0201]  223.4 22.61 270 top
RE517  10K_0201_1%  [R_0201]  223.4 25.53 270 top
RE518  10K_0201_1%  [R_0201]  227.15 27.69 270 top
RE519  1M_0201_1%  [R_0201]  230.83 27.69 270 top
RE520  1K_0201_1%  [R_0201]  230.83 28.96 270 top
RE521  10K_0201_1%  [R_0201]  227.15 28.96 270 top
RE522  10K_0201_1%  [R_0201]  227.15 21.22 270 top
RE523  1M_0201_1%  [R_0201]  230.83 21.22 270 top
RE524  1K_0201_1%  [R_0201]  230.83 22.49 270 top
RE525  10K_0201_1%  [R_0201]  227.15 22.49 270 top
RE526  10K_0201_1%  [R_0201]  227.15 30.93 270 top
RE527  1M_0201_1%  [R_0201]  230.83 30.93 270 top
RE528  1K_0201_1%  [R_0201]  230.83 32.2 270 top
RE529  10K_0201_1%  [R_0201]  227.15 32.2 270 top
RE530  47K_0402_5%  [R_0402]  306.84 46.37 90 top
RE630  100K_0201_1%  [R_0201]  143.26 9.09 270 top
RE631  100K_0201_1%  [R_0201]  143.9 9.09 270 top
RE632  100K_0201_1%  [R_0201]  144.53 9.09 270 top
RE633  100K_0201_1%  [R_0201]  145.17 9.09 270 top
RE634  100K_0201_1%  [R_0201]  145.87 9.09 270 top
RE635  100K_0201_1%  [R_0201]  146.5 9.09 270 top
RE636  1.1K_0402_1%  [R_0402]  257.7 15.34 180 bottom
RE637  1K_0201_1%  [R_0201]  252.45 16.22 0 bottom
RE638  1M_0201_1%  [R_0201]  253.03 15.59 180 bottom
RE639  1.1K_0402_1%  [R_0402]  251.9 17.11 0 bottom
RE640  1K_0201_1%  [R_0201]  257.35 16.42 180 bottom
RE641  1M_0201_1%  [R_0201]  256.76 16.99 0 bottom
RE642  4.7K_0402_5%  [R_0402]  303.79 45.5 180 top
RE643  4.7K_0402_5%  [R_0402]  303.79 46.83 180 top
RE644  100K_0402_5%  [R_0402]  311.98 51.09 0 top
RE645  10K_0402_5%  [R_0402]  311.84 23.97 0 top
RE646  0_0201_5%  [R_0201]  307.29 25.39 90 top
RE647  0_0402_5%  [R_0402]  158.01 162.72 180 top
RE648  0_0402_5%  [R_0402]  158.01 163.61 180 top
RE649  10K_0402_5%  [R_0402]  309.19 46.37 90 top
RE650  10K_0402_5%  [R_0402]  293.75 43.99 180 top
RE651  0_0402_5%  [R_0402]  316.92 19.64 90 top
RE652  10K_0402_5%  [R_0402]  143.61 166.68 0 top
RF1  10K_0402_5%  [R_0402]  105.03 57.31 0 top
RF2  10K_0402_5%  [R_0402]  105.04 61.2 270 top
RF3  10K_0402_5%  [R_0402]  105.03 58.26 0 top
RF4  10K_0402_5%  [R_0402]  287.52 74.01 180 top
RF5  10K_0402_5%  [R_0402]  287.52 74.9 180 top
RF6  10K_0402_5%  [R_0402]  292.45 73.97 180 top
RG1  100K_0402_5%  [R_0402]  210.85 115.51 270 bottom
RG2  10K_0402_5%  [R_0402]  209.6 119.5 90 bottom
RG3  200_0402_1%  [R_0402]  228.13 89.53 0 top
RG5  10K_0402_5%  [R_0402]  233.79 80.52 270 top
RG6  10K_0402_5%  [R_0402]  232.91 80.52 270 top
RG7  1K_0201_1%  [R_0201]  216.16 110.01 0 top
RG8  1K_0201_1%  [R_0201]  216.16 112.81 0 top
RG12  5.1K_0402_1%~D  [R_0402]  214.37 101.31 0 bottom
RG13  5.1K_0402_1%~D  [R_0402]  214.45 100.43 0 bottom
RG17  1K_0402_1%  [R_0402]  223.19 101.89 90 top
RG18  10K_0402_5%  [R_0402]  235.4 86.9 270 top
RG19  10K_0402_5%  [R_0402]  235.28 85.13 270 top
RG20  1K_0402_1%  [R_0402]  224.98 102.8 180 top
RG22  0_0402_5%  [R_0402]  211.72 85.5 0 bottom
RG23  100K_0402_5%  [R_0402]  215.4 85.76 180 bottom
RG24  10K_0402_5%  [R_0402]  215.4 86.65 180 bottom
RG25  10K_0402_5%  [R_0402]  231.27 90.92 180 top
RG26  10K_0402_5%  [R_0402]  232.62 90.66 270 top
RG27  0_0402_5%  [R_0402]  228.93 83.9 90 top
RG28  0_0402_5%  [R_0402]  228.67 76.09 90 bottom
RG29  0_0402_5%  [R_0402]  227.72 76.09 90 bottom
RG30  0_0402_5%  [R_0402]  207.36 60.29 90 bottom
RG38  10K_0402_5%  [R_0402]  215.29 102.2 180 bottom
RG39  4.7K_0402_5%  [R_0402]  213.67 115.51 270 bottom
RG40  0_0402_5%  [R_0402]  213.87 119.75 180 bottom
RG41  45.3K_0402_1%  [R_0402]  215.06 122.88 270 bottom
RG42  45.3K_0402_1%  [R_0402]  214.46 124.87 180 bottom
RG43  0_0402_5%  [R_0402]  244.4 103.37 90 top
RG44  200_0402_1%  [R_0402]  225.3 85.78 180 top
RG45  200_0402_1%  [R_0402]  226.07 76.09 90 bottom
RG46  150_0402_1%  [R_0402]  234.24 77.98 270 top
RG47  220K_0402_5%  [R_0402]  210.3 90.05 270 bottom
RG48  220_0603_5%  [R_0603]  202.87 83.49 90 bottom
RG49  10K_0402_5%  [R_0402]  209.35 87.95 270 bottom
RG50  0_0402_5%  [R_0402]  206.39 87.05 180 bottom
RG51  10K_0402_5%  [R_0402]  210.3 87.04 90 bottom
RG52  60.4_0402_1%  [R_0402]  225.26 138.74 180 top
RG53  60.4_0402_1%  [R_0402]  225.26 139.63 180 top
RG54  60.4_0402_1%  [R_0402]  238.06 140.58 0 top
RG55  60.4_0402_1%  [R_0402]  254.15 138.93 180 top
RG56  60.4_0402_1%  [R_0402]  254.15 138.04 180 top
RG57  60.4_0402_1%  [R_0402]  209.55 138.74 0 top
RG58  60.4_0402_1%  [R_0402]  209.55 137.85 0 top
RG59  60.4_0402_1%  [R_0402]  238.06 139.69 0 top
RG60  120_0402_1%  [R_0402]  216.99 113.63 90 top
RG61  120_0402_1%  [R_0402]  243.38 106.4 90 top
RG62  40.2_0402_1%  [R_0402]  239.83 107.25 270 top
RG63  4.7K_0402_5%  [R_0402]  254.63 113.57 0 top
RG64  40.2_0402_1%  [R_0402]  231.45 107.7 270 top
RG65  51.1_0402_1%  [R_0402]  255.46 112.38 0 top
RG66  10_0402_1%  [R_0402]  255.55 111.16 180 top
RG67  100_0402_1%  [R_0402]  240.77 106.1 0 top
RG68  4.99K_0402_1%  [R_0402]  252.8 111.16 0 top
RG69  100_0402_1%  [R_0402]  231.9 105.91 180 top
RG70  60.4_0402_1%  [R_0402]  275.7 126.34 90 top
RG71  60.4_0402_1%  [R_0402]  274.82 126.34 90 top
RG72  60.4_0402_1%  [R_0402]  277.42 106.21 90 top
RG73  60.4_0402_1%  [R_0402]  278.31 106.21 90 top
RG74  60.4_0402_1%  [R_0402]  275.92 98.25 90 top
RG75  60.4_0402_1%  [R_0402]  275.03 98.25 90 top
RG76  60.4_0402_1%  [R_0402]  276.68 76.22 90 top
RG77  60.4_0402_1%  [R_0402]  275.81 76.22 90 top
RG78  120_0402_1%  [R_0402]  239.82 90.1 270 top
RG79  120_0402_1%  [R_0402]  244.55 106.4 0 top
RG80  4.7K_0402_5%  [R_0402]  256.31 90.9 180 top
RG81  51.1_0402_1%  [R_0402]  254.53 90.9 180 top
RG82  10_0402_1%  [R_0402]  253.04 91.8 90 top
RG83  40.2_0402_1%  [R_0402]  246.33 101.6 180 top
RG84  40.2_0402_1%  [R_0402]  246.36 92 180 top
RG85  4.99K_0402_1%  [R_0402]  250.14 92 0 top
RG86  100_0402_1%  [R_0402]  245.48 100.4 180 top
RG87  100_0402_1%  [R_0402]  244.47 91.89 270 top
RG88  1K_0402_1%  [R_0402]  215.96 137.29 270 top
RG89  1K_0402_1%  [R_0402]  218.58 139.02 90 top
RG90  1K_0402_1%  [R_0402]  210.89 136.51 270 top
RG91  1K_0402_1%  [R_0402]  223.47 137.86 270 top
RG92  121_0402_1%  [R_0402]  202.71 139.48 180 bottom
RG93  121_0402_1%  [R_0402]  230.32 141.66 0 top
RG94  2.37K_0402_1%  [R_0402]  223.39 146.17 0 bottom
RG95  2.37K_0402_1%  [R_0402]  210.47 128.01 180 bottom
RG96  5.49K_0402_1%  [R_0402]  209.55 128.89 0 bottom
RG97  5.49K_0402_1%  [R_0402]  225.44 128.96 270 bottom
RG98  2.37K_0402_1%  [R_0402]  201.8 135.88 0 bottom
RG99  2.37K_0402_1%  [R_0402]  231.28 140.72 270 top
RG100  5.49K_0402_1%  [R_0402]  202.72 136.9 180 bottom
RG101  5.49K_0402_1%  [R_0402]  231.28 138.94 270 top
RG102  1K_0402_1%  [R_0402]  243.72 136.82 270 top
RG103  1K_0402_1%  [R_0402]  238.08 138.8 0 top
RG104  1K_0402_1%  [R_0402]  246.82 136.59 270 top
RG105  121_0402_1%  [R_0402]  232.68 141.71 90 top
RG106  1K_0402_1%  [R_0402]  253.12 136.76 270 top
RG107  121_0402_1%  [R_0402]  259.84 139.18 0 bottom
RG108  2.37K_0402_1%  [R_0402]  252.95 146.18 0 bottom
RG109  2.37K_0402_1%  [R_0402]  238.14 146.12 270 top
RG110  5.49K_0402_1%  [R_0402]  255.22 128.97 270 bottom
RG111  5.49K_0402_1%  [R_0402]  237.25 145.2 90 top
RG112  2.37K_0402_1%  [R_0402]  260.76 136.51 180 bottom
RG113  2.37K_0402_1%  [R_0402]  234.52 146.12 270 top
RG114  5.49K_0402_1%  [R_0402]  259.84 137.4 0 bottom
RG115  5.49K_0402_1%  [R_0402]  233.63 145.2 90 top
RG116  1K_0402_1%  [R_0402]  274.84 112.1 90 top
RG117  1K_0402_1%  [R_0402]  275.74 114.97 180 top
RG118  1K_0402_1%  [R_0402]  276.53 106.21 90 top
RG119  1K_0402_1%  [R_0402]  283.84 121.76 0 bottom
RG120  121_0402_1%  [R_0402]  279.76 100.26 0 top
RG121  121_0402_1%  [R_0402]  279.45 126.34 90 top
RG122  2.37K_0402_1%  [R_0402]  265.85 124.58 0 bottom
RG123  2.37K_0402_1%  [R_0402]  265.79 103.75 0 bottom
RG124  5.49K_0402_1%  [R_0402]  266.7 104.64 180 bottom
RG125  5.49K_0402_1%  [R_0402]  266.76 123.69 180 bottom
RG126  2.37K_0402_1%  [R_0402]  273.55 129.16 270 bottom
RG127  2.37K_0402_1%  [R_0402]  278.33 100.95 270 top
RG128  5.49K_0402_1%  [R_0402]  274.5 128.25 90 bottom
RG129  5.49K_0402_1%  [R_0402]  276.54 100.02 180 top
RG130  1K_0402_1%  [R_0402]  274.84 84.09 90 top
RG131  1K_0402_1%  [R_0402]  274.8 87.13 0 top
RG132  1K_0402_1%  [R_0402]  282.69 79.65 90 top
RG133  1K_0402_1%  [R_0402]  276.48 93.38 0 top
RG134  121_0402_1%  [R_0402]  279.45 72.65 270 top
RG135  121_0402_1%  [R_0402]  277.96 98.2 180 top
RG136  2.37K_0402_1%  [R_0402]  265.79 92.83 0 bottom
RG137  2.37K_0402_1%  [R_0402]  265.79 75.71 0 bottom
RG138  5.49K_0402_1%  [R_0402]  266.7 93.72 180 bottom
RG139  5.49K_0402_1%  [R_0402]  266.7 76.6 180 bottom
RG140  2.37K_0402_1%  [R_0402]  283.84 96.36 0 bottom
RG141  2.37K_0402_1%  [R_0402]  278.57 71.72 180 top
RG142  5.49K_0402_1%  [R_0402]  283.84 98.35 0 bottom
RG143  5.49K_0402_1%  [R_0402]  276.79 71.72 180 top
RG144  5.1K_0201_1%  [R_0201]  226.62 88.38 180 top
RG145  5.1K_0201_1%  [R_0201]  215.08 103.03 180 bottom
RG146  5.1K_0201_1%  [R_0201]  215.08 103.66 180 bottom
RG147  5.1K_0201_1%  [R_0201]  221.18 102.65 180 top
RG148  5.1K_0201_1%  [R_0201]  221.18 101.95 180 top
RG149  10K_0201_5%  [R_0201]  237.82 76.45 90 bottom
RG150  10K_0201_5%  [R_0201]  241.23 76.97 270 bottom
RG151  10K_0201_5%  [R_0201]  238.45 76.45 90 bottom
RG152  0_0402_5%  [R_0402]  209.88 114.57 90 bottom
RG153  5.1K_0201_1%  [R_0201]  215.08 104.3 180 bottom
RG154  5.1K_0201_1%  [R_0201]  218.13 105.19 0 top
RG155  5.1K_0201_1%  [R_0201]  219.46 105.19 0 top
RG156  5.1K_0201_1%  [R_0201]  215.08 104.93 180 bottom
RG157  5.1K_0201_1%  [R_0201]  230.26 82.29 90 top
RG158  5.1K_0201_1%  [R_0201]  210.19 81.79 270 bottom
RG159  5.1K_0201_1%  [R_0201]  210.19 82.48 90 bottom
RG160  10K_0201_5%  [R_0201]  235.7 75.85 90 bottom
RG161  10K_0201_5%  [R_0201]  235.12 76.44 270 bottom
RG162  10K_0201_5%  [R_0201]  233.96 75.85 90 bottom
RG163  10K_0201_5%  [R_0201]  234.55 76.44 270 bottom
RG164  10K_0201_5%  [R_0201]  236.27 75.85 90 bottom
RG165  10K_0201_5%  [R_0201]  236.85 76.44 270 bottom
RG166  10K_0201_5%  [R_0201]  232.74 76.54 270 bottom
RG167  10K_0201_5%  [R_0201]  231.57 75.95 90 bottom
RG168  10K_0201_5%  [R_0201]  230.97 76.54 270 bottom
RG169  10K_0201_5%  [R_0201]  232.16 75.95 90 bottom
RG170  0_0402_5%  [R_0402]  208.97 114.57 90 bottom
RG171  0_0402_5%  [R_0402]  208.07 114.57 90 bottom
RG396  1K_0201_1%  [R_0201]  216.73 111.28 180 top
RG397  1K_0201_1%  [R_0201]  216.73 111.98 180 top
RG400  100K_0201_5%  [R_0201]  215.57 101.21 90 top
RG401  100K_0201_5%  [R_0201]  214.99 101.21 90 top
RG402  100K_0201_5%  [R_0201]  230.26 84.21 270 top
RG403  100K_0201_5%  [R_0201]  230.26 84.83 90 top
RG499  2.2K_0402_5%  [R_0402]  206.74 107.5 270 bottom
RG513  10K_0402_5%  [R_0402]  259.11 52.18 270 bottom
RG514  470_0402_5%  [R_0402]  258.62 47.24 180 bottom
RG515  10K_0402_5%  [R_0402]  261.06 51.64 0 bottom
RG516  470_0402_5%  [R_0402]  263 49.98 270 bottom
RG620  0_0402_5%  [R_0402]  252.57 112.4 0 top
RG621  0_0402_5%  [R_0402]  247.62 107.6 180 top
RH1  1K_0402_1%  [R_0402]  224.1 23.28 270 bottom
RH2  10K_0402_5%  [R_0402]  208.72 35.91 270 top
RH4  0_0402_5%  [R_0402]  217.5 33.49 0 top
RH5  1K_0402_5%  [R_0402]  214.01 44.03 270 bottom
RH6  0_0603_5%  [R_0603]  202.76 24.92 0 top
RH7  0_0603_5%  [R_0603]  212.35 31.97 90 top
RH9  100K_0402_5%  [R_0402]  219.66 39.77 270 bottom
RH12  0_0805_5%  [R_0805]  191.63 31.25 0 top
RH16  1K_0402_1%  [R_0402]  214.38 36.87 90 top
RH21  10K_0201_5%  [R_0201]  196.2 13.18 180 bottom
RH22  10K_0201_5%  [R_0201]  196.82 13.18 0 bottom
RH23  10K_0201_5%  [R_0201]  210.54 24.54 0 top
RH24  10K_0201_5%  [R_0201]  209.91 24.54 180 top
RH25  10K_0201_5%  [R_0201]  198.95 13.71 270 bottom
RH26  10K_0201_5%  [R_0201]  198.95 14.33 90 bottom
RH27  10K_0201_5%  [R_0201]  196.2 14.26 180 bottom
RH28  10K_0201_5%  [R_0201]  196.82 14.26 0 bottom
RH29  10K_0201_5%  [R_0201]  198.38 13.71 270 bottom
RH30  10K_0201_5%  [R_0201]  198.38 14.33 90 bottom
RH38  30_0402_5%  [R_0402]  211.02 45.32 270 bottom
RH39  30_0402_5%  [R_0402]  210.13 45.32 270 bottom
RH57  49.9_0402_1%  [R_0402]  128.95 108.59 0 bottom
RH58  49.9_0402_1%  [R_0402]  128.95 110.37 0 bottom
RH59  49.9_0402_1%  [R_0402]  129.87 109.48 180 bottom
RH70  10M_0402_5%  [R_0402]  219.66 36.15 270 bottom
RH71  2.7K_0402_1%  [R_0402]  198.27 40.16 180 top
RH72  1M_0402_5%~D  [R_0402]  193.37 42.61 0 bottom
RH73  12.1_0402_1%  [R_0402]  209.11 42.56 90 bottom
RH74  3.3K_0402_5%  [R_0402]  220.63 19.31 180 bottom
RH75  1K_0402_5%  [R_0402]  220.95 22.8 180 top
RH78  1K_0402_5%  [R_0402]  220.95 21.91 180 top
RH79  620_0402_5%  [R_0402]  208.16 42.56 90 bottom
RH83  20K_0402_5%~D  [R_0402]  216.05 34.02 270 top
RH84  20K_0402_5%~D  [R_0402]  216.24 35.76 90 top
RH85  8.2K_0402_5%  [R_0402]  220.02 27.91 0 top
RH88  10K_0402_5%  [R_0402]  212.87 36.79 270 top
RH89  22_0402_5%  [R_0402]  220.51 29.04 180 bottom
RH90  100K_0402_5%  [R_0402]  211.92 36.34 270 top
RH104  15_0402_1%  [R_0402]  223.62 19.58 180 bottom
RH109  113_0402_1%  [R_0402]  206.28 42.27 90 bottom
RH111  10K_0402_5%~D  [R_0402]  222.42 28.91 270 bottom
RH130  4.7K_0402_5%~D  [R_0402]  210.69 25.69 0 top
RH135  10K_0402_5%  [R_0402]  220.95 30.36 180 top
RH148  121_0402_1%  [R_0402]  172.79 89.92 180 bottom
RH149  75_0402_1%  [R_0402]  169.16 89.85 90 bottom
RH150  100_0402_1%  [R_0402]  168.27 89.85 90 bottom
RH151  100_0402_1%  [R_0402]  126.73 118.81 0 bottom
RH152  56.2_0402_1%  [R_0402]  126.73 120.91 0 bottom
RH153  220_0402_5%  [R_0402]  127.64 120.02 180 bottom
RH154  60.4_0402_1%  [R_0402]  174.26 100.73 90 top
RH155  20_0402_5%  [R_0402]  126.73 116.78 0 bottom
RH156  51_0402_5%  [R_0402]  128.95 114.88 0 bottom
RH158  499_0402_1%  [R_0402]  128.95 115.83 0 bottom
RH163  1K_0402_5%  [R_0402]  167.94 115.38 180 top
RH164  1K_0402_5%  [R_0402]  174.26 98.95 90 top
RH165  1K_0402_5%  [R_0402]  126.73 115.83 0 bottom
RH166  49.9_0402_1%  [R_0402]  126.73 114.88 0 bottom
RH167  30_0402_5%  [R_0402]  175.65 109.16 180 top
RH184  1K_0402_5%  [R_0402]  133.25 111.66 180 top
RH185  1K_0402_5%  [R_0402]  129.87 105.42 180 bottom
RH186  1K_0402_5%  [R_0402]  134.76 105.99 180 top
RH187  1K_0402_5%  [R_0402]  129.87 106.37 180 bottom
RH188  1K_0402_5%  [R_0402]  129.87 107.32 180 bottom
RH192  30_0402_5%  [R_0402]  175.65 110.11 180 top
RH193  100_0402_1%  [R_0402]  192.55 31.9 270 bottom
RH196  0_0402_5%  [R_0402]  216.23 24.91 90 top
RH197  100_0402_1%  [R_0402]  155.59 122.51 90 bottom
RH199  100K_0402_5%  [R_0402]  215.01 20.8 0 top
RH201  100_0402_1%  [R_0402]  174.51 124.76 270 bottom
RH203  100_0402_1%  [R_0402]  151.4 122.51 90 bottom
RH206  1K_0402_1%~D  [R_0402]  153.56 52.26 270 top
RH207  1K_0402_1%~D  [R_0402]  152.66 39.42 0 top
RH209  1K_0402_1%~D  [R_0402]  155.34 51.35 90 top
RH210  1K_0402_1%~D  [R_0402]  154.44 38.53 0 top
RH211  24.9_0402_1%  [R_0402]  154.45 54.48 270 top
RH212  24.9_0402_1%  [R_0402]  154.44 37.58 0 top
RH453  10K_0402_5%  [R_0402]  219.59 32.01 0 bottom
RH455  1K_0402_5%  [R_0402]  220.94 20.61 180 top
RH460  1K_0402_5%  [R_0402]  209.11 12.38 90 top
RH461  1K_0402_5%  [R_0402]  210 12.38 90 top
RH462  1K_0402_5%  [R_0402]  214.32 14.69 90 top
RH463  1K_0402_5%  [R_0402]  213.37 14.69 90 top
RH466  100_0402_1%  [R_0402]  153.73 123.4 270 bottom
RH469  100_0402_1%  [R_0402]  173.62 124.76 270 bottom
RH472  100_0402_1%  [R_0402]  152.84 123.4 270 bottom
RH484  2_0402_1%  [R_0402]  156.23 52.26 270 top
RH485  2_0402_1%  [R_0402]  152.66 38.53 0 top
RH489  1K_0402_5%  [R_0402]  217.63 43.11 90 bottom
RH493  2.2K_0402_5%  [R_0402]  216.74 43.11 90 bottom
RH494  51_0402_5%  [R_0402]  128.95 112.91 0 bottom
RH495  51_0402_5%  [R_0402]  128.02 113.84 270 bottom
RH496  51_0402_5%  [R_0402]  128.95 113.92 0 bottom
RH497  51_0402_5%  [R_0402]  128.33 158.34 0 top
RH501  499_0402_1%  [R_0402]  216.37 18.23 180 top
RH502  499_0402_1%  [R_0402]  216.37 19.69 180 top
RH506  1M_0402_5%  [R_0402]  220.04 29.36 0 top
RH512  10K_0402_5%  [R_0402]  204.87 15.21 180 top
RH515  8.2K_0402_5%  [R_0402]  219.59 32.96 0 bottom
RH516  10K_0402_5%  [R_0402]  205.49 20.92 45 top
RH517  8.2K_0402_5%  [R_0402]  215.16 14.57 180 bottom
RH518  10K_0402_5%~D  [R_0402]  208.44 32.38 90 top
RH519  0_0402_5%  [R_0402]  126.73 117.8 0 bottom
RH520  8.2K_0402_5%  [R_0402]  212.42 14.69 90 top
RH521  10K_0402_5%  [R_0402]  205.49 22.19 45 top
RH524  4.7K_0402_5%~D  [R_0402]  220.95 25.15 180 top
RH525  330K_0402_5%  [R_0402]  124.3 75.76 270 top
RH530  0_0402_5%  [R_0402]  160.75 101.1 90 top
RH531  1M_0402_5%  [R_0402]  216.84 34.9 180 top
RH533  8.2K_0402_5%  [R_0402]  221.37 30.5 90 bottom
RH537  10K_0201_5%  [R_0201]  207.78 15.06 270 bottom
RH545  10K_0402_5%  [R_0402]  219.59 33.92 0 bottom
RH558  10K_0201_5%  [R_0201]  215.23 30.31 90 top
RH571  8.2K_0402_5%  [R_0402]  215.79 44.03 270 bottom
RH580  1K_0402_5%  [R_0402]  206.64 36.21 90 top
RH581  1K_0402_5%  [R_0402]  207.16 42.24 90 bottom
RH584  10K_0402_5%  [R_0402]  200.04 14.35 270 bottom
RH585  10K_0402_5%  [R_0402]  200.93 13.43 90 bottom
RH588  10K_0402_5%  [R_0402]  223.2 24.15 0 bottom
RH589  10K_0402_5%  [R_0402]  223.2 25.04 0 bottom
RH656  0_0201_5%  [R_0201]  218.98 38.96 0 top
RH657  0_0201_5%  [R_0201]  218.98 38.32 0 top
RL1  4.7K_0402_5%~D  [R_0402]  233.68 158.71 270 bottom
RL2  30K_0402_5%  [R_0402]  234.57 158.71 270 bottom
RL3  2.37K_0402_1%~D  [R_0402]  240.03 156.84 90 bottom
RL4  5.1K_0402_1%~D  [R_0402]  234.26 156.34 180 top
RL5  10K_0402_5%  [R_0402]  227.26 147.15 270 bottom
RL8  330_0402_5%  [R_0402]  242.77 165.78 270 top
RL9  75_0402_1%~D  [R_0402]  251.01 153.32 0 top
RL10  75_0402_1%~D  [R_0402]  251.01 154.53 0 top
RL11  75_0402_1%~D  [R_0402]  251.01 160.88 0 top
RL12  75_0402_1%~D  [R_0402]  251.01 162.15 0 top
RL13  130_0402_1%~D  [R_0402]  258.52 164.89 270 top
RL14  1K_0402_1%~D  [R_0402]  259.42 163.1 180 top
RL15  130_0402_5%~D  [R_0402]  259.41 164.89 270 top
RM5  10K_0402_5%  [R_0402]  158.82 173.73 90 bottom
RM6  10K_0402_5%  [R_0402]  163.15 172.7 180 bottom
RM14  1K_0201_1%  [R_0201]  124.32 157.04 0 bottom
RM17  100K_0402_5%  [R_0402]  163.14 173.58 90 bottom
RM18  2.2_0402_1%  [R_0402]  173.31 158.53 180 bottom
RM20  1K_0402_1%  [R_0402]  169.35 151.44 90 bottom
RM21  1K_0402_1%  [R_0402]  171.26 151.44 90 bottom
RM23  1K_0201_1%  [R_0201]  138.92 160.12 180 bottom
RM25  475_0402_1%  [R_0402]  169.86 162.39 270 bottom
RM26  1K_0201_1%  [R_0201]  138.92 160.75 180 bottom
RM27  33_0402_1%  [R_0402]  167.52 162.27 270 bottom
RM28  33_0402_1%  [R_0402]  166.63 162.27 270 bottom
RM29  49.9_0402_1%  [R_0402]  164.14 161.7 0 bottom
RM31  100K_0402_5%  [R_0402]  309.55 41.59 270 top
RM38  49.9_0402_1%  [R_0402]  164.14 163.04 0 bottom
RM41  100K_0402_5%  [R_0402]  150.95 170.01 90 bottom
RM42  470K_0402_5%  [R_0402]  152.66 174.62 270 bottom
RM61  20K_0402_5%  [R_0402]  139.37 154.58 180 bottom
RM62  1K_0201_1%  [R_0201]  137.6 150.55 90 bottom
RM64  1K_0201_1%  [R_0201]  138.35 157.36 0 bottom
RM66  1K_0201_1%  [R_0201]  138.35 158.25 0 bottom
RM70  1K_0201_1%  [R_0201]  128.33 150.55 90 bottom
RM72  10K_0201_5%  [R_0201]  124.9 159.07 180 bottom
RM75  1K_0201_1%  [R_0201]  139.4 153.13 180 bottom
RM76  1K_0201_1%  [R_0201]  127.38 150.55 90 bottom
RM79  1K_0201_1%  [R_0201]  139.4 152.24 180 bottom
RM81  1K_0201_1%  [R_0201]  126.43 150.55 90 bottom
RM82  1K_0201_1%  [R_0201]  138.92 159.48 180 bottom
RM84  1K_0201_1%  [R_0201]  124.38 150.56 0 bottom
RM85  1K_0201_1%  [R_0201]  138.92 158.85 180 bottom
RM86  1K_0201_1%  [R_0201]  138.5 151.04 270 bottom
RM87  10K_0201_5%  [R_0201]  125.23 158.12 180 bottom
RM91  549_0402_1%  [R_0402]  148.52 163.6 180 bottom
RM92  100K_0402_5%~D  [R_0402]  148.51 164.71 180 bottom
RM93  100_0402_1%  [R_0402]  151.77 162.77 90 bottom
RM94  100K_0402_5%~D  [R_0402]  150.88 162.77 90 bottom
RM96  4.7K_0402_5%  [R_0402]  170.3 151.44 90 bottom
RN5  10K_0402_5%  [R_0402]  315.08 39.29 180 top
RN15  0_0201_5%  [R_0201]  313.42 39.3 180 top
RN16  10K_0402_5%  [R_0402]  315.12 38.13 0 top
RN17  0_0201_5%  [R_0201]  316.04 36.47 180 top
RP2  33_0804_8P4R_5%  [RP_0804_8P4R]  218.54 14.18 90 top
RP3  10K_0804_8P4R_5%  [RP_0804_8P4R]  221.13 27.95 180 bottom
RP5  10K_0804_8P4R_5%  [RP_0804_8P4R]  221.13 24.97 180 bottom
RPH5  15_0804_8P4R_5%  [RP_0804_8P4R]  221.13 21.98 180 bottom
RPH6  10K_8P4R_5%  [RP_0804_8P4R]  204.19 14.82 270 bottom
RPT1  2.2K_0804_8P4R_5%  [RP_0804_8P4R]  174 164.68 180 bottom
RS1  100K_0201_5%  [R_0201]  187.13 68.55 0 top
RS2  10K_0201_5%  [R_0201]  103.2 13.09 270 bottom
RS3  0_0201_5%  [R_0201]  102.6 13.11 180 bottom
RS8  0_0201_5%  [R0201_0OHM]  124.53 10.17 270 top
RT1  0_0201_5%  [R0201_0OHM]  176.06 165.39 0 bottom
RT2  0_0201_5%  [R_0201]  176.92 153.26 270 bottom
RT3  3.01K_0201_1%  [R_0201]  183.79 163.72 270 bottom
RT4  1M_0201_1%  [R_0201]  174.1 164.46 180 top
RT5  14K_0402_1%  [R_0402]  178.04 164.36 270 bottom
RT6  10K_0201_5%  [R_0201]  164.98 162.25 270 top
RT7  10K_0201_5%  [R_0201]  164.16 162.25 270 top
RT8  10K_0201_5%  [R_0201]  163.2 162.25 270 top
RT9  10K_0201_5%  [R_0201]  162.38 162.25 270 top
RT10  0_0201_5%  [R0201_0OHM]  172.36 160.91 90 top
RT11  1M_0201_1%  [R_0201]  172.95 159.26 180 top
RT12  0_0201_5%  [R_0201]  169.9 166.19 180 top
RT13  0_0201_5%  [R0201_0OHM]  169.31 162.18 0 top
RT14  0_0201_5%  [R_0201]  171.15 162.12 0 top
RT15  0_0201_5%  [R0201_0OHM]  171.75 166.02 180 bottom
RT16  0_0201_5%  [R_0201]  172.35 164.09 270 top
RT17  100_0201_5%  [R_0201]  171.74 165.49 180 top
RT18  100_0201_5%  [R_0201]  176.84 158.03 270 top
RT19  14K_0402_1%  [R_0402]  183.88 161.85 0 bottom
RT20  10K_0201_5%  [R_0201]  177.54 152.69 90 bottom
RT21  10K_0201_5%  [R_0201]  177.75 172.6 270 top
RT22  0_0201_5%  [R_0201]  201.56 158.67 270 bottom
RT23  0_0201_5%  [R_0201]  169.9 164.03 180 top
RT24  10K_0201_5%  [R_0201]  176.92 152.03 270 bottom
RT25  4.75K_0402_0.5%  [R_0402]  179.35 167.18 270 bottom
RT26  3.3K_0201_5%  [R_0201]  173.51 162.69 0 top
RT27  3.3K_0201_5%  [R_0201]  173.51 163.26 0 top
RT28  10K_0201_5%  [R_0201]  172.93 161.5 270 top
RT29  10K_0201_5%  [R_0201]  173.5 161.5 270 top
RT30  10K_0201_5%  [R_0201]  171.15 166.19 0 top
RT31  10K_0201_5%  [R_0201]  171.74 162.69 180 top
RT32  10K_0201_5%  [R_0201]  169.9 164.72 180 top
RT33  10K_0201_5%  [R_0201]  171.15 164.73 0 top
RT34  100K_0201_5%  [R_0201]  173.52 162.11 180 top
RT35  100K_0201_5%  [R_0201]  169.31 162.76 0 top
RT36  100K_0201_5%  [R_0201]  171.74 164.09 180 top
RT37  100K_0201_5%  [R_0201]  169.31 165.49 0 top
RT38  100K_0201_5%  [R_0201]  172.95 158.63 180 top
RT39  100K_0201_5%  [R_0201]  178.72 160.28 180 bottom
RT40  1M_0201_1%  [R_0201]  178.32 172.02 90 top
RT41  100K_0201_5%  [R_0201]  169.31 163.33 0 top
RT42  1M_0201_1%  [R_0201]  178.28 172.24 0 bottom
RT43  499_0201_1%  [R_0201]  185.39 166.4 0 bottom
RT44  499_0201_1%  [R_0201]  185.3 167.77 270 bottom
RT45  100K_0201_5%  [R_0201]  178.28 171.61 0 bottom
RT46  100K_0201_5%  [R_0201]  178.95 172.02 90 top
RT47  100K_0201_5%  [R_0201]  174.1 163.89 180 top
RT48  3.3K_0402_5%  [R_0402]  190 162.99 270 bottom
RT49  3.3K_0402_5%  [R_0402]  188.48 162.07 90 bottom
RT50  3.3K_0402_5%  [R_0402]  187.52 162.99 270 bottom
RT51  3.3K_0402_5%  [R_0402]  188.67 156.51 270 bottom
RT53  0_0402_5%  [R0402_0OHM]  194.69 164.56 0 top
RT57  10K_0201_5%  [R_0201]  205.49 155.01 270 bottom
RT58  10K_0201_5%  [R_0201]  204.86 155.01 270 bottom
RT59  0_0201_5%  [R_0201]  204.86 152.14 90 bottom
RT60  0_0201_5%  [R_0201]  205.49 152.14 90 bottom
RT61  0_0201_5%  [R_0201]  197.11 167.47 90 top
RT62  100K_0201_5%  [R_0201]  198.26 161.91 270 top
RT63  100K_0201_5%  [R_0201]  205.42 162.4 0 bottom
RT64  10K_0201_5%  [R_0201]  203.84 167.15 90 bottom
RT65  10K_0201_5%  [R_0201]  205.15 167.15 90 bottom
RT66  10K_0201_5%  [R_0201]  199.14 159.47 90 top
RT67  10K_0201_5%  [R_0201]  200.03 159.47 90 top
RT68  100K_0201_5%  [R_0201]  199.72 167.44 90 bottom
RT69  100K_0201_5%  [R_0201]  199.08 167.44 90 bottom
RT70  100K_0201_5%  [R_0201]  197.11 168.03 270 bottom
RT71  100K_0201_5%  [R_0201]  198.45 167.44 90 bottom
RT72  100K_0201_5%  [R_0201]  197.81 167.44 90 bottom
RT73  100K_0201_5%  [R_0201]  196.22 167.47 90 bottom
RT74  0_0201_5%  [R0201_0OHM]  208.2 163.23 180 bottom
RT75  15K_0402_1%  [R_0402]  195.6 163.67 180 bottom
RT76  100K_0201_5%  [R_0201]  178.19 153.26 270 bottom
RT77  100K_0201_5%  [R_0201]  182.57 153.26 270 bottom
RT78  100K_0201_5%  [R_0201]  179.97 153.26 270 bottom
RT79  100K_0201_5%  [R_0201]  180.79 153.26 270 bottom
RT80  100K_0201_5%  [R_0201]  176.74 167.7 270 bottom
RT83  0_0201_5%  [R_0201]  198.01 163.29 180 top
RT86  10K_0201_5%  [R_0201]  177.36 169.48 90 bottom
RT94  10K_0201_5%  [R_0201]  169.91 163.16 180 bottom
RT95  0_0805_5%  [R_0805]  174.63 174.36 270 bottom
RT97  0_0402_5%  [R0402_0OHM]  174.7 169.69 90 bottom
RT98  0_0201_5%  [R0201_0OHM]  197.01 157 0 bottom
RT99  0_0201_5%  [R0201_0OHM]  195.94 156.05 180 bottom
RT100  0_0201_5%  [R0201_0OHM]  187.52 160.98 270 bottom
RT101  0_0201_5%  [R0201_0OHM]  195.68 157 0 bottom
RT102  0_0201_5%  [R_0201]  205.42 163.29 0 bottom
RT107  10K_0201_5%  [R_0201]  205.47 155.67 180 bottom
RT108  0_0402_5%  [R_0402]  198.48 168.47 0 top
RT109  0_0402_5%  [R_0402]  199.4 167.58 180 top
RU1  10K_0402_5%  [R_0402]  24.32 41.66 180 top
RU2  19.1K_0402_1%  [R_0402]  19.41 45.29 270 top
RU3  19.1K_0402_1%  [R_0402]  19.41 42.6 90 top
RU4  100K_0402_5%  [R_0402]  32.83 45.27 90 top
RU5  220K_0402_5%  [R_0402]  32.83 44.41 270 top
RU6  1M_0402_5%  [R_0402]  27.86 46.23 0 top
RU7  10K_0402_5%  [R_0402]  26.16 45.66 180 top
RU12  0_0805_5%  [R_0805]  23.59 48.74 180 bottom
RU14  100K_0402_1%  [R_0402]  16.6 48.11 90 bottom
RU15  100K_0402_5%  [R_0402]  20.07 53.19 270 top
RU16  100K_0402_5%  [R_0402]  19.19 54.65 270 top
RU17  100K_0402_5%  [R_0402]  14.61 54.15 270 top
RU18  100K_0402_5%  [R_0402]  15.5 54.15 270 top
RU19  100K_0402_5%  [R_0402]  16.46 54.65 270 top
RU20  100K_0402_5%  [R_0402]  17.4 54.52 0 top
RU21  10K_0402_5%  [R_0402]  18.63 48.11 90 bottom
RU23  100K_0402_1%  [R_0402]  17.74 48.11 90 bottom
RU24  10K_0201_1%  [R_0201]  306.97 59.14 0 top
RU25  20K_0201_1%  [R_0201]  307.55 58.55 180 top
RU26  10K_0201_1%  [R_0201]  304.63 54.74 0 top
RV1  10K_0201_5%  [R_0201]  167.52 160.03 270 top
RV8  100K_0201_5%  [R_0201]  169.97 160.5 180 top
RV9  100K_0402_5%  [R_0402]  159.75 166.53 0 bottom
RV10  1K_0201_1%  [R_0201]  161.65 182.1 0 top
RV12  100K_0402_5%  [R_0402]  160.16 164.56 180 bottom
RV13  0_0402_5%  [R_0402]  164.21 163.74 0 top
RV15  100K_0201_5%  [R_0201]  232.72 159.9 90 bottom
RV16  100K_0201_5%  [R_0201]  232.72 161.93 270 bottom
RV17  1M_0201_1%  [R_0201]  231.85 155.96 180 bottom
RV18  5.1M_0402_5%  [R_0402]  233.22 166.68 90 bottom
RV19  100K_0402_5%  [R_0402]  190.75 123.53 270 bottom
RV20  100K_0402_5%  [R_0402]  191.7 122.61 90 bottom
RV21  4.7K_0402_1%  [R_0402]  187.19 109.49 270 bottom
RV22  4.7K_0402_1%  [R_0402]  187.19 107.21 270 bottom
RV23  1M_0402_5%  [R_0402]  192.41 112.21 180 bottom
RV24  4.99K_0402_1%  [R_0402]  191.91 110.41 270 top
RV25  10K_0402_5%  [R_0402]  191.51 110.42 90 bottom
RV26  499_0402_1%  [R_0402]  192.41 109.54 180 bottom
RV45  10K_0402_5%  [R_0402]  166.76 166.33 90 bottom
RV47  0_0402_5%  [R0402_0OHM]  160.03 163.35 90 top
RV81  0_0402_5%  [R0402_0OHM]  167.65 170 0 bottom
RV193  4.99K_0402_1%  [R_0402]  214.96 150.67 90 bottom
RV197  4.7K_0402_5%  [R_0402]  218.91 161.16 90 bottom
RV198  4.7K_0402_5%  [R_0402]  216.71 162.07 270 bottom
RV199  4.7K_0402_5%  [R_0402]  217.62 161.16 90 bottom
RV200  10K_0402_5%  [R_0402]  215.83 151.58 270 bottom
RV202  4.7K_0402_5%  [R_0402]  219.01 150.67 90 bottom
RV203  4.7K_0402_5%  [R_0402]  215.35 161.16 90 bottom
RV204  4.7K_0402_5%  [R_0402]  218.12 150.67 90 bottom
RV260  0_0402_5%  [R_0402]  210.89 105.14 270 bottom
RV500  150_0402_1%  [R_0402]  215.06 167.66 0 bottom
RV501  150_0402_1%  [R_0402]  210.3 167.66 0 bottom
RV502  150_0402_1%  [R_0402]  212.71 167.72 0 bottom
RV503  150_0402_1%  [R_0402]  217.27 167.7 0 bottom
RV533  0_0402_5%  [R_0402]  209.62 110.19 90 bottom
RV534  69.8K_0402_1%  [R_0402]  213.62 106.13 90 bottom
RV535  3.48K_0402_1%  [R_0402]  211.78 104.22 90 bottom
RV536  10K_0402_5%  [R_0402]  213.62 108.82 270 bottom
RV537  11.5K_0402_1%  [R_0402]  211.07 106.14 0 bottom
RV600  100K_0201_5%  [R_0201]  167.46 164.75 180 bottom
RV618  0_0402_5%  [R_0402]  226.82 156.05 180 bottom
RV619  0_0402_5%  [R_0402]  226.82 155.16 180 bottom
RV622  4.7K_0402_1%  [R_0402]  185.1 107.21 270 bottom
RV623  4.7K_0402_1%  [R_0402]  185.1 109.49 270 bottom
RV624  4.7K_0402_1%  [R_0402]  193.68 109.49 90 top
RV625  4.7K_0402_1%  [R_0402]  192.79 109.49 90 top
RV626  4.7K_0402_1%  [R_0402]  185.99 107.21 270 bottom
RV627  4.7K_0402_1%  [R_0402]  185.99 109.49 270 bottom
RV628  4.7K_0402_1%  [R_0402]  188.08 107.21 270 bottom
RV629  4.7K_0402_1%  [R_0402]  188.08 109.49 270 bottom
RV630  4.7K_0402_1%  [R_0402]  185.39 104.46 90 bottom
RV631  4.7K_0402_1%  [R_0402]  184.5 104.46 90 bottom
RV632  0_0402_5%  [R_0402]  190.05 108.58 90 bottom
RV633  0_0402_5%  [R_0402]  189.1 108.58 90 bottom
RV634  4.7K_0402_1%  [R_0402]  184.18 106.31 180 bottom
RV635  4.7K_0402_1%  [R_0402]  184.15 108.58 90 bottom
RV638  5.6_0402_1%  [R_0402]  218.18 165.61 90 bottom
RV639  5.6_0402_1%  [R_0402]  213.69 165.64 90 bottom
RV640  5.6_0402_1%  [R_0402]  215.97 165.58 90 bottom
RV641  5.6_0402_1%  [R_0402]  215.08 165.58 90 bottom
RV642  5.6_0402_1%  [R_0402]  212.67 165.64 90 bottom
RV643  5.6_0402_1%  [R_0402]  210.32 165.58 90 bottom
RV645  5.6_0402_1%  [R_0402]  217.29 165.61 90 bottom
RV646  5.6_0402_1%  [R_0402]  211.21 165.58 90 bottom
RV655  10K_0402_5%  [R_0402]  219.24 167.08 0 bottom
RV658  10K_0402_5%  [R_0402]  193.05 107.47 90 bottom
RV659  10K_0402_5%  [R_0402]  188.48 88.74 270 bottom
RV669  100K_0201_1%  [R_0201]  187.96 124.58 90 bottom
RV670  100K_0201_1%  [R_0201]  186.95 124.58 90 bottom
RV1307  4.99K_0402_1%  [R_0402]  218.64 148.43 180 bottom
RV1309  10K_0402_1%  [R_0402]  217.72 147.52 0 bottom
RX2  150K_0402_5%  [R_0402]  231.25 166.68 90 bottom
RX4  100K_0402_5%  [R_0402]  222.88 161.88 270 top
RX5  10K_0402_5%  [R_0402]  229.69 158.9 90 top
RX6  150K_0402_5%  [R_0402]  212.68 161.96 270 bottom
RX7  10K_0402_5%  [R_0402]  228.23 158.9 90 top
RX8  100K_0402_5%  [R_0402]  209.7 155.24 270 bottom
SW1  TST71A-N-220-S017 SPST H0.6 2P  [SW_TST71-N-220-T170-S017_2P]  315.1 5.49 180 top
T1  PAD~D  [TPC12]  175 117.23 180 bottom
T2  PAD~D  [TPC12]  174.51 161.77 90 top
T7  PAD~D  [TPC12]  174.82 160.24 45 top
T9  PAD~D  [TPC12]  173.24 160.12 45 top
T41  PAD~D  [TPC12]  170.49 94.87 0 top
T43  PAD~D  [TPC12]  133.68 94.27 0 top
