# Allegro board LAD752PR10-0816.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
+1.5VS_B+ on TOP (solid shape): 271.66,170.02 271.66,168.94 272.11,168.5 272.11,167.55 272.08,167.54 272.03,167.53 271.99,167.5 271.95,167.47 271.91,167.43 271.88,167.39 271.86,167.35 271.84,167.3 271.83,167.25 271.83,167.19 271.83,167.14 271.84,167.09 271.85,167.07 271.85,165.92 271.91,165.86 272.76,165.86 273.59,165.03 275.24,165.03 275.24,165.03 275.58,165.03 275.79,164.81 275.79,164.31 275.6,164.12 274.61,164.12 274.33,163.84 274.33,163.19 273.81,163.19 273.81,162.75 274.22,162.75 274.22,162.75 274.22,161.03 273.47,160.28 272.17,158.97 272.17,157.89 271.92,157.64 271.41,157.64 271.41,157.64 270.94,157.64 270.89,157.6 270.89,156.99 270.85,156.94 269.82,156.94 269.76,157 269.76,161.07 269.28,161.54 269.28,165.26 268.62,165.92 268.62,166.33 269.88,166.33 269.88,165.52 270.02,165.39 270.53,165.39 270.71,165.21 270.71,164.89 271.04,164.56 271.4,164.56 271.6,164.76 271.6,166.01 271.08,166.53 270.09,166.53 269.88,166.33 268.62,166.33 268.62,170.1 268.69,170.17 271.52,170.17
+1.5VS_B+ on BOTTOM (solid shape): 273.55,165.04 275.69,165.04 275.85,164.88 275.85,164.24 275.57,163.96 274.64,163.96 274.27,163.59 272.46,163.59 271.82,164.24 271.82,165.12 271.91,165.21 273.38,165.21
+1.8VGS on TOP (solid shape): 233.45,88.82 233.45,88.56 233.39,88.44 233.37,88.3 233.37,88.16 233.39,88.03 233.45,87.92 233.45,87.57 233.41,87.53 233.35,87.54 232.85,87.32 233.01,86.8 233.05,86.73 233.03,86.66 232.92,86.55 232.37,86.55 232.23,86.7 232.04,86.76 232.02,86.76 231.52,87.25 230.73,87.25 230.58,87.4 230.11,87.4 230.05,87.47 230.05,88.81 230.17,88.93 231.07,88.93 231.24,88.75 231.61,88.75 231.62,88.71 231.77,88.43 232.09,88.35 232.13,88.35 232.28,88.38 232.41,88.47 232.7,88.75 232.88,88.75 232.88,88.83 232.96,88.91 233.03,89 233.27,89
+1.8VGS on BOTTOM (solid shape): 214.7,80.14 214.7,78.78 214.7,78.78 214.7,77.37 214.58,77.25 212.9,77.25 212.79,77.36 212.79,77.74 213.32,77.74 213.32,78.24 212.79,78.24 212.79,78.54 213.32,78.54 213.32,79.04 212.79,79.04 212.79,80.16 212.94,80.32 214.53,80.32
+1.8VGS on IN2 (solid shape): outline of 295 points within 213.24,78.46 221.6,81.59
+1.8VGS on IN4 (solid shape): outline of 1202 points within 218.87,77.95 235.28,89.25
+1.8VGSP on BOTTOM (solid shape): 212.1,80.74 212.66,80.18 212.66,78.92 213.19,78.92 213.19,78.67 212.66,78.67 212.66,78.12 213.19,78.12 213.19,77.87 212.66,77.87 212.66,77.27 212.93,76.99 214.45,76.99 214.63,76.81 214.63,75.62 214.57,75.56 211.18,75.56 211.02,75.72 211.02,76.34 210.93,76.43 210.1,76.43 209.69,76.01 207.99,76.01 207.86,76.14 207.86,76.86 208.02,77.03 209.75,77.03 210,77.28 210,77.95 209.81,78.14 209.81,80.55 210,80.74 210.34,80.74
+1.8VGSP_VIN on BOTTOM (solid shape): 204.63,76.68 204.63,76.1 204.54,76 202.78,76 202.42,75.64 202.42,74.91 202.37,74.85 202.26,74.55 202.42,74.27 202.42,73.73 203.07,73.08 203.3,73.08 203.62,72.77 203.62,71.11 203.52,71.02 203.12,71.02 203.12,71.57 202.57,71.57 202.57,71.03 202.32,71.03 202.32,71.57 201.77,71.57 201.77,71.03 201.01,71.03 200.81,71.22 200.81,74.75 200.27,75.3 200.27,76.4 200.3,76.44 201.48,76.44 201.54,76.5 202.52,76.5 202.8,76.77 204.54,76.77
+1.8VS on TOP (solid shape): 36.33,15.72 37.16,15.72 37.22,15.65 37.22,15.16 37.14,15.08 36.71,15.08 36.15,14.52 36.15,14.26 35.96,14.07 35.96,12.99 35.89,12.93 35.79,12.93 35.74,12.98 35.74,14.03 35.64,14.13 35.64,14.51 35.52,14.63 35.19,14.63 35.19,14.63 35.15,14.6 35.14,14.6 35.01,14.51 34.92,14.38 34.92,14.37 34.88,14.33 34.88,14.13 34.69,13.94 34.53,13.94 34.34,13.75 34.34,12.96 34.3,12.93 34.19,12.93 34.14,12.98 34.14,13.85 34.37,14.08 34.37,14.4 34.48,14.52 34.49,14.52 34.8,14.83 34.81,14.83 34.81,15.67 34.86,15.72 36.32,15.72
+1.8VS on BOTTOM (solid shape): 226.36,39.02 226.36,38.34 225.83,38.34 225.83,37.83 226.36,37.83 226.36,37.54 225.83,37.54 225.83,37.03 226.36,37.03 226.36,36.58 226.2,36.42 225.37,36.42 225.16,36.63 225.16,38.9 225.36,39.1 226.28,39.1
+1.8VS on BOTTOM (solid shape): 34.93,22.17 34.93,21.06 34.43,20.57 33.83,20.57 33.55,20.29 32.52,20.29 31.44,21.37 31.44,22.12 31.46,22.14 31.89,22.14 31.91,22.12 31.91,21.74 32.4,21.25 34.08,21.25 34.35,21.52 34.35,22.14 34.4,22.19 34.91,22.19
+1.8VSP on BOTTOM (solid shape): 231.34,39.34 231.34,38.51 231.21,38.39 229.69,38.39 228.99,37.69 228.99,36.1 228.8,35.91 227.91,35.91 227.66,35.66 227.66,34.7 227.59,34.64 226.69,34.64 226.49,34.84 226.49,37.16 225.96,37.16 225.96,37.16 225.96,37.41 226.49,37.41 226.49,37.96 225.96,37.96 225.96,38.21 226.49,38.21 226.49,38.8 226.7,39.02 227.37,39.02 227.72,38.74 228.07,39.02 228.74,39.02 229.18,39.47 231.21,39.47
+1V_MPHY on TOP (solid shape): outline of 2653 points within 191.94,16.67 203.85,31.88
+1V_MPHY on BOTTOM (solid shape): 195.26,19.05 195.42,18.89 195.42,18.74 195.33,18.65 195.2,18.65 195,18.44 194.6,18.44 194.33,18.17 194.33,16.63 194.73,16.23 195.23,16.23 195.38,16.38 195.38,17.89 195.53,18.04 195.53,18.27 195.66,18.4 195.76,18.4 195.84,18.39 196,18.23 196,18.03 195.98,18.02 195.85,17.82 195.92,17.6 195.92,16.11 195.69,15.88 192.83,15.88 192.55,16.16 192.55,17.74 192.79,17.99 193.18,17.99 194.2,19.01 194.52,19.01 194.76,18.87 195,19.03 195.01,19.05
+1V_PCH on TOP (solid shape): outline of 1245 points within 193.91,29.07 203.18,41.75
+1V_PCH on IN2 (solid shape): outline of 1312 points within 200.03,27.91 211.53,33.43
+1V_PCH on IN3 (solid shape): outline of 1694 points within 203.29,27.92 211.07,42.63
+1V_PCH_PRIM on TOP (solid shape): outline of 2202 points within 199.73,26.18 208.55,42.33
+1VALW on TOP (solid shape): 182.89,80.52 182.89,79.13 182.76,79 181.59,79 181.43,78.84 181.43,77.88 181.75,77.57 181.99,77.57 181.99,77.56 182.64,77.56 182.74,77.46 182.74,76.79 183.02,76.52 183.02,76.42 183.14,76.29 183.14,76.09 182.97,75.91 182.13,75.91 181.54,75.32 181.54,74.66 180.92,74.05 176.72,74.05 176.27,74.49 176.27,77.69 177.2,77.69 177.2,76.14 177.26,76.08 177.27,76.08 178.55,76.08 178.77,76.3 178.77,76.99 179.26,77.48 179.26,78.94 179.13,79.06 178.05,79.06 177.8,78.81 177.8,78.29 177.2,77.69 176.27,77.69 176.27,80.33 176.65,80.71 182.7,80.71
+1VALW on TOP (solid shape): outline of 809 points within 186.64,30.49 205.6,47.7
+1VALW on BOTTOM (solid shape): 249.94,40.29 249.94,36.93 249.55,36.53 248.42,36.53 248.42,37.06 247.72,37.06 247.72,36.53 247.22,36.53 247.22,37.06 246.52,37.06 246.52,36.53 243.12,36.53 243.12,37.05 242.42,37.05 242.42,36.53 241.92,36.53 241.92,37.05 241.22,37.05 241.22,36.53 240.61,36.53 240.55,36.6 240.55,38.13 240.86,38.45 241.5,38.45 241.82,38.77 241.82,40.42 242.32,40.92 249.31,40.92
+1VALW on VCC: 191.12,27.72 186.61,32.23 184.39,32.23 179.52,37.1 179.52,37.49 179.57,84.59 187.57,84.59 190.37,81.79 190.37,45.28 192.12,43.53 244.44,43.53 244.44,43.53 245.65,43.53 249.31,39.87 249.31,38.63 248.31,37.62 247.36,37.62 237.46,27.72
+1VALWP on BOTTOM (solid shape): 247.1,36.4 247.85,36.4 247.85,36.94 248.3,36.94 248.3,36.4 249.01,36.4 252.88,36.4 253.96,35.32 253.96,31.58 253.46,31.08 239.85,31.08 238.96,31.97 238.96,35.08 240.23,36.35 240.28,36.4 241.32,36.4 241.35,36.4 241.35,36.92 241.8,36.92 241.8,36.4 241.81,36.39 242.53,36.39 242.55,36.4 242.55,36.92 243,36.92 243,36.4 243.01,36.39 246.63,36.39 246.65,36.4 246.65,36.94 247.1,36.94
+1VALWP_B+ on TOP (solid shape): 258.9,27.08 258.9,25.69 258.39,25.69 258.39,25.18 258.9,25.18 258.9,23.32 258.47,22.89 256.12,22.89 256.03,22.98 256.03,25.44 255.41,26.07 254.83,26.07 254.71,26.19 254.71,28.73 254.9,28.92 257.06,28.92
+1VALWP_B+ on BOTTOM (solid shape): 259.6,28.16 259.6,26.51 259.47,26.38 256.29,26.38 255.91,26.77 255.91,27.46 255.09,28.29 255.09,28.73 255.28,28.92 258.83,28.92
+1VALWP_PGOOD on TOP (solid shape): 308.08,19.9 308.08,19.72 308,19.64 305.91,19.64 305.62,19.35 305.62,18.7 305.44,18.52 305.18,18.52 305.05,18.65 305.05,19.55 305.36,19.86 305.53,19.87 305.68,19.96 308.02,19.96
+2.5V_MEM on TOP (solid shape): 179.61,63.29 179.61,58.2 179.37,57.96 178.02,57.96 177.89,58.09 177.89,63.36 178.08,63.55 179.35,63.55
+2.5V_MEM on TOP (solid shape): 180.92,49.63 180.92,46.07 180.73,45.88 180.29,45.88 179.84,46.32 179.21,46.32 178.82,46.7 178.82,47.02 179.65,47.85 179.65,49.82 179.84,50.01 180.54,50.01
+2.5V_MEM on BOTTOM (solid shape): 179.96,60.61 179.96,58 179.73,57.77 177.76,57.77 177.53,58.01 177.53,60.85 177.63,60.95 179.62,60.95
+2.5V_MEM on BOTTOM (solid shape): 180.41,46.94 179.79,46.32 177.66,46.32 177.53,46.45 177.53,48.61 177.76,48.84 179.14,48.84 179.42,49.12 180.41,49.12
+2.5V_MEM on BOTTOM (solid shape): 110.44,45.69 110.44,44.55 109.93,44.04 109.17,44.04 104.66,39.53 103.16,39.53 103.13,39.56 103.13,39.95 103.66,39.95 103.66,40.46 103.13,40.46 103.13,40.75 103.66,40.75 103.66,41.26 103.13,41.26 103.13,42.44 106.82,46.13 109.99,46.13
+2.5V_MEM on IN4 (solid shape): 111.2,47.28 111.2,46.32 110.56,45.69 110.56,44.99 110.05,44.48 109.23,44.48 108.97,44.74 108.97,46.83 109.55,47.4 111.07,47.4
+2.5V_MEM on IN4 (solid shape): 180.22,49.18 180.22,47.38 179.49,46.64 178.95,46.64 178.7,46.9 178.7,47.47 179.21,47.97 179.21,49.18 179.27,49.24 180.16,49.24
+2.5V_MEMP on BOTTOM (solid shape): 101.93,44.48 101.93,42.83 102.24,42.51 102.69,42.51 103,42.2 103,41.13 103.53,41.13 103.53,40.88 103,40.88 103,40.33 103.53,40.33 103.53,40.08 103,40.08 103,39.51 103,39.51 103,38.76 102.28,38.04 101.25,38.04 101.23,38.02 100.56,38.02 100.55,38.04 100.55,41.52 100.77,41.75 100.78,41.75 100.78,42.39 101.16,42.77 101.16,44.61 101.35,44.8 101.61,44.8
+2.5VOUT on TOP (solid shape): outline of 626 points within 129.83,150.83 138.84,161.25
+2.5VSP_VIN on BOTTOM (solid shape): 100.94,54.06 101.5,54.06 101.5,54.62 101.75,54.62 101.75,54.07 102.3,54.07 102.3,54.62 102.91,54.62 103.2,54.32 103.2,53.37 102.37,52.55 102.37,50.32 101.99,49.94 101.99,48.17 101.8,47.97 101.35,47.97 101.16,48.17 101.16,50.14 101.18,50.16 101.22,50.2 101.24,50.25 101.26,50.31 101.27,50.36 101.27,50.42 101.26,50.47 101.24,50.52 101.22,50.57 101.18,50.62 101.16,50.64 101.16,52.42 100.62,52.97 101.61,52.97 101.61,52.91 101.62,52.86 101.64,52.81 101.67,52.76 101.7,52.72 101.74,52.69 101.79,52.66 101.83,52.63 101.89,52.62 101.94,52.61 101.99,52.61 102.04,52.62 102.09,52.63 102.14,52.66 102.19,52.69 102.23,52.72 102.26,52.76 102.29,52.81 102.31,52.86 102.32,52.91 102.32,52.97 102.32,53.02 102.31,53.07 102.29,53.12 102.26,53.17 102.23,53.21 102.19,53.24 102.14,53.27 102.09,53.3 102.04,53.31 101.99,53.32 101.94,53.32 101.89,53.31 101.83,53.3 101.79,53.27 101.74,53.24 101.7,53.21 101.67,53.17 101.64,53.12 101.62,53.07 101.61,53.02 101.61,52.97 100.62,52.97 100.4,53.18 100.4,54.45 100.57,54.62 100.94,54.62
+3.3V_1.8V_DVDD on TOP (solid shape): 38.61,31.79 38.84,31.62 39.13,31.68 39.14,31.69 39.24,31.69 39.24,31.69 39.28,31.69 39.29,31.68 39.47,31.61 39.66,31.65 39.7,31.67 39.8,31.67 40.18,31.29 40.97,31.29 41.22,31.04 41.22,29.6 41.18,29.56 40.3,29.56 40.23,29.5 40.23,29.38 39.98,29.13 39.89,29.15 39.8,29.14 39.77,29.14 39.68,29.23 39.68,29.68 39.71,29.69 39.91,30 39.74,30.32 39.74,30.42 39.73,30.87 39.3,30.71 39.29,30.67 39.29,30.57 39.18,30.46 38.95,30.46 38.81,30.6 38.81,30.94 38.71,31.04 38.14,31.04 38.07,31.11 38.07,31.74 38.13,31.79
+3.3V_1.8V_DVDD_IO on BOTTOM (solid shape): 33.34,27.36 33.34,26.5 33.57,26.27 33.57,25.9 34.12,25.36 34.12,21.47 34.1,21.45 33.34,21.45 33.21,21.57 33.21,26.28 33.1,26.4 33.1,27.37 33.14,27.41 33.29,27.41
+3.3V_F383 on TOP (solid shape): 191.45,74.71 191.45,74.57 192.63,73.38 192.63,71.91 192.53,71.81 191.71,71.81 191.63,71.89 191.63,72.86 190.41,74.07 190.41,74.62 190.61,74.82 191.34,74.82
+3.3V_F383 on TOP (solid shape): 318.85,9.99 318.85,8.41 319.92,7.34 319.92,6.91 319.78,6.76 316.61,6.76 316.48,6.89 316.48,7.27 317.14,7.93 317.14,8.02 317.53,8.41 317.53,9.93 317.72,10.12 318.72,10.12
+3.3V_F383 on TOP (solid shape): 103.52,19.21 105.16,19.21 105.67,18.7 105.67,17.81 104.94,17.08 102.33,17.08 99.05,13.8 99.05,11.64 98.11,10.7 97.14,10.7 96.99,10.85 96.99,16.29 98.08,17.38 100.18,17.38 100.69,17.9 100.69,18.66 99.89,19.46 98.24,19.46 98.12,19.59 98.12,20.28 98.82,20.99 101.74,20.99
+3.3V_F383 on TOP (solid shape): 221.48,152.12 221.48,150.85 221.31,150.67 220,150.67 219.72,150.39 219.1,150.39 218.84,150.64 218.84,151.33 219.61,152.1 219.98,151.94 220.26,152.23 221.37,152.23
+3.3V_F383 on TOP (solid shape): 186.4,26.81 188.31,26.81 188.55,26.67 188.82,26.75 188.89,26.77 188.95,26.75 189.19,26.66 189.42,26.76 189.46,26.79 189.69,26.55 190.23,26.55 190.97,25.81 190.97,25.38 190.98,25.38 190.98,25.25 191.19,25.04 191.31,25.04 191.38,24.97 191.38,24.52 191.25,24.39 189.41,24.39 189.16,24.64 189.16,25.34 189.14,25.36 188.66,25.84 188.43,25.84 188.39,25.87 188.22,25.87 188.15,25.86 188.06,25.84 187.84,25.84 187.7,25.98 186.71,25.98 186.16,25.42 186.16,24.94 185.87,24.65 185.17,24.65 185.1,24.71 185.1,26.85 185.24,27 186.21,27
+3.3V_F383 on BOTTOM (solid shape): 105.61,18.64 105.61,17.24 105.42,17.05 104.28,17.05 104.21,17.11 104.21,18.64 104.34,18.76 105.48,18.76
+3.3V_F383 on BOTTOM (solid shape): 303.51,11.52 303.51,10.31 303.36,10.16 302.78,10.16 301.82,11.12 301.82,11.68 301.93,11.79 303.24,11.79
+3.3V_F383 on BOTTOM (solid shape): 102.12,21.63 102.12,21.5 102.32,21.29 102.32,19.76 102.19,19.63 100.6,19.63 100.42,19.81 100.42,20.4 100.97,20.95 100.97,21.6 101.17,21.8 101.94,21.8
+3.3V_F383 on BOTTOM (solid shape): 97.43,12.28 97.43,11.98 97.44,11.97 97.44,11.71 97.78,11.38 98.65,11.38 98.85,11.17 98.85,10.48 98.5,10.13 97.18,10.13 97.03,10.28 97.03,11.23 96.78,11.48 96.78,12.26 96.83,12.31 97.4,12.31
+3.3V_F383 on BOTTOM (solid shape): outline of 280 points within 314.74,7.32 318.92,30.18
+3.3V_F383 on IN1 (solid shape): outline of 105 points within 301.76,7.06 318.76,11.75
+3.3V_F383 on IN2 (solid shape): 106.56,18.74 106.56,17.94 106.48,17.86 104.29,17.86 104.15,18 104.15,18.62 104.34,18.81 106.49,18.81
+3.3V_F383 on IN2 (solid shape): outline of 184 points within 285.14,29.48 322.81,42.04
+3.3V_F383 on IN3 (solid shape): 286.85,42.02 286.85,40.63 288.24,39.25 288.24,38.67 288.02,38.45 286.25,38.45 285.25,39.45 285.25,42.03 285.43,42.21 286.66,42.21
+3.3V_F383 on IN3 (solid shape): 215.07,64.1 215.07,63.49 215.02,63.44 215.02,62.92 214.89,62.8 214.13,62.8 213.95,62.97 213.95,63.44 213.89,63.51 213.89,64.1 214.03,64.24 214.93,64.24
+3.3V_F383 on IN3 (solid shape): 316.27,46.6 316.27,29.53 315.97,29.23 314.61,29.23 314.44,29.4 314.44,34.57 314.45,34.59 314.48,34.64 314.49,34.69 314.5,34.74 314.5,34.79 314.49,34.85 314.48,34.9 314.45,34.94 314.44,34.97 314.44,42.41 315.29,42.41 315.29,42.36 315.29,42.3 315.31,42.25 315.33,42.2 315.36,42.16 315.4,42.12 315.44,42.09 315.49,42.06 315.54,42.04 315.59,42.03 315.64,42.03 315.69,42.03 315.75,42.04 315.8,42.06 315.84,42.09 315.88,42.12 315.92,42.16 315.95,42.2 315.97,42.25 315.99,42.3 316,42.36 316,42.41 315.99,42.46 315.97,42.51 315.95,42.56 315.92,42.6 315.88,42.64 315.84,42.68 315.8,42.7 315.75,42.72 315.69,42.73 315.64,42.74 315.59,42.73 315.54,42.72 315.49,42.7 315.44,42.68 315.4,42.64 315.36,42.6 315.33,42.56 315.31,42.51 315.29,42.46 315.29,42.41 314.44,42.41 314.44,46.47 314.81,46.85 316.02,46.85
+3.3V_F383 on IN4 (solid shape): 193.28,72.86 193.28,72.53 192.76,72.02 192.53,72.02 191.21,73.33 191.21,73.67 191.63,74.08 192.06,74.08
+3.3V_F383 on IN4 (solid shape): 215.13,64.23 215.13,63.6 214.99,63.46 213.32,63.46 212.8,63.98 212.8,64.29 212.99,64.49 214.87,64.49
+3.3V_FLASH on TOP (solid shape): 195.35,163.23 196.05,163.23 196.64,162.63 196.65,162.61 196.71,162.45 196.83,162.34 196.84,162.34 196.87,162.29 196.86,162.26 196.83,162.12 196.88,161.99 196.89,161.9 196.83,161.84 196.61,161.66 196.59,161.39 196.59,161.31 196.54,161.26 196.54,160.61 197.02,161.05 197.03,161.12 197.08,161.17 197.28,161.42 197.17,161.82 197.23,161.89 197.26,161.91 197.32,161.95 197.69,161.58 197.69,160.62 197.87,160.43 197.87,160.18 197.7,160 197.63,160 197.57,159.99 195.7,159.99 195.63,160.02 195.6,160.08 195.33,160.4 194.94,160.24 194.87,160.19 194.78,160.22 194.7,160.31 194.7,162.85 195.08,163.23 195.35,163.23
+3.3V_LC on TOP (solid shape): 165.19,162.62 165.19,162.06 165.17,162.03 161.5,162.03 161.44,162.09 161.44,162.63 161.49,162.68 162.31,162.68 162.35,162.71 165.1,162.71
+3.3V_TBT_SX on BOTTOM (solid shape): 177.75,169.51 177.75,168.94 177.55,168.75 177.3,168.75 176.86,169.2 175.59,169.2 175.46,169.32 175.46,169.64 175.52,169.7 177.55,169.7
+3V_PCH on TOP (solid shape): outline of 2052 points within 203.59,36.86 222.7,64.23
+3V_PCH on BOTTOM (solid shape): 217.49,39.81 217.49,38.97 217.44,38.92 217.44,38.2 216.99,37.74 216.75,37.74 216.56,37.93 216.3,37.93 216.24,38 216.24,38.63 216.37,38.76 216.62,38.76 216.75,38.89 216.75,39.83 216.83,39.91 217.38,39.91
+3V_PCH on BOTTOM (solid shape): 229.33,15.05 229.33,15.04 229.53,14.83 229.81,14.81 229.9,14.8 229.94,14.71 229.94,14.49 229.2,13.75 226.7,13.75 226.64,13.81 226.64,14.45 226.7,14.51 228.04,14.51 228.61,15.08 229.29,15.08
+3V_PCH on BOTTOM (solid shape): 210.4,20.26 210.4,20.15 210.44,20.11 210.44,19.79 210.39,19.71 210.3,19.7 210.02,19.67 209.87,19.44 209.19,19.44 209.14,19.46 209.09,19.46 209.04,19.46 209,19.46 208.95,19.44 208.56,19.44 208.38,19.61 208.38,19.71 208.7,20.02 208.7,20.03 208.99,20.32 209.43,20.32 209.51,20.24 209.55,20.24 209.56,20.23 209.67,20.21 209.77,20.23 209.78,20.24 209.8,20.24 209.95,20.38 210.28,20.38
+3V_PCH on BOTTOM (solid shape): 217.13,19.71 217.13,18.64 216.99,18.5 216.44,18.5 216.43,18.49 216.38,18.49 216.34,18.49 216.28,18.53 216.25,18.57 216.24,18.6 216.23,18.64 216.24,18.68 216.24,18.71 216.24,18.85 216.14,18.95 216.14,18.97 216.07,19.04 215.7,19.04 215.6,18.95 215.6,17.93 215.69,17.85 215.69,17.34 215.69,17.33 215.69,16.89 215.54,16.75 214.94,16.75 214.79,16.89 214.79,17.01 214.88,17.35 214.6,17.56 214.4,17.76 214.4,17.81 214.52,17.93 215.03,17.93 215.16,18.06 215.16,19.01 215.46,19.32 215.46,19.56 215.74,19.84 217,19.84
+3V_PCH on IN2 (solid shape): outline of 3389 points within 195.53,12.34 230.47,23.95
+3V_PCH on IN3 (solid shape): outline of 4234 points within 210.91,21.86 223.56,40.12
+3VALW on TOP (solid shape): 235.52,30.26 235.52,29.5 235.45,29.43 234.44,29.43 234.37,29.5 234.37,30.32 234.5,30.44 235.33,30.44
+3VALW on TOP (solid shape): 235.52,27.02 235.52,26.26 235.45,26.19 234.44,26.19 234.37,26.26 234.37,27.08 234.5,27.2 235.33,27.2
+3VALW on TOP (solid shape): 235.52,33.5 235.52,32.73 235.45,32.67 234.44,32.67 234.37,32.73 234.37,33.56 234.5,33.69 235.33,33.69
+3VALW on TOP (solid shape): 298.13,5.3 298.7,5.3 298.76,5.24 298.76,4.67 298.73,4.64 297.84,4.64 297.23,5.25 297.23,5.4 297.55,5.71 297.72,5.71
+3VALW on TOP (solid shape): 305.87,8.82 306.04,8.82 306.1,8.76 306.1,6.73 306,6.64 305.69,6.64 305.41,6.91 305.41,9.01 305.47,9.07 305.61,9.07
+3VALW on TOP (solid shape): 306.09,46.67 307.13,46.67 307.18,46.62 307.18,45.1 307,44.92 303.63,44.92 303.48,45.07 303.48,45.84 303.66,46.02 304.65,46.02 305.3,46.67 306.08,46.67
+3VALW on TOP (solid shape): 244.61,19.27 244.61,18.42 244.62,18.41 244.62,18.1 245.22,17.5 246.38,17.5 246.44,17.44 246.44,16.65 246.41,16.62 244.78,16.62 242.59,18.81 242.59,19.86 242.71,19.97 243.91,19.97
+3VALW on TOP (solid shape): 297.4,26.18 297.4,25.27 297.3,25.17 297.3,23 297.19,22.9 297.09,22.9 296.98,23 296.98,24.69 296.93,24.75 296.9,24.78 296.87,24.8 296.71,24.96 296.71,26.17 296.81,26.27 297.3,26.27
+3VALW on TOP (solid shape): 290.06,25.75 290.06,24.55 290.28,24.33 290.28,23.03 290.55,22.77 292.11,22.77 292.4,22.47 292.4,22.13 292.33,22.05 289.34,22.05 288.36,23.03 288.36,23.86 288.36,23.86 288.36,24.75 288.61,25 288.61,26.26 288.66,26.31 289.49,26.31
+3VALW on TOP (solid shape): 303.38,26.14 303.38,25.59 302.48,24.7 302.48,23.71 302.47,23.7 302.47,23.01 302.4,22.94 302.28,22.94 302.21,23 302.21,25.13 302.6,25.51 302.6,25.6 302.61,25.61 302.69,25.85 302.66,26.09 302.65,26.12 302.72,26.19 303.33,26.19
+3VALW on TOP (solid shape): 51.51,23.4 51.51,21.05 50.99,20.54 47.06,20.54 47.06,21.06 46.36,21.06 46.36,20.54 45.86,20.54 45.86,21.06 45.16,21.06 45.16,20.54 41.85,20.54 41.85,21.06 41.15,21.06 41.15,20.54 40.65,20.54 40.65,21.06 39.95,21.06 39.95,20.54 39.38,20.54 39.19,20.73 39.19,23.53 39.44,23.78 41.47,23.78 41.86,24.16 50.75,24.16
+3VALW on TOP (solid shape): 311.86,25.08 311.86,24.76 311.47,24.38 311.46,24.38 311.46,23.56 312.11,23.56 312.11,22.69 311.08,21.67 311.08,20.38 310.95,20.24 310.31,20.24 310.25,20.31 310.25,21.26 310.09,21.42 310.09,21.42 309.9,21.61 308.98,21.61 308.28,20.9 306.25,20.9 306.25,21.09 306.35,21.18 308.1,21.18 308.21,21.29 308.21,21.8 308.85,22.45 308.85,22.46 308.92,22.53 310.45,22.53 310.64,22.72 310.64,25.12 310.79,25.27 311.66,25.27
+3VALW on TOP (solid shape): outline of 147 points within 310.46,50.68 318.68,59.85
+3VALW on TOP (solid shape): outline of 243 points within 11.33,50.23 19.57,54.83
+3VALW on TOP (solid shape): outline of 478 points within 195.26,61.46 209.69,82.28
+3VALW on BOTTOM (solid shape): 175.46,174.95 175.46,174.02 175.33,173.9 174,173.9 173.87,174.02 173.87,175.32 174.06,175.51 174.89,175.51
+3VALW on BOTTOM (solid shape): 229.59,23.78 229.59,23.02 229.52,22.96 228.51,22.96 228.44,23.02 228.44,23.84 228.57,23.97 229.4,23.97
+3VALW on BOTTOM (solid shape): 235.52,23.78 235.52,23.02 235.45,22.96 234.44,22.96 234.37,23.02 234.37,23.84 234.5,23.97 235.33,23.97
+3VALW on BOTTOM (solid shape): 229.59,30.26 229.59,29.5 229.52,29.43 228.51,29.43 228.44,29.5 228.44,30.32 228.57,30.44 229.4,30.44
+3VALW on BOTTOM (solid shape): 229.59,27.02 229.59,26.26 229.52,26.19 228.51,26.19 228.44,26.26 228.44,27.08 228.57,27.2 229.4,27.2
+3VALW on BOTTOM (solid shape): 235.52,33.5 235.52,32.73 235.45,32.67 234.44,32.67 234.37,32.73 234.37,33.56 234.5,33.69 235.33,33.69
+3VALW on BOTTOM (solid shape): 235.52,30.26 235.52,29.5 235.45,29.43 234.44,29.43 234.37,29.5 234.37,30.32 234.5,30.44 235.33,30.44
+3VALW on BOTTOM (solid shape): 235.52,27.02 235.52,26.26 235.45,26.19 234.44,26.19 234.37,26.26 234.37,27.08 234.5,27.2 235.33,27.2
+3VALW on BOTTOM (solid shape): 229.59,33.69 229.59,32.73 229.52,32.67 228.51,32.67 228.44,32.73 228.44,33.7 228.59,33.85 229.43,33.85
+3VALW on BOTTOM (solid shape): 164.14,165.61 164.14,163.7 164.05,163.61 162.12,163.61 162.06,163.67 162.06,164.2 161.83,164.44 161.2,164.44 161.1,164.33 161.09,164.32 161.09,164.08 161.06,164.05 160.6,164.05 160.55,164.11 160.55,165.22 161.06,165.73 164.02,165.73
+3VALW on BOTTOM (solid shape): 225.94,150.44 225.94,149.5 224.91,148.47 224.91,147.21 224.67,146.97 223.78,146.97 223.35,147.4 223.35,149.32 223.47,149.43 223.78,149.43 223.9,149.55 223.9,150.06 224.02,150.18 224.98,150.18 225.36,150.56 225.82,150.56
+3VALW on BOTTOM (solid shape): 123.58,115.92 123.58,115.8 123.9,115.47 123.9,114.84 124.34,114.4 124.53,114.4 124.6,114.33 124.6,112.68 124.53,112.62 123.9,112.62 123.71,112.81 123.71,114.2 123.2,114.71 123.2,115.22 122.62,115.8 122.62,115.92 122.75,116.05 123.45,116.05
+3VALW on BOTTOM (solid shape): 209.11,83.6 209.11,81.44 208.8,81.12 208.48,81.12 208.08,80.72 208.08,79.83 207.5,79.25 206.78,79.25 206.78,79.77 206.25,79.77 206.25,80.07 206.78,80.07 206.78,80.57 206.25,80.57 206.25,80.86 206.78,80.86 206.78,81.45 206.38,81.45 206.25,81.57 206.25,82.07 206.26,82.07 206.26,83.66 206.45,83.85 208.86,83.85
+3VALW on BOTTOM (solid shape): 68.4,18.56 68.4,17.93 68.56,17.76 68.56,15.16 68.12,14.71 65.45,14.71 65.39,14.78 65.39,15.6 65.86,16.07 65.86,17.14 65.98,17.27 66.26,17.27 66.47,17.47 66.47,17.77 67.41,18.71 68.25,18.71
+3VALW on BOTTOM (solid shape): 162.04,175.04 162.26,174.94 162.49,175 162.52,175.02 162.57,174.97 162.57,174.29 162.45,174.17 161.28,174.17 160.6,173.48 160.05,173.48 159.84,173.27 158.77,173.27 158.73,173.31 158.73,173.34 158.6,173.48 158.54,173.48 158.51,173.5 158.51,174.13 158.54,174.16 159.51,174.16 159.53,174.13 159.82,173.96 160.11,174.13 160.13,174.16 160.46,174.16 160.64,174.33 160.64,174.88 160.79,175.04
+3VALW on BOTTOM (solid shape): outline of 165 points within 200.92,64.87 205.18,71.42
+3VALW on BOTTOM (solid shape): outline of 451 points within 309.21,9.13 312.38,25.57
+3VALW on IN1 (solid shape): 318.47,58.33 318.47,55.14 318.29,54.96 314.98,54.96 313.81,53.79 310.62,53.79 310.28,54.13 310.28,58.39 310.58,58.69 318.11,58.69
+3VALW on IN1 (solid shape): outline of 94 points within 63.23,13.43 69.58,18.32
+3VALW on IN1 (solid shape): outline of 209 points within 288.79,23.43 311.95,25.88
+3VALW on IN2 (solid shape): 209.37,83.28 209.37,81.19 209.18,80.99 208.54,80.99 208.35,81.19 208.35,83.28 208.48,83.41 209.24,83.41
+3VALW on IN2 (solid shape): 220.45,149.99 220.8,149.69 221.15,149.99 221.16,150.03 221.7,150.03 221.79,149.98 221.8,149.89 222.04,149.39 222.48,149.73 222.49,149.77 222.52,149.81 222.85,149.78 223.06,150.03 223.76,150.03 224.14,149.65 224.14,148.38 224.11,148.35 221.25,148.35 221.24,148.38 220.91,148.58 220.59,148.38 220.58,148.35 217.56,148.35 217.3,148.09 217.04,148.09 216.8,147.85 215.96,147.85 215.79,148.01 215.79,148.99 215.81,148.99 216.63,149.81 218.82,149.81 218.91,149.72 219.04,149.29 219.48,149.33 219.55,149.36 219.62,149.33 220.13,149.35 220.11,149.85 220.08,149.97 220.17,150.03 220.44,150.03
+3VALW on IN2 (solid shape): outline of 1442 points within 228.35,19.36 244.59,34.77
+3VALW on IN3 (solid shape): outline of 2398 points within 10.92,21.03 49.44,52.52
+3VALW on VCC: outline of 125 points within 44.14,12.86 334.15,167.42
+3VALW_PD on TOP (solid shape): 197.43,164.62 197.43,163.93 197.3,163.8 196.67,163.8 196.22,163.35 195.4,163.35 195.32,163.43 195.32,164.74 195.4,164.81 197.24,164.81
+3VALWP on TOP (solid shape): 40.53,20.41 40.55,20.41 41.25,20.41 41.28,20.41 41.28,20.93 41.73,20.93 41.73,20.41 41.75,20.41 42.53,20.41 42.53,20.41 44.48,20.41 44.48,20.41 45.26,20.41 45.29,20.41 45.29,20.93 45.73,20.93 45.73,20.41 45.76,20.41 46.46,20.41 46.49,20.41 46.49,20.93 46.93,20.93 46.93,20.41 46.96,20.41 51.52,20.41 51.76,20.16 51.76,16.54 51.25,16.03 44.27,16.03 42.93,17.37 42.02,17.37 42,17.39 39.93,17.39 39.38,17.94 39.38,20.23 39.38,20.23 39.38,20.37 39.42,20.41 40.05,20.41 40.08,20.41 40.08,20.93 40.53,20.93
+3VALWP on BOTTOM (solid shape): 43.63,24.04 43.63,21.88 44.4,21.11 51.44,21.11 51.63,20.92 51.63,17.18 51.44,16.99 41.6,16.99 41.16,17.43 41.16,18 39.89,19.27 39.89,24.1 40.33,24.54 43.13,24.54
+3VGS on TOP (solid shape): 234.6,89.8 234.6,89.67 234.62,89.64 234.64,89.55 234.62,89.46 234.6,89.43 234.6,88.91 234.62,88.88 234.66,88.75 234.62,88.62 234.6,88.59 234.6,88.51 234.58,88.49 233.69,88.49 233.57,88.6 233.57,88.84 233.56,88.85 233.56,89.12 233.63,89.19 234.01,89.19 234.2,89.38 234.2,89.69 234.32,89.82 234.58,89.82
+3VGS on BOTTOM (solid shape): 207.86,65.09 207.86,61.09 207.7,60.94 206.64,60.94 206.46,61.6 206.27,60.94 205.47,60.94 205.34,61.07 205.34,65.04 205.81,65.51 207.44,65.51
+3VGS on BOTTOM (solid shape): outline of 115 points within 202.32,79.09 206.64,84.8
+3VGS on BOTTOM (solid shape): outline of 91 points within 231.78,77.12 235.91,90.27
+3VLP on TOP (solid shape): 306.39,15.58 307.94,15.58 307.96,15.59 308.52,15.59 308.77,15.34 309.31,15.34 309.5,15.15 309.5,14.76 309.37,14.63 308.73,14.63 308.1,15.26 308.09,15.26 306.35,15.26 306.27,15.34 306.27,15.5 306.36,15.59
+3VS on TOP (solid shape): 300.81,5.18 300.81,4.3 300.72,4.21 299.22,4.21 299.08,4.34 299.08,5.18 299.21,5.3 300.69,5.3
+3VS on TOP (solid shape): 303.88,40.39 305.05,40.39 305.16,40.27 305.16,39.31 304.82,38.97 300.66,38.97 300.27,39.35 300.27,40.94 300.46,41.13 303.13,41.13
+3VS on TOP (solid shape): 318.75,41.07 318.75,40.14 317.44,38.82 315.02,38.82 314.77,39.07 314.77,40.25 315.32,40.8 316.52,40.8 316.97,41.26 318.56,41.26
+3VS on TOP (solid shape): 177.26,64.63 177.37,64.57 177.5,64.55 177.53,64.55 177.7,64.37 177.7,61.13 177.57,61.01 176.94,61.01 176.68,61.26 176.68,62.28 176.37,62.59 176.37,64.44 176.56,64.63
+3VS on TOP (solid shape): 312.53,44.25 312.53,43.56 311.98,43.02 311.98,41.53 312.53,40.99 312.53,40.74 312.38,40.59 310.86,40.59 310.46,40.99 310.46,43.97 310.92,44.43 311.21,44.43 311.21,44.44 312.34,44.44
+3VS on TOP (solid shape): 305.58,43.14 305.58,41.3 305.31,41.03 303.66,41.03 303.45,41.24 303.45,42.3 304.63,42.3 304.63,42.24 304.64,42.19 304.66,42.14 304.69,42.1 304.72,42.05 304.76,42.02 304.81,41.99 304.86,41.97 304.91,41.95 304.96,41.94 305.01,41.94 305.07,41.95 305.12,41.97 305.16,41.99 305.21,42.02 305.25,42.05 305.28,42.1 305.31,42.14 305.33,42.19 305.34,42.24 305.34,42.3 305.34,42.35 305.33,42.4 305.31,42.45 305.28,42.5 305.25,42.54 305.21,42.58 305.16,42.61 305.12,42.63 305.07,42.65 305.01,42.65 304.96,42.65 304.91,42.65 304.86,42.63 304.81,42.61 304.76,42.58 304.72,42.54 304.69,42.5 304.66,42.45 304.64,42.4 304.63,42.35 304.63,42.3 303.45,42.3 303.45,43.22 303.64,43.42 305.31,43.42
+3VS on TOP (solid shape): 161,163.48 161,162.2 161.4,161.79 161.4,161.79 161.44,161.75 161.44,161.03 161.61,160.86 161.61,160.57 161.41,160.37 160,160.37 159.84,160.53 159.8,160.59 159.8,160.79 159.86,161.12 159.61,161.35 159.6,161.35 159.5,161.45 159.5,162.53 159.59,162.67 159.62,162.83 159.62,162.85 159.59,163 159.52,163.13 159.61,163.34 159.6,163.56 159.68,163.64 160.83,163.64
+3VS on BOTTOM (solid shape): 210.32,160.73 210.32,158.34 210.16,158.19 208.39,158.19 208.33,158.25 208.33,160.74 208.62,161.02 210.03,161.02
+3VS on BOTTOM (solid shape): 239.66,163.74 239.66,162.41 239.53,162.29 236.9,162.29 236.62,162.57 236.62,163.22 236.62,163.22 236.62,163.57 236.98,163.93 239.47,163.93
+3VS on BOTTOM (solid shape): 126.08,12.48 126.08,9.36 125.99,9.27 123.31,9.27 123.24,9.33 123.24,10.66 123.16,10.74 122.63,10.74 122.51,10.87 122.51,12.45 122.7,12.64 125.92,12.64
+3VS on BOTTOM (solid shape): 301.23,41.83 301.23,40.3 301.44,40.09 302.87,40.09 303.03,39.93 303.03,39.03 302.96,38.96 300.61,38.96 300.27,39.29 300.27,41.76 300.4,41.89 301.16,41.89
+3VS on BOTTOM (solid shape): 73.02,18.48 73.02,12.68 72.47,12.13 72.47,10.31 72.25,10.08 72.19,10.08 72.19,10.08 71.04,10.08 70.28,10.08 69.77,10.59 69.77,15.46 70.13,15.82 70.13,18.49 70.33,18.69 72.81,18.69
+3VS on BOTTOM (solid shape): 185.12,53.67 185.12,52.71 185.31,52.52 185.31,52.49 185.31,52.48 185.31,51.67 185.32,51.58 185.36,51.49 185.36,51.48 185.36,50.94 185.26,50.84 184.93,50.84 184.74,51.03 184.74,51.97 183.85,52.86 183.85,53.56 184.03,53.74 185.05,53.74
+3VS on BOTTOM (solid shape): 125.87,156.89 125.98,156.88 126.09,156.89 127.19,156.89 127.31,156.77 127.31,156.57 127.19,156.45 126.31,156.45 126.18,156.32 126.18,155.91 125.99,155.72 125,155.72 124.88,155.84 124.88,156.65 124.97,156.74 125.22,156.74 125.37,156.89
+3VS on BOTTOM (solid shape): 173.26,165.09 173.28,165.05 173.29,165.02 173.29,163.14 173.17,163.03 172.29,163.03 172.01,163.31 172.06,163.57 171.92,163.79 171.92,165.1 172.16,165.34 173.02,165.34
+3VS on BOTTOM (solid shape): 319.17,41.72 319.17,39.82 318.75,39.51 318.54,39.05 318.52,39.03 317.27,39.03 316.87,39.43 316.87,39.99 317.04,40.16 317.69,40.16 317.89,40.36 317.89,41.8 318.05,41.96 318.92,41.96
+3VS on BOTTOM (solid shape): 167.97,170.23 167.97,169.67 168.22,169.42 168.85,169.42 168.88,169.39 168.88,168.6 168.78,168.51 168.04,168.51 168.03,168.51 167.9,168.54 167.77,168.51 167.77,168.51 167.62,168.51 167.23,168.12 167.23,167.61 167.09,167.47 167.09,167.05 167,166.96 166.57,166.96 166.39,166.96 166.35,167 166.35,167.56 166.71,167.91 166.71,168 166.82,168.11 166.82,168.83 167.34,169.35 167.34,170.24 167.43,170.33 167.87,170.33
+3VS on BOTTOM (solid shape): 161.75,161.18 162.16,161.18 162.17,161.18 162.37,161.15 162.56,161.18 162.57,161.18 164.69,161.18 164.79,161.09 164.79,160.08 164.66,159.95 163.57,159.95 163.04,160.48 162.68,160.48 162.65,160.51 161.72,160.51 161.65,160.5 161.57,160.48 161.49,160.48 161.17,160.15 160.83,160.15 160.73,160.21 160.75,160.32 160.97,160.54 160.97,160.84 161.47,161.35 161.59,161.35
+3VS on BOTTOM (solid shape): 216.16,150.88 216.16,149.46 215.9,149.2 215.9,149.19 215.65,148.95 214.78,148.95 214.65,148.83 213.98,148.83 213.67,149.13 213.67,150.77 213.72,150.82 214.3,150.82 214.55,150.56 214.55,150.29 214.58,150.29 214.58,150.02 214.59,149.93 214.62,149.84 214.63,149.82 214.64,149.82 215.06,149.65 215.34,150 215.34,150.02 215.54,150.22 215.54,150.9 215.58,150.93 216.11,150.93
+3VS on BOTTOM (solid shape): 222.53,27.38 222.35,27.2 222.35,26.61 222.36,26.59 222.36,25.79 222.37,25.78 222.37,25.47 222.12,25.22 222.12,24.91 222.37,24.66 222.54,24.66 222.74,24.45 223.44,24.45 223.48,24.42 223.48,23.77 222.8,23.09 220.95,23.09 220.73,23.31 220.73,25.94 220.9,25.94 220.9,25.92 220.91,25.87 220.93,25.81 220.95,25.77 220.98,25.72 221.02,25.68 221.06,25.65 221.1,25.62 221.15,25.6 221.21,25.59 221.26,25.59 221.31,25.59 221.36,25.6 221.41,25.62 221.46,25.65 221.5,25.68 221.54,25.72 221.57,25.77 221.59,25.81 221.61,25.87 221.61,25.92 221.61,25.97 221.61,26.02 221.59,26.07 221.57,26.12 221.54,26.17 221.5,26.21 221.46,26.24 221.41,26.27 221.36,26.29 221.31,26.3 221.26,26.3 221.21,26.3 221.15,26.29 221.1,26.27 221.06,26.24 221.02,26.21 220.98,26.17 220.95,26.12 220.93,26.07 220.91,26.02 220.9,25.97 220.9,25.94 220.73,25.94 220.73,28 220.86,28.12 221.49,28.12 221.51,28.12 221.56,28.12 221.63,28.12 221.68,28.14 221.72,28.16 221.77,28.18 221.8,28.21 221.84,28.25 221.87,28.29 221.88,28.31 222.53,28.31
+3VS on BOTTOM (solid shape): outline of 150 points within 176.07,70.4 186.16,73.53
+3VS on IN1 (solid shape): outline of 126 points within 300.54,39.19 318.65,41.56
+3VS on IN1 (solid shape): outline of 520 points within 107.51,26.45 124.79,32.5
+3VS on IN1 (solid shape): outline of 1008 points within 181.75,107.16 191.52,122.14
+3VS on IN2 (solid shape): outline of 184 points within 102.66,9.3 125.84,12.27
+3VS on IN2 (solid shape): outline of 519 points within 186.25,115.67 192.03,124.62
+3VS on IN3 (solid shape): outline of 7875 points within 157.11,33.86 182.89,71.31
+3VS on IN4 (solid shape): 208.48,33.12 208.48,32.16 207.94,31.62 207.94,25.46 207.18,24.71 207.09,24.68 207.02,24.74 206.5,24.84 206.6,24.32 206.66,24.25 206.63,24.16 206.57,24.1 205.3,24.1 205.05,24.35 205.05,25.31 205.24,25.5 206.19,25.5 207.08,26.38 207.08,32.99 207.59,33.5 208.1,33.5
+3VS on TOP: outline of 169 points within 194.72,8.6 210.13,25.5
+3VS on VCC: outline of 115 points within 47.25,16.54 327.29,173.51 ; 7 cut-outs
+3VS_CAM on TOP (solid shape): 160.95,165.86 160.95,165.51 160.86,165.42 160.73,165.42 160.63,165.32 160.63,165.3 160.62,165.29 160.52,165.04 160.62,164.8 160.63,164.79 160.63,164.69 160.52,164.52 160.51,164.32 160.51,164.31 160.51,164.15 160.33,163.98 159.44,163.98 159.22,164.21 159.22,165.98 159.31,166.07 160.58,166.07 160.58,166.1 160.71,166.1
+3VS_CAM on TOP (solid shape): outline of 302 points within 162.89,169.51 167.8,180.83
+3VS_CAM on IN4 (solid shape): 165.23,172.28 165.23,171.19 165.04,171 164.54,171 164.12,170.58 164.12,170.51 164.02,170.41 164.02,168.76 164.12,168.66 164.12,167.59 161.26,164.73 161.19,164.73 161.15,164.76 161.15,164.82 160.88,165.4 160.61,164.82 160.61,164.76 160.57,164.73 160.45,164.73 160.06,165.13 160.06,165.79 162.81,168.54 162.81,171.64 163.25,172.08 163.33,172.11 163.41,172.06 163.45,172 163.51,171.95 163.56,171.86 163.51,171.78 163.71,171.13 163.91,171.78 163.86,171.86 163.91,171.95 163.98,172.01 164.03,172.09 164.1,172.14 164.18,172.13 164.58,172.12 164.74,172.49 164.76,172.57 164.84,172.61 164.9,172.61
+3VS_DP on BOTTOM (solid shape): 237.99,171.58 237.99,170.14 239.53,168.61 240,168.61 240.17,168.44 240.17,166.94 240.09,166.86 239.89,166.76 239.79,166.56 239.65,166.42 239.65,165.1 239.66,165.09 239.57,165.01 238.04,165.01 238.01,165.04 238.01,166.07 238.11,166.17 238.29,166.17 238.45,166.34 238.45,167.06 238.22,167.29 238.22,167.97 237.52,168.67 237.52,171.53 237.66,171.67 237.9,171.67
+3VS_SSD on TOP (solid shape): 337.01,48.48 337.01,44.42 336.63,44.04 334.45,44.04 333.38,45.11 333.38,47.75 333.03,48.1 333.03,48.63 333.07,48.67 336.82,48.67
+3VS_SSD on TOP (solid shape): 322.46,50.58 326.91,50.58 327.16,50.32 327.16,48.36 327.01,48.2 327,48.2 326.91,48.13 326.84,48.04 326.84,48.03 326.59,47.78 321.95,47.78 321.26,47.09 315.41,47.09 315.03,47.47 315.03,49.75 315.35,50.07 315.98,50.07 316.3,50.38 316.3,51.27 316.47,51.44 321.6,51.44
+3VS_SSD on TOP (solid shape): 334.23,33.11 334.23,29.75 334.44,29.54 335.52,29.54 335.77,29.29 335.77,27.47 335.66,27.35 332.53,27.35 332.32,27.57 332.32,29.59 332.01,29.9 331.44,29.9 331.26,30.08 331.26,31.64 331.21,31.7 329.42,31.7 329.1,31.38 329.1,31.09 328.8,30.79 328.35,30.79 328.23,30.91 328.23,32.4 329.09,33.26 329.09,33.26 329.35,33.52 333.82,33.52
+3VS_SSD on TOP (solid shape): 278.62,23.3 278.62,18.72 281.95,15.4 281.95,10.36 281.97,10.34 281.97,6.28 281.82,6.13 281.82,6.12 281.63,5.94 281.63,5.18 281.38,4.92 279.09,4.92 278.84,5.18 278.84,5.56 279.54,6.26 279.54,7.91 279.29,8.15 276.21,8.15 275.84,7.78 275.84,6.97 275.72,6.85 274.59,6.85 274.39,7.06 274.39,10.45 274.5,10.56 277.06,10.56 277.06,10.57 277.31,10.83 277.31,12.1 276.39,13.02 276.39,15.94 274.77,17.56 274.77,23.65 274.84,23.72 278.2,23.72
+3VS_SSD on TOP (solid shape): 237.92,7.51 238.22,7.51 238.23,7.53 238.5,7.53 238.51,7.51 238.56,7.51 238.95,7.12 243.18,7.12 243.57,6.74 251.68,6.74 251.9,6.95 254.38,6.95 254.77,6.85 255.17,6.95 255.28,6.95 255.66,6.57 255.66,5.81 255.53,5.68 254.97,5.68 254.78,5.74 254.59,5.68 249.56,5.68 248.67,4.79 238.79,4.79 238.71,4.83 238.63,5.25 238.32,5.4 237.46,5.4 237.24,5.62 235.53,5.62 235.4,5.75 235.4,6.64 235.64,6.88 236.53,6.88 236.67,7.02 236.67,7.49 236.71,7.53 237.91,7.53
+3VS_SSD on BOTTOM (solid shape): 237.89,6.83 237.89,6.5 237.77,6.37 237.19,6.37 236.93,6.11 236.93,4.66 236.84,4.57 235.69,4.57 235.59,4.67 235.59,6.07 235.49,6.18 235.49,6.83 235.77,7.11 237.61,7.11
+3VS_SSD on BOTTOM (solid shape): outline of 124 points within 332.37,43.72 336.43,48.29
+3VS_SSD on BOTTOM (solid shape): outline of 2062 points within 249.63,4.16 335.8,31.01
+3VS_SSD on IN1 (solid shape): outline of 393 points within 260.35,16.44 278.9,22.06
+3VS_SSD on IN2 (solid shape): outline of 1072 points within 278.96,4.17 328.43,7.02
+3VS_SSD on IN3 (solid shape): outline of 899 points within 329.19,27.34 336.37,46.51
+3VS_SSD on IN4 (solid shape): outline of 266 points within 250.15,7.56 274.19,12.77
+3VS_SSD on IN4 (solid shape): outline of 653 points within 318.89,43.9 336.3,51.25
+3VS_SSD on VCC: 172.47,4.17 172.47,6.78 176.77,11.08 176.79,11.08 177.05,11.34 181.75,11.34 186.95,6.13 232.84,6.13 234.05,7.33 237.56,7.33 238.2,6.7 238.2,4.22 238.14,4.17
+3VS_TBT on TOP (solid shape): 178.19,174.66 178.19,173.51 177.94,173.26 177.94,173.07 177.81,172.94 177.43,172.94 177.36,172.88 177.36,172.43 177.17,172.24 177.17,171.56 177.03,171.42 177.03,171.41 176.9,171.28 176.88,171.28 176.47,171.07 176.35,170.62 176.35,170.53 176.48,170.41 176.48,170.15 176.6,170.02 176.92,170.02 176.94,170 176.94,169.54 176.96,169.51 176.96,169.29 176.9,169.23 176.79,169.23 176.66,169.35 176.66,169.53 176.53,169.66 176.34,169.66 176.28,169.72 176.28,169.99 175.96,170.32 175.96,170.98 175.96,171.1 176.1,171.24 176.17,171.24 176.17,171.86 176.41,172.11 176.41,174.34 176.86,174.78 178.06,174.78
+3VS_TBT on BOTTOM (solid shape): 178.19,173.83 178.19,173.5 178.1,173.42 178.04,173.31 178.04,173.3 177.62,172.89 177.24,172.89 175.71,171.36 174.06,171.36 173.87,171.55 173.87,172.94 174,173.07 175.59,173.07 176.54,174.02 178,174.02
+3VS_TBT on IN2 (solid shape): outline of 183 points within 173.43,155.48 182.25,169.95
+3VS_TBT on IN4 (solid shape): outline of 1042 points within 176.22,162.66 182.29,174.09
+5V_HDD on TOP (solid shape): 130.25,10.98 130.25,10.21 129.72,10.21 129.71,10.2 129.71,9.46 130.25,9.46 130.25,9.01 129.71,9.01 129.71,8.26 130.25,8.26 130.25,7.69 130.19,7.63 128.53,7.63 128.43,7.72 128.43,9.32 127.94,9.81 125.26,9.81 125.19,9.88 125.19,10.46 125.62,10.88 125.62,11.44 126.06,11.88 129.35,11.88
+5V_HDD on BOTTOM (solid shape): 128.95,11.3 128.95,9.27 128.67,8.98 126.54,8.98 126.29,9.23 126.29,11.45 126.46,11.62 128.63,11.62
+5V_PVDD on TOP (solid shape): 27.81,42.01 27.88,41.98 27.91,41.91 27.95,41.78 28.04,41.67 28.07,41.59 28.04,41.52 28.27,40.89 28.5,41.52 28.46,41.59 28.5,41.67 28.58,41.78 28.62,41.91 28.65,41.98 28.72,42.01 29.88,42.01 30.18,41.83 30.49,42.01 30.69,42.01 31.04,41.65 33.75,41.65 33.94,41.46 33.94,39.05 34.13,38.86 34.76,38.86 34.95,38.67 34.95,37.68 34.81,37.53 32.99,37.53 32.98,37.56 32.95,37.62 32.9,37.67 32.68,37.89 32.68,39.65 32.61,39.72 31.47,39.72 30.93,39.18 29.74,39.18 29.65,39.24 29.67,39.35 29.66,39.85 29.16,39.85 26.87,39.85 26.74,39.98 26.74,40 26.75,40.18 26.68,40.35 26.68,41.75 26.93,42.01
+5V_TOBII on TOP (solid shape): outline of 283 points within 145.55,157.48 155.58,166.4
+5V_USB_PWR1 on TOP (solid shape): 19.51,48.34 19.61,48.14 19.8,48.04 20.06,47.78 21.04,47.78 21.64,47.19 21.64,46.62 21.65,46.61 21.65,45.88 21.7,45.82 21.7,45.6 21.64,45.54 21.51,45.54 21.13,45.92 20.27,45.92 20.24,45.94 20.21,45.95 20.05,46.11 20.05,46.13 18.68,46.13 18.17,46.64 18.17,48.32 18.42,48.57 19.27,48.57
+5V_USB_PWR1 on BOTTOM (solid shape): 21.22,47.59 21.22,44.77 20.87,44.42 20.87,41.88 20.62,41.62 18.79,41.62 17.98,40.82 16.19,40.82 15.94,41.07 15.94,42.89 18.1,45.06 18.1,47.4 18.11,47.4 18.11,47.56 18.21,47.66 21.15,47.66
+5V_USB_PWR2 on TOP (solid shape): 326.41,12.01 327.35,12.01 327.52,11.84 327.52,10.3 327.39,10.17 326.44,10.17 326.23,10.38 326.23,10.46 325.99,10.7 325.07,10.7 324.95,10.82 324.95,11.92 325.04,12.02 326.4,12.02
+5V_USB_PWR2 on BOTTOM (solid shape): 268.42,24.35 268.42,22.38 267.09,21.05 265.5,21.05 265.44,21.11 265.44,22.77 264.93,23.27 264.3,23.27 264.14,23.43 264.14,24.12 264.56,24.54 268.23,24.54
+5V_USB_PWR2 on IN4 (solid shape): outline of 2171 points within 266.33,9.64 327.51,24.65
+5V_USBC_VBUS on BOTTOM (solid shape): 15.06,54.52 15.06,53.47 15.26,53.27 16.66,53.27 16.79,53.14 16.79,52.63 16.66,52.5 14.94,52.5 14.67,52.24 14.67,51.4 14.48,51.21 11.06,51.21 10.74,51.53 10.74,54.71 10.93,54.9 14.68,54.9
+5V_USBC_VBUS on BOTTOM (solid shape): 11.03,58.36 11.79,58.36 12.2,57.94 12.2,57.06 12.07,56.93 11.69,56.93 11.57,57.06 11.57,57.18 11.38,57.37 10.8,57.37 10.39,57.79 8.64,57.79 7.85,58.58 7.85,58.86 8.07,59.09 10.3,59.09
+5V_USBC_VBUS on BOTTOM (solid shape): 11.44,63.28 11.44,62.01 11.25,61.82 9.53,61.82 9.09,61.37 8.07,61.37 8.01,61.44 8.01,61.94 8.72,62.65 8.97,62.91 9,62.91 9.28,63.01 9.38,63.29 9.38,63.31 9.53,63.47 11.25,63.47
+5V_USBC_VBUS on IN2 (solid shape): outline of 648 points within 4.77,52.8 13.03,63.91
+5VALW on TOP (solid shape): 223.23,166.79 223.23,164.86 223.11,164.74 221.89,164.74 221.64,164.99 221.64,166.78 221.79,166.94 223.08,166.94
+5VALW on TOP (solid shape): 249.6,24.45 249.6,23.88 248.8,23.08 248.48,23.08 248.45,23.11 248.45,24.45 248.61,24.61 249.44,24.61
+5VALW on TOP (solid shape): 203.46,69.63 203.46,68.74 202.76,68.04 202.19,68.04 201.94,68.29 201.94,68.8 202.13,68.99 202.13,68.99 202.57,68.99 202.95,69.37 202.95,69.69 203.4,69.69
+5VALW on TOP (solid shape): 321.87,8.13 322.91,8.13 323.16,7.88 323.16,6.8 323.1,6.74 320.53,6.74 320.28,6.99 320.28,7.37 319.14,8.51 319.14,9.98 319.26,10.1 319.9,10.1
+5VALW on TOP (solid shape): 21.7,43.57 21.7,43.34 21.65,43.29 21.65,42.5 21.62,42.47 21.62,40.18 21.45,40.01 20.3,40.01 20.05,40.27 20.05,42.17 21.51,43.63 21.64,43.63
+5VALW on TOP (solid shape): 200.11,175.36 200.11,174.3 199.92,174.1 199.22,174.1 198.83,173.7 198.26,173.7 197.94,174.02 197.94,174.15 198.51,174.72 198.51,175.08 198.9,175.46 199.52,175.46 199.52,175.47 200.01,175.47
+5VALW on TOP (solid shape): 145.11,165.93 145.11,164.82 146.08,163.85 146.08,163.11 145.31,162.34 143.46,162.34 143.26,162.53 143.26,163.44 143.06,163.65 142.36,163.65 142.31,163.69 142.31,164.32 142.48,164.48 143.26,164.48 143.66,164.89 143.66,165.26 144.07,165.67 144.07,166 144.1,166.03 145,166.03
+5VALW on TOP (solid shape): outline of 143 points within 61.16,5.71 68.3,17.16
+5VALW on TOP (solid shape): outline of 211 points within 36.97,43.34 51.38,50.32
+5VALW on BOTTOM (solid shape): 241.37,40.35 241.37,38.82 241.25,38.7 240.15,38.7 239.89,38.95 239.89,39.63 240.43,39.63 240.43,40.06 239.89,40.06 239.89,40.38 240.06,40.55 241.18,40.55
+5VALW on BOTTOM (solid shape): 25.39,49.58 25.39,48.08 25.15,47.85 23.5,47.85 23.23,48.12 23.23,49.31 23.29,49.37 23.82,49.37 24.27,49.82 24.27,49.83 25.13,49.83
+5VALW on BOTTOM (solid shape): 104.72,49.94 104.72,49.31 104.59,49.18 103.51,49.18 103.26,48.93 103.26,47.12 103.21,47.07 102.52,47.07 102.43,47.16 102.43,49.75 102.75,50.07 104.59,50.07
+5VALW on BOTTOM (solid shape): 221.19,166.06 222.16,166.06 222.16,166.05 222.52,166.05 222.74,165.83 222.74,165.3 222.57,165.13 221.19,165.13 220.64,165.68 220.09,165.68 219.88,165.88 219.88,166.24 219.91,166.31 219.92,166.38 220.02,166.48 220.77,166.48
+5VALW on BOTTOM (solid shape): 264.81,27.95 264.82,27.95 264.87,27.91 264.87,25.88 264.61,25.62 263.98,25.62 263.55,26.05 263.55,26.37 263.3,26.62 261.08,26.62 260.8,26.89 260.8,28.04 260.93,28.16 264.6,28.16
+5VALW on BOTTOM (solid shape): 321.77,16.23 321.77,7.59 321.45,7.27 320.05,7.27 319.54,7.78 319.29,8.03 319.29,11 319.42,11.28 319.29,11.56 319.29,16.39 319.6,16.7 321.3,16.7
+5VALW on BOTTOM (solid shape): 62.1,17.91 62.1,17.41 62.33,17.18 62.34,17.18 62.35,17.17 62.43,17.12 62.52,17.1 62.54,17.1 63.25,16.38 63.25,16.33 63.99,15.6 63.99,14.78 63.93,14.71 60.54,14.71 59.4,15.86 59.4,17.47 59.54,17.62 60.19,17.62 60.32,17.48 60.32,16.79 60.54,16.57 60.96,16.57 61.11,16.72 61.11,17.79 61.38,18.05 61.96,18.05
+5VALW on BOTTOM (solid shape): 205.62,161.58 205.62,159.61 205.81,159.42 207.78,159.42 207.91,159.29 207.91,159.28 208.03,159.15 208.03,156.97 208.12,156.88 208.13,156.88 208.45,156.56 209.11,156.56 209.28,156.39 209.28,154.02 210.38,152.92 211.02,152.92 212.08,151.87 212.08,149.73 212.29,149.52 213.15,149.52 213.53,149.14 213.53,148.52 213.91,148.14 214.64,148.14 214.73,148.05 214.73,147.83 214.68,147.78 213.45,147.78 213.15,148.08 211.92,148.08 210.79,146.95 208.66,146.95 208.35,147.25 208.35,148.39 208.85,148.89 209.86,148.89 210.03,149.05 210.03,149.54 210.21,149.98 210.03,150.42 210.03,150.44 209.43,151.03 207.54,151.03 207.11,151.46 207.11,151.76 207.11,152.46 207.08,152.49 207.08,155.16 205.81,156.43 205.81,157.88 205.59,158.1 204.56,158.1 204.22,157.77 203.59,157.77 203.53,157.83 203.53,159.17 203.14,159.55 203.14,159.57 203.07,159.68 202.97,159.76 202.94,159.77 202.94,161.6 203.02,161.69 203.22,161.69 203.44,161.47 203.45,161.47 203.6,161.32 203.6,161.31 203.65,161.26 204.1,161.26 204.39,161.55 204.39,161.78 204.41,161.81 205.39,161.81
+5VALW on BOTTOM (solid shape): outline of 207 points within 177.73,67.79 203.15,79.47
+5VALW on BOTTOM (solid shape): outline of 419 points within 100.62,54.22 114.23,65.42
+5VALW on IN1 (solid shape): outline of 262 points within 101.13,54.85 112.48,67.61
+5VALW on IN1 (solid shape): outline of 2150 points within 39.01,13.38 65.08,45.97
+5VALW on IN2 (solid shape): 204.11,79.27 204.11,78.05 203.71,77.65 202.78,77.65 202.63,77.8 202.63,78.4 202.68,78.58 202.63,78.76 202.63,79.32 202.86,79.55 203.83,79.55
+5VALW on IN2 (solid shape): 203.71,72.14 203.71,71.88 203.71,71.87 203.68,71.72 203.71,71.58 203.71,71.57 203.71,71.24 203.71,71.24 203.68,71.09 203.71,70.94 203.71,70.93 203.71,68.86 202.95,68.1 202.19,68.1 202,68.29 202,69.18 202.64,69.82 202.64,72.19 202.7,72.24 203.61,72.24
+5VALW on IN2 (solid shape): outline of 192 points within 20.33,39.85 25.79,49.69
+5VALW on IN2 (solid shape): outline of 864 points within 260.66,13.87 320.84,28.11
+5VALW on IN2 (solid shape): outline of 2893 points within 37.35,14.59 64.98,45.82
+5VALW on IN2 (solid shape): outline of 7363 points within 108.92,62.3 222.72,182.98
+5VALW on IN4 (solid shape): outline of 97 points within 101.46,47.22 104.94,59.46
+5VALW on IN4 (solid shape): outline of 192 points within 223.21,22.64 227.72,33.31
+5VALW on IN4 (solid shape): outline of 318 points within 201.88,153.67 209.74,164.31
+5VALW on GND2: 181.7,165.19 180.08,165.19 169.93,175.34 169.93,176.16 169.92,176.16 168.89,177.19 152.8,177.19 151.86,176.24 151.86,168.05 148.34,164.54 148.34,156.02 144.12,151.8 125.76,151.8 120.79,146.82 120.79,85.53 117.42,82.17 117.42,69.93 111.39,63.9 111.39,62.87 110.84,62.33 108.5,62.33 106.94,63.89 106.94,68.09 112.1,73.25 112.1,85.92 115.01,88.83 115.01,160.78 115.74,161.51 140.94,161.51 142.25,162.82 142.25,166.41 144.56,168.72 146.82,169.87 147.2,172.38 147.2,180.6 148.3,181.71 173.01,181.71 175.14,179.57 175.14,177.53 181.58,171.1 182.17,171.1 182.18,171.09 188.71,171.09 189.29,171.67 191.97,171.67 195.72,167.93 195.72,164.52 199.94,160.3 205.52,160.3 209.37,156.45 209.37,154.12 208.82,153.57 208.33,153.57 207.7,154.21 199.11,154.21 199.11,154.21 197.39,154.21 190.15,161.45 189.1,161.45 185.35,165.2 181.71,165.2 ; 1 cut-out
+5VALW on VCC: 148.98,176.65 149.72,177.39 149.74,177.39 150.44,178.09 174.34,178.09 176.88,175.55 178.66,175.55 181.07,173.13 187.14,173.13 188.22,174.21 190.19,174.21 191.27,173.13 196.27,173.13 198.87,175.74 205.01,175.74 205.37,175.38 205.37,169.81 202.66,167.1 179.5,167.1 175.19,171.42 149.53,171.42 148.98,171.97
+5VALW on VCC: 47.25,42.64 47.25,50.48 47.64,50.37 48.04,50.33 63.85,50.33 64.35,50.83 65.15,50.83 65.15,50.83 88.37,50.83 89.9,51.47 90.54,53 90.54,57.1 91.22,58.75 92.87,59.43 97.62,59.43 98.72,59.73 99.52,60.55 99.98,60.55 102.94,57.58 102.94,50.68 94.9,42.64
+5VALW on VCC: outline of 110 points within 16.01,1.17 334.15,56.33
+5VALWP on TOP (solid shape): 44.62,43.85 45.37,43.85 45.37,44.38 45.82,44.38 45.82,43.85 46.52,43.85 46.52,42.48 46.32,42.28 45.48,42.28 45.48,42.28 44.72,42.28 44.72,42.28 44.44,42.28 43.94,41.78 43.28,41.78 42.93,41.43 42.93,40.55 42.62,40.23 37.85,40.23 36.97,41.12 36.97,43.15 43.24,43.15 43.41,43.32 43.41,43.75 43.51,43.85 44.17,43.85 44.17,44.38 44.62,44.38
+5VALWP on BOTTOM (solid shape): outline of 508 points within 36.39,38.32 47.48,46.45
+5VS on TOP (solid shape): 184.73,147.23 184.1,146.59 183.78,146.59 183.4,146.21 182.25,146.21 182,146.46 182,146.91 182.06,146.97 183.02,146.97 183.9,147.86 184.1,147.86
+5VS on TOP (solid shape): 108.15,29.05 108.15,26.64 107.58,26.07 104.85,26.07 104.76,26.15 104.76,29.15 104.9,29.28 107.92,29.28
