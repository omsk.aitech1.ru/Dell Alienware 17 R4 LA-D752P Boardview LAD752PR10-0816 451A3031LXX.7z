# Allegro board LAD752PR10-0816.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PSID-3: length 3.1
  TOP w0.107: PR4.1 v2(276.47,37.55)
  TOP w0.254: PR4.1 274.87,37.05 PQ7.3
PWM1: length 51.3
  TOP w0.107: v1(274.98,61.78) v2(274.98,62.49)
  TOP w0.254: PR6009.1 282.7,56.48 282.15,55.94 v1(282.14,55.94)
  IN1 w0.254: v1(246.76,55.21) 246.93,55.21 247.28,55.56 247.28,58.57 247.65,58.93 263.53,58.93 265.55,60.95 273.45,60.95 274.28,61.78 v1(274.98,61.78)
  IN3 w0.254: v1(282.14,55.94) 279.71,53.51 277.72,53.51 277.36,53.87 277.36,56.34 275.47,58.23 275.47,61.53 275.22,61.78 v1(274.98,61.78)
  BOTTOM w0.203: PU6102.4 247,55.1 246.89,55.21 v1(246.76,55.21) ; PU8201.31 v1(282.14,55.94)
PWM1_GT: length 24.9
  IN1 w0.254: v1(140.79,149.96) 140.66,149.96 140.47,150.15 140.03,150.15 139.14,149.26 139.14,148.24 138.57,147.67 138.57,147 137.52,145.96 131.77,145.96 131.33,145.51 129.74,145.51 129.42,145.19 129.42,144.88 128.47,143.92 123.24,143.92 v1(123.02,144.14)
  BOTTOM w0.107: v1(140.79,149.96) 140.52,149.96 v2(140.06,150.42)
  BOTTOM w0.203: PU500.12 123.2,143.28 123.02,143.46 v1(123.02,144.14)
  BOTTOM w0.254: v1(140.79,149.96) 140.79,150.15 141.2,150.56 PR590.2
PWM1_VCORE: length 35.9
  IN2 w0.254: v1(132.22,147.92) 133.09,147.92 133.28,148.11 135.34,148.11 135.72,148.5 137.99,148.5 141.36,151.86 154.69,151.86 157.55,149 157.55,148.03 v1(157.6,147.99)
  BOTTOM w0.203: PU500.25 129.88,143.28 130.22,143.63 130.22,144 130.87,144.65 130.87,145.94 131.96,147.03 131.96,147.67 v1(132.22,147.92)
  BOTTOM w0.254: v1(157.6,147.99) 157.4,147.8 PR552.2
PWM2: length 60.5
  TOP w0.107: v1(282.1,54.19) 281.63,54.67 v2(280.26,54.67)
  TOP w0.254: v1(282.1,54.19) 282.61,54.71 PR6016.1
  IN1 w0.254: v1(282.1,54.19) 280.98,54.19 279.1,56.06 277.19,56.06 276.01,57.25 276.01,61.84 275.35,62.49 266.55,62.49 263.37,59.32 239.16,59.32 238.69,58.85 238.69,55.56 238.35,55.21 v1(238.2,55.21)
  BOTTOM w0.203: v1(238.2,55.21) 238.32,55.21 238.43,55.11 PU6201.4 ; v1(282.1,54.19) 282.25,54.34 282.25,54.55 282.84,55.14 PU8201.29
PWM2_GT: length 31.7
  IN1 w0.254: v1(149.23,150.72) 149.01,150.95 144.51,150.95 143.9,150.34 141.47,150.34 141.25,150.56 139.9,150.56 138.69,149.35 138.69,148.43 138.18,147.93 138.18,147.16 137.36,146.34 131.55,146.34 131.11,145.89 129.36,145.89 128.91,145.45 128.91,145.19 128.16,144.43 v1(123.53,144.43)
  BOTTOM w0.203: PU500.13 124.27,144.43 124.13,144.58 123.67,144.58 v1(123.53,144.43)
  BOTTOM w0.254: PR591.2 149.37,150.59 v1(149.23,150.72)
PWM2_VCORE: length 43
  IN1 w0.254: v1(130.5,143.1) 130.75,143.35 131.2,143.35 131.83,143.99 132.85,143.99 134.44,145.57 137.87,145.57 138.95,146.65 139.58,146.65 140.28,147.35 140.28,148.62 141.61,149.96 146.09,149.96 146.34,150.21 156.28,150.21 157.11,149.38 160.06,149.38 162.53,146.91 164.94,146.91 v1(165.04,147.01)
  BOTTOM w0.107: v2(165.93,148.55) PR563.2
  BOTTOM w0.203: v1(130.5,143.1) 130.37,142.97 129.99,142.97 129.9,142.88 PU500.26
  BOTTOM w0.254: PR563.2 165.3,147.27 v1(165.04,147.01)
PWM3: length 67
  TOP w0.107: v1(282.43,55.37) 281.79,55.37 v2(281.56,55.61)
  TOP w0.254: v1(282.43,55.37) 282.64,55.58 PR6084.1
  IN1 w0.254: v1(229.62,55.21) 229.82,55.21 230.11,55.51 230.11,58.29 231.54,59.72 263.24,59.72 266.39,62.87 275.51,62.87 276.39,62 276.39,57.42 277.34,56.47 279.24,56.47 280.34,55.37 v1(282.43,55.37)
  BOTTOM w0.203: v1(282.43,55.37) 282.59,55.54 PU8201.30 ; v1(229.62,55.21) 229.75,55.21 229.86,55.11 PU6202.4
PWM3_VCORE: length 50.3
  IN1 w0.254: v1(131.13,142.85) 131.43,142.85 132.06,143.48 132.91,143.48 134.63,145.19 138.12,145.19 139.07,146.15 139.71,146.15 140.66,147.1 140.66,148.43 141.8,149.57 146.25,149.57 146.45,149.78 156.02,149.78 156.79,149 159.9,149 162.4,146.5 172.75,146.5 v1(173.55,147.3)
  BOTTOM w0.203: PU500.27 130.01,142.48 130.12,142.59 130.82,142.59 131.07,142.85 v1(131.13,142.85)
  BOTTOM w0.254: PR573.2 173.58,147.28 v1(173.55,147.3)
PWM4: length 73.8
  TOP w0.107: v1(282.15,53.58) 281.66,53.58 v2(281.4,53.84)
  TOP w0.254: PR6023.1 282.53,53.58 v1(282.15,53.58)
  IN1 w0.254: v1(282.15,53.58) 282.15,50.21 281.62,49.68 279.12,49.68 278.65,50.15 275.84,50.15 274.85,51.14 272.55,51.14 271.75,51.94 267.55,51.94 267.08,51.47 257.67,51.47 257.45,51.68 230.72,51.68 229.45,52.95 222,52.95 221.57,53.38 221.57,55.9 221.26,56.21 v1(220.93,56.21)
  BOTTOM w0.203: PU8201.28 282.93,54.74 282.58,54.38 282.58,54.01 v1(282.15,53.58) ; v1(220.93,56.21) 221.06,56.21 221.16,56.1 PU6301.4
PWM_SA: length 63.8
  IN3 w0.254: v1(130.88,138.78) 134.51,138.78 135.3,139.57 135.3,144.66 135.84,145.19 138.56,145.19 140.66,147.29 140.66,148.4 142.34,150.08 143.93,150.08 145.68,151.83 154.66,151.83 157.51,148.98 163.86,148.98 165.94,146.9 168.97,146.9 169.49,147.42 171.14,147.42 172.22,146.34 174.32,146.34 174.43,146.45 v1(180.6,146.45)
  BOTTOM w0.203: v1(130.88,138.78) 130.56,138.78 130.06,139.28 PU500.35
  BOTTOM w0.254: PR5001.1 180.92,146.14 v1(180.6,146.45)
PWM_VDDCI: length 20.6
  IN4 w0.254: v1(281.25,52.39) 280.97,52.39 279.92,51.34 270.39,51.34 269.35,52.38 268.48,52.38 266.84,54.03 v1(266.84,54.18)
  BOTTOM w0.203: v1(281.25,52.39) 282.11,52.39 PR6061.1 282.91,53.14 282.91,54.13 283.11,54.34 PU8201.27 ; v1(266.84,54.18) 266.96,54.18 267.07,54.08 PU6400.4
PWR_B#: length 17.4
  TOP w0.107: v1(210.16,171.09) 210.38,171.09 211.82,169.65 JPWR.4 ; RE160.1 202.99,174.63 202.27,174.63 RE154.2 201.91,173.92 201.94,173.9 QE13.3 201.94,172.11 201.5,171.68 201.5,170.6 201.76,170.35 v2(202.7,170.35) 203.15,170.35 v1(203.65,170.85)
  IN4 w0.097: v1(203.65,170.85) 209.69,170.85 209.93,171.09 v1(210.16,171.09)
PWR_B_7313#: length 38.7
  TOP w0.254: UE3.17 216.81,153.49 216.33,153 v2(215.81,153) 215.43,153 v1(215.18,153.24)
  TOP w0.508: QE13.4 v1(201.94,170.78)
  IN1 w0.508: v1(201.94,170.78) 202.83,170.78 203.41,170.2 204.66,170.2 206.45,168.42 206.45,165.9 207.79,164.56 207.79,160.36 205.14,157.71 205.14,154.69 209.93,149.9 213.75,149.9 215.38,151.52 215.38,153.05 v1(215.18,153.24)
PWR_B_EC: length 268.1
  TOP w0.107: v1(328.43,42.64) 328.68,42.64 328.87,42.45 UE6.22 ; QE13.2 202.59,172.75 v1(202.52,172.69)
  IN2 w0.091: v1(328.43,42.64) 328.56,42.64 328.88,42.96 328.88,45.18 327.2,46.85 319.03,46.85 316.94,48.95 310.1,48.95 309.83,48.67 299.22,48.67 296.84,46.3 295,46.3 294.34,45.64 282.2,45.64 279.91,47.93 279.91,60.97 274.01,66.88 266.92,66.88 266.77,66.72 249.72,66.72 249.53,66.91 224.27,66.91 224.12,66.76 223.99,66.76 223.87,66.64 223.47,66.25 213.58,66.25 212.51,65.18 207.72,65.18 205.65,67.25 200.85,67.25 200.16,67.94 200.16,70.52 199.95,70.73 199.95,71.89 200.12,72.06 200.26,72.06 200.76,72.56 200.76,77.1 201.03,77.37 201.03,95.77 200.59,96.21 200.59,109.07 198.4,111.27 198.4,144.51 193.67,149.23 193.67,159.71 196.13,162.16 196.13,162.97 198.33,165.17 198.33,166.37 199.56,167.61 201.4,167.61 202.8,169.02 202.8,170.88 202.99,171.06 202.99,172.27 202.57,172.69 v1(202.52,172.69)
PWR_G#: length 21.4
  TOP w0.107: JPWR.3 211.32,167.19 210.61,167.9 205.15,167.9 v2(204.92,167.67) 201.37,167.67 200.61,168.43 200.61,170.09 200.29,170.4 199.53,170.4 199.02,170.92 199.02,172.33 RE156.2 198.41,173.24 198.52,173.35 QE21.3 199.46,173.65 199.65,173.84 200.07,173.84 RE155.1
PWR_G_7313#: length 41.4
  TOP w0.254: v1(215.17,153.93) 214.99,154.11 v2(214.99,154.46) 215.36,154.83 UE3.16
  TOP w0.432: QE21.4 199.46,172.3 v1(199.47,172.3)
  IN1 w0.508: v1(215.17,153.93) 214.97,153.93 214.46,153.42 214.46,152.9 214.74,152.62 214.74,151.79 213.49,150.53 210.2,150.53 205.77,154.95 205.77,157.44 208.42,160.09 208.42,164.82 207.08,166.16 207.08,168.68 204.29,171.47 199.83,171.47 199.48,171.82 199.48,172.29 v1(199.47,172.3)
PWR_G_EC: length 282
  TOP w0.107: v1(199.92,172.72) 200.11,172.9 QE21.2 ; UE6.10 334.39,42.95 335.19,42.15 v1(335.19,42.07)
  IN2 w0.091: v1(199.92,172.72) 200.3,173.09 203.4,173.09 203.64,172.85 203.64,171.4 203.02,170.78 203.02,168.93 201.49,167.39 199.66,167.39 198.55,166.28 198.55,165.08 196.35,162.88 196.35,162.07 193.89,159.61 193.89,149.32 198.61,144.6 198.61,111.36 200.81,109.16 200.81,96.3 201.25,95.86 201.25,77.59 201.58,77.26 201.58,75.72 201.48,75.62 201.48,72.09 200.54,71.15 200.54,67.86 200.94,67.47 205.74,67.47 207.81,65.39 212.42,65.39 213.49,66.47 223.38,66.47 223.81,66.9 223.81,66.9 223.9,66.98 224.03,66.98 224.18,67.13 249.62,67.13 249.81,66.94 266.67,66.94 266.83,67.1 274.1,67.1 280.13,61.07 280.13,48.02 282.29,45.86 294.25,45.86 294.91,46.51 296.75,46.51 299.16,48.93 309.77,48.93 310.01,49.17 317.03,49.17 318.96,47.23 330.38,47.23 333.45,44.16 333.45,41.18 334.36,40.27 334.69,40.27 335.19,40.77 v1(335.19,42.07)
PWR_LED#: length 53.7
  TOP w0.203: UE5.92 303.94,9.22 303.73,9.43 v1(303.72,9.43)
  TOP w0.432: v1(323.92,44.16) 323.88,44.16 323.29,44.76 QE4.2
  IN3 w0.508: v1(303.72,9.43) 303.72,9.89 304.6,10.77 315.23,10.77 316.11,11.65 316.11,13.72 318.66,16.26 318.66,17.41 319.53,18.29 319.53,25.97 325.96,32.4 325.96,41.43 324.97,42.42 324.63,42.42 323.92,43.12 v1(323.92,44.16)
PWR_R#: length 14
  TOP w0.107: RE157.1 205.49,174.54 204.54,174.54 RE158.2 204.31,173.95 204.41,173.85 QE22.3 204.02,172.95 204.02,172.56 203.78,172.32 203.78,171.36 204.13,171.01 204.13,170.56 204.29,170.4 v2(204.61,170.4) 204.99,170.4 205.46,170.87 209.7,170.87 209.98,170.59 210.13,170.59 210.82,169.91 JPWR.2
PWR_R_7313#: length 34.8
  TOP w0.254: UE3.15 215.33,155.33 214.93,154.94 214.89,154.94 214.46,154.51 214.46,152.5 v1(214.11,152.14)
  TOP w0.432: QE22.4 204.41,172.06 204.29,172.18 v1(204.29,172.25)
  IN1 w0.508: v1(214.11,152.14) 213.83,151.86 209.77,151.86 207.02,154.61 207.02,156.88 209.22,159.08 209.22,165.1 207.72,166.61 207.72,168.94 204.58,172.08 204.48,172.08 204.44,172.12 204.42,172.12 v1(204.29,172.25)
  BOTTOM w0.109: v1(204.29,172.25) 204.23,172.3 v2(204.23,172.76)
PWR_R_EC: length 276.6
  TOP w0.107: v1(334.52,40.67) 334.52,40.42 334.15,40.04 332.75,40.04 332.54,40.25 UE6.6 ; v1(204.73,172.69) 205.06,173.02 QE22.2
  IN2 w0.091: v1(204.73,172.69) 204.73,169.33 202.58,167.18 199.75,167.18 198.76,166.19 198.76,164.99 196.56,162.79 196.56,161.98 194.11,159.52 194.11,149.41 198.83,144.69 198.83,111.45 201.03,109.26 201.03,96.39 201.47,95.95 201.47,77.68 201.8,77.35 201.8,75.63 201.7,75.53 201.7,71.99 200.76,71.05 200.76,68.27 201.34,67.69 205.83,67.69 207.9,65.61 212.33,65.61 213.4,66.68 223.29,66.68 223.76,67.15 223.8,67.2 223.94,67.2 224.09,67.35 249.71,67.35 249.9,67.16 266.58,67.16 266.74,67.31 274.19,67.31 280.35,61.16 280.35,48.11 282.38,46.07 294.16,46.07 294.82,46.73 296.66,46.73 299.07,49.15 309.68,49.15 309.92,49.38 317.24,49.38 319.16,47.47 330.46,47.47 333.67,44.26 333.67,41.53 v1(334.52,40.67)
PWR_SRC_ON: length 5.3
  BOTTOM w0.107: QV1.3 160.4,168.69 160.56,168.54 160.56,168.12 160.66,168.01 CV15.2 RV9.2 160.66,166.47 159.75,165.56 159.75,164.96 RV12.1
PWR_VGA_CORE_BOOT1: length 1.3
  TOP w0.107: PR8205.2 v2(276.17,153.26)
PWR_VGA_CORE_BOOT1_1:
  vias: v2(273.69,154.53)
PWR_VGA_CORE_BOOT2: length 5.2
  TOP w0.107: v2(275.65,160.64) 275.79,160.5 276.35,159.94 276.41,159.94 v1(276.41,159.92)
  TOP w0.203: PU8200.15 276.84,159.5 v1(276.41,159.92)
  BOTTOM w0.508: v1(276.41,159.92) 276.68,159.92 277.88,161.13 PR8207.2
PWR_VGA_CORE_BOOT2_1: length 1.3
  BOTTOM w0.107: PC8213.2 v2(274.07,162.21)
PWR_VGA_CORE_LGATE1: length 10.5
  IN4 w1.016: 273.76,157.45 271.92,159.29 266.96,159.29 264.87,157.19
  vias: v1(264.99,156.24) v1(264.99,155.61) v1(274.58,156.94) v1(275.22,156.94) v2(264.68,157)
PWR_VGA_CORE_LGATE2: length 10.9
  TOP w0.203: PU8200.17 275.35,158.02
  IN4 w1.016: 273.76,160.12 272.49,161.39 271.15,161.39 267.41,165.13 266.07,165.13 265.82,164.88
  vias: v1(265.18,165.2) v1(265.18,164.56) v1(274.11,159.34) v1(274.53,158.91) v2(264.68,164.62)
PWR_VGA_CORE_PHASE1: length 6.6
  TOP w0.107: v2(265.31,154.91) 265.69,155.29 v1(265.95,155.29)
  IN4 w1.016: 269.5,157.45 271.47,157.45 273.57,155.35 274.41,155.35
  vias: v1(265.95,155.92) v1(266.58,156.56) v1(266.58,155.92) v1(266.58,155.29) v1(267.22,156.56) v1(267.22,155.92) v1(267.22,155.29) v1(267.85,156.56) v1(267.85,155.92) v1(267.85,155.29) v1(268.49,156.56) v1(268.49,155.92) v1(268.49,155.29) v1(269.12,155.92) v1(269.12,155.29) v1(275.41,155.61) v1(275.79,156.05)
PWR_VGA_CORE_PHASE2: length 12.7
  TOP w0.107: v1(270.65,172.43) 271.28,172.43 v2(271.41,172.56)
  IN4 w1.016: 268.42,169.64 268.42,166.66 272.11,162.97 273.06,162.97 274.96,161.07
  vias: v1(267.79,170.47) v1(268.42,170.47) v1(269.38,172.43) v1(269.38,171.8) v1(269.38,171.16) v1(269.38,170.53) v1(270.01,172.43) v1(270.01,171.8) v1(270.01,171.16) v1(270.01,170.53) v1(270.65,171.8) v1(270.65,171.16) v1(270.65,170.53) v1(274.95,160.08) v1(275.59,160.08)
PWR_VGA_CORE_SS: length 2.7
  TOP w0.107: PC8216.1 279.6,160.48 v2(279.97,160.85)
  TOP w0.203: PU8200.11 278.44,159.59 279.03,160.18 PC8216.1
PWR_VGA_CORE_TON: length 3.4
  TOP w0.203: PU8200.9 279.86,158.02 280.22,158.38 280.22,159.3 280.21,159.32 v2(280.21,159.37) 280.21,159.56 280.46,159.81 PR8202.1
PWR_VGA_CORE_TON_1: length 3
  TOP w0.107: PR8201.1 282,162.02 v2(281.44,162.58)
  TOP w0.254: PR8201.1 PC8205.1 PR8202.2
PWR_VGA_CORE_UGATE1: length 7.7
  TOP w0.107: v1(270.77,156.31) 271.47,155.61 v2(271.47,155.54)
  TOP w0.203: v1(277.12,154.97) 277.24,155.09 PU8200.2
  IN4 w1.016: 271.28,155.8 271.28,155.42 272.8,153.89 275.79,153.89
  vias: v1(270.14,156.31) v1(277.06,154.34)
PWR_VGA_CORE_UGATE2: length 5.1
  IN4 w1.016: 272.23,164.94 273.69,164.94 276.3,162.34
  vias: v1(271.22,165.83) v1(271.22,165.2) v1(276.36,160.88) v1(276.93,161.07) v2(277.06,160.56)
PWRSHARE_EN_EC#: length 307.8
  TOP w0.107: UE5.119 308.31,18.61 v1(308.47,18.78) ; v1(25.41,44.23) 25.01,43.83 UU1.5
  IN2 w0.091: v1(25.41,44.23) 25.79,44.23 29.02,47.47 29.85,47.47 30.48,48.09 33.74,48.09 34.87,46.95 49.19,46.95 49.99,47.76 55.63,47.76 55.64,47.77 57.47,47.77 58.27,46.98 94.69,46.98 95.28,46.38 97.97,46.38 99.04,45.32 106.05,45.32 109.66,41.72 111.05,41.72 113.2,39.56 173.29,39.56 174.3,38.55 180.08,38.55 183.81,42.28 197.41,42.28 199.12,43.99 202.82,43.99 202.82,43.99 206.95,43.99 207.04,44.08 213.39,44.08 213.77,43.69 214.45,43.69 214.68,43.47 222.46,43.47 223.17,42.76 227.13,42.76 227.49,42.4 233.22,42.4 233.91,41.71 262.26,41.71 267.83,36.13 269.03,36.13 273.89,31.27 281.21,31.27 285.65,26.83 290.9,26.83 293.07,24.66 306.97,24.66 v1(307.86,23.78)
  BOTTOM w0.107: v1(308.47,18.78) 308.47,21.39 307.86,22 v1(307.86,23.78)
PX_EN: length 1.2
  TOP w0.089: TV1.1 220.7,103.82 v1(220.7,103.41)
  BOTTOM w0.089: v1(220.7,103.41) 220.82,103.29 UG1.V40
R16M_ID: length 24.8
  BOTTOM w0.089: UH1.AK45 209.07,17.77 209.2,17.63 209.2,16.9 209.65,16.45 210.78,16.45 212.03,15.2 212.03,15.16
  BOTTOM w0.107: 212.03,15.16 212.03,13.27 211.54,12.78 210.53,12.78 209.56,11.81 v2(208.19,11.81) 207.59,11.81 206.88,11.1 204.05,11.1 203.49,10.53 199.46,10.53 198.01,11.99 198.01,13.57 198.15,13.71 RH29.1 RH30.1
REGN_CHG: length 17.7
  TOP w0.203: v1(60.71,21.49) 60.55,21.49 60.22,21.83 PU700.24
  TOP w0.254: v1(53.67,26.32) 53.67,27.02 v2(53.92,27.27) 54.3,27.65 55.7,27.65 55.96,27.39 PR714.1
  IN3 w0.254: v1(53.67,26.32) 53.67,26.58 53.98,26.89 54.62,26.89 55.34,26.17 55.34,25.23 55.63,24.95 57.85,24.95 58.28,24.52 59.15,24.52 60.71,22.96 v1(60.71,21.49)
  BOTTOM w0.254: PC710.1 59.91,21.37 60.04,21.49 v1(60.71,21.49)
REMOTE1+: length 217.6
  IN3 w0.254: v1(138.38,127.1) 138.25,127.22 131.04,127.22 129.73,125.91 129.73,113.53 130.25,113.02 130.25,104.85 128.28,102.88 128.28,101.89 126.57,100.18 126.57,99.74 119.33,92.49 119.33,76.85 107.2,64.72 107.2,56.42 106.83,56.05 106.83,53.05 107.65,52.23 107.65,36.47 108.66,35.47 109.25,35.47 110.12,34.6 v1(110.12,34.51)
  BOTTOM w0.254: v1(110.12,34.51) 110.12,34.56 110.33,34.77 113.17,34.77 113.8,35.4 141.11,35.4 142.31,34.2 178.02,34.2 181.87,38.05 181.87,50.96 182.57,51.66 182.57,54.52 183.27,55.21 185,55.21 C2502.1 185.69,52.65 185.69,52.64 U2407.2 ; v1(138.38,127.1) 141.1,127.1 141.17,127.16 141.69,127.68 C2500.1 141.94,128.69 Q2407.2 141.29,130.29 Q2407.1
REMOTE1-: length 213.9
  IN3 w0.254: v1(109.48,34.51) 109.04,34.96 108.45,34.96 107.14,36.26 107.14,52.02 106.32,52.84 106.32,56.26 106.69,56.63 106.69,64.93 118.82,77.06 118.82,92.71 126.06,99.95 126.06,100.39 127.77,102.1 127.77,103.09 129.8,105.12 129.8,112.74 129.23,113.32 129.23,126.12 130.83,127.73 v1(138.38,127.73)
  BOTTOM w0.254: v1(109.48,34.51) 109.48,34.64 110.12,35.27 112.96,35.27 113.59,35.91 141.32,35.91 142.52,34.7 177.81,34.7 181.36,38.26 181.36,51.17 182.06,51.87 182.06,54.73 183.06,55.72 185.4,55.72 C2502.2 R184.1 ; Q2407.3 140.64,128.56 C2500.2 140.77,127.86 140.52,127.6 138.5,127.6 v1(138.38,127.73)
REMOTE2+: length 142.5
  TOP w0.254: v1(281.52,42.66) 281.44,42.73 281.44,46.45 279.28,48.61 279.28,60.89 276.85,63.32 v2(276.85,63.81) 276.85,66.69 Q2408.1 277.65,67.49 Q2408.2 277.65,69.63 C2505.1
  IN4 w0.254: v1(190.25,50.63) 190.59,50.63 192.86,48.36 198.81,48.36 203.27,52.82 206.86,52.82 209.39,50.29 209.39,47.89 209.94,47.34 216.69,47.34 217.45,46.57 219.63,46.57 219.89,46.83 227.02,46.83 227.21,47.02 229.75,47.02 233.68,43.09 234.45,43.09 235.47,42.07 235.47,41.43 236.86,40.04 256.89,40.04 257.84,40.99 268.11,40.99 270.65,38.45 279.33,38.45 281.44,40.56 281.44,42.58 v1(281.52,42.66)
  BOTTOM w0.254: v1(190.25,50.63) 190.18,50.71 189.47,50.71 188.35,51.83 188.35,53.16 187.82,53.69 187.65,53.69 C2504.1 187.22,53.27 186.69,52.74 U2407.4
REMOTE2-: length 143.2
  TOP w0.254: v1(280.93,42.66) 280.93,46.24 278.77,48.4 278.77,60.68 276.35,63.11 Q2408.3 276.35,69.75 C2505.2
  IN4 w0.254: v1(280.93,42.66) 280.93,40.77 279.12,38.96 270.86,38.96 268.32,41.5 257.63,41.5 256.68,40.55 237.07,40.55 235.97,41.64 235.97,42.28 234.66,43.59 233.9,43.59 229.96,47.53 227,47.53 226.81,47.34 219.68,47.34 219.42,47.08 217.66,47.08 216.9,47.85 210.15,47.85 209.9,48.1 209.9,50.5 207.07,53.33 203.06,53.33 198.6,48.87 193.07,48.87 190.72,51.21 v1(190.25,51.21)
  BOTTOM w0.254: v1(190.25,51.21) 189.68,51.21 188.86,52.04 188.86,53.37 187.71,54.52 R184.2 186.68,54.52 186.35,54.2 186.35,53.84 186.6,53.58 C2504.2 186.19,53.14 186.19,51.68 U2407.3
REMOTE3+: length 116.5
  IN4 w0.254: v1(190.25,49.82) 190.32,49.75 190.75,49.75 192.65,47.85 199.02,47.85 203.48,52.31 206.65,52.31 208.88,50.08 208.88,47.45 209.5,46.83 216.48,46.83 217.24,46.07 219.84,46.07 220.1,46.32 228.67,46.32 236.63,38.36 240.57,38.36 241.56,37.37 265.08,37.37 265.75,36.7 270.18,36.7 270.58,36.29 286,36.29 286.25,36.54 v1(286.25,36.99)
  BOTTOM w0.254: Q2411.1 286.14,34.37 Q2411.2 285.49,35.7 C2511.1 286.25,36.46 286.25,36.98 v1(286.25,36.99) ; v1(190.25,49.82) 190.21,49.77 188.68,49.77 C2510.1 187.87,49.98 187.19,50.65 U2407.5
REMOTE3-: length 113.5
  IN4 w0.254: v1(190.25,49.23) 190.55,49.23 192.44,47.34 199.23,47.34 203.69,51.8 206.44,51.8 208.37,49.87 208.37,47.24 209.29,46.32 216.27,46.32 217.03,45.56 220.05,45.56 220.31,45.82 228.46,45.82 236.42,37.85 240.36,37.85 241.35,36.86 264.87,36.86 265.54,36.19 269.97,36.19 270.37,35.78 286.31,35.78 286.84,36.31 v1(286.84,36.98)
  BOTTOM w0.254: v1(286.84,36.98) 286.75,36.9 286.75,36.38 C2511.2 286.91,35.59 286.79,35.47 Q2411.3 ; R185.2 C2510.2 188.68,49.26 190.22,49.26 v1(190.25,49.23)
RESET#: length 3
  BOTTOM w0.107: RV200.1 CV67.1 216.72,152.05 216.54,152.23 v2(216.54,152.47) 216.54,152.71 216.76,152.93 U1.35
RESET_N: length 2.6
  BOTTOM w0.076: 203.72,162.53 203.44,162.53 203.4,162.57 UT4.F11
  BOTTOM w0.107: RT102.1 205.04,162.91 204.42,162.91 204.05,162.53 203.72,162.53 203.72,162.53
RF_+1VALWP: length 3.5
  TOP w0.254: PR306.1 251.85,18.32 251.02,19.15 v2(250.71,19.15) 249.37,19.15 249.11,19.4 PU300.5
RING2: length 14.5
  IN1 w1.016: 24.58,30.7 22.58,28.7 22.58,25.49 23.63,24.44 26.65,24.44 27.86,23.23 27.86,20.99
  vias: v1(26.15,31.08) v1(26.62,30.73) v1(28.45,20.17) v1(29.09,20.16) v2(29.54,20.48)
RING2_R: length 33.1
  IN1 w1.016: 27.42,18.56 26.81,19.17 24.55,19.17 23.08,20.63 21.75,20.63 ; JACK1.4 5.67,3.72 6.69,2.7 14.74,2.7 17.15,5.11 17.15,13.11 17.31,13.27 17.31,15.3 18.33,16.33 18.33,17.76
  vias: v1(18.4,18.51) v1(18.98,18.51) v1(21.31,19.74) v1(21.89,19.74) v1(27.44,17.49) v1(28.01,17.75) v2(27.5,19.15)
RJ45_CT: length 13.4
  TOP w0.254: v1(254.14,161) 252.99,162.15 RL12.2 RL11.2 252.8,160.88 253.06,160.62 v2(253.06,158.91) 253.06,154.97 252.61,154.53 RL10.2 RL9.2
RJ45_CT0: length 2.9
  TOP w0.127: v2(249.63,162.47) 249.96,162.13 v1(250.22,162.13)
  TOP w0.508: RL12.1 250.99,162.13 v1(250.22,162.13)
  BOTTOM w0.508: TL1.15 v1(250.22,162.13)
RJ45_CT1: length 3
  TOP w0.127: v1(250.2,160.88) v2(249.44,160.88)
  TOP w0.508: RL11.1 v1(250.2,160.88)
  BOTTOM w0.508: TL1.16 250.28,160.86 250.26,160.88 v1(250.2,160.88)
RJ45_CT2: length 3
  TOP w0.127: v2(249.63,154.85) 249.96,154.51 v1(250.2,154.51)
  TOP w0.508: v1(250.2,154.51) 251,154.51 RL10.1
  BOTTOM w0.508: TL1.21 250.28,154.51 250.28,154.51 v1(250.2,154.51)
RJ45_CT3: length 3
  TOP w0.127: v1(250.21,153.19) v2(249.51,153.19)
  TOP w0.508: v1(250.21,153.19) 250.34,153.32 RL9.1
  BOTTOM w0.508: v1(250.21,153.19) 250.26,153.24 TL1.22
RJ45_MDI0+: length 19.2
  IN4 w0.216: v1(249.39,164.39) 249.86,164.39 250.52,163.73 250.52,163.09 249.9,162.47 249.62,162.19 247.96,162.19 247.06,163.08 247.06,165.55 250.23,168.72 250.23,169.02 249.39,169.87 249.39,171.51 JLAN.1
  BOTTOM w0.254: TL1.13 251.01,164.67 250.52,164.18 249.6,164.18 v1(249.39,164.39)
RJ45_MDI0-: length 19.2
  IN4 w0.216: JLAN.2 250.66,170.79 250.48,170.97 250.11,170.97 249.73,170.59 249.73,170.01 250.57,169.17 250.57,168.58 247.4,165.41 247.4,163.23 248.1,162.53 249.47,162.53 250.17,163.23 250.17,163.59 249.84,163.93 249.02,163.93 248.8,163.71 248.8,163.44 248.95,163.29 v1(249.37,163.29)
  BOTTOM w0.254: v1(249.37,163.29) 249.89,163.81 250.31,163.81 250.72,163.4 TL1.14
RJ45_MDI1+: length 22.4
  IN3 w0.203: JLAN.3 251.68,167.8 248.54,164.65 248.54,157.91 248.99,157.45 250.18,157.45 250.58,157.84 250.58,158.72 250.16,159.15 249.44,159.15 v1(249.34,159.25)
  BOTTOM w0.254: v1(249.34,159.25) 249.45,159.14 250.18,159.14 250.63,159.59 TL1.17
RJ45_MDI1-: length 22.4
  IN3 w0.203: v1(249.34,158.66) 249.5,158.82 250.02,158.82 250.25,158.59 250.25,157.98 250.05,157.78 249.13,157.78 248.87,158.04 248.87,164.51 252.01,167.66 252.01,169.5 252.22,169.7 254.71,169.7 254.9,169.89 254.9,170.51 JLAN.6
  BOTTOM w0.254: v1(249.34,158.66) 249.45,158.77 250.21,158.77 250.66,158.32 TL1.18
RJ45_MDI2+: length 27.1
  IN1 w0.216: JLAN.4 252.7,168.78 251.85,167.93 249.71,167.93 247.25,165.46 247.25,155.44 247.74,154.96 249.99,154.96 250.01,154.98 250.1,154.98 250.58,155.45 250.58,156.22 250.09,156.71 v1(249.38,156.71)
  BOTTOM w0.254: TL1.19 250.42,157.05 249.97,156.6 249.49,156.6 v1(249.38,156.71)
RJ45_MDI2-: length 27
  IN1 w0.216: v1(249.38,156.12) 249.46,156.12 249.7,156.36 249.95,156.36 250.24,156.08 250.24,155.59 249.96,155.32 249.86,155.32 249.85,155.3 247.88,155.3 247.6,155.58 247.6,165.32 249.86,167.58 251.99,167.58 253.04,168.64 253.04,169.76 253.58,170.3 253.58,171.03 253.46,171.15 253.46,171.55 253.68,171.77 JLAN.5
  BOTTOM w0.254: TL1.20 250.42,155.78 249.97,156.23 249.49,156.23 v1(249.38,156.12)
RJ45_MDI3+: length 30.9
  IN2 w0.203: JLAN.7 255.76,169.83 254.75,168.82 253.67,168.82 251.7,166.85 249.69,166.85 247.9,165.06 247.9,153.06 248.56,152.4 250.55,152.4 250.76,152.19 250.76,151.68 250.55,151.48 249.81,151.48 v1(249.66,151.63)
  BOTTOM w0.254: TL1.23 250.56,151.97 250.12,151.53 249.76,151.53 v1(249.66,151.63)
RJ45_MDI3-: length 30.9
  IN2 w0.203: JLAN.8 256.34,170.67 256.09,170.42 256.09,169.69 254.88,168.48 253.81,168.48 251.84,166.52 249.83,166.52 248.23,164.92 248.23,153.19 248.7,152.73 250.69,152.73 251.09,152.33 251.09,151.55 250.69,151.15 249.77,151.15 v1(249.66,151.04)
  BOTTOM w0.254: v1(249.66,151.04) 249.76,151.14 249.86,151.14 249.88,151.16 250.14,151.16 250.6,150.7 TL1.24
RPD_G1: length 3.5
  BOTTOM w0.076: 203.65,166.32 v2(203.53,166.32) 203.36,166.32 202.67,165.63 202.67,165.57 202.41,165.3 202.41,165.17 202.41,165.17 202.41,164.96 202.41,164.96 202.41,164.95 202.16,164.7 UT4.K9
  BOTTOM w0.127: RT64.1 203.84,166.51 203.65,166.32
RPD_G2: length 4.2
  BOTTOM w0.076: 203.49,165.66 203.31,165.48 203.22,165.48 202.91,165.17 202.91,164.89 202.66,164.64 UT4.K10
  BOTTOM w0.127: RT65.1 205.15,166.73 205.09,166.67 205.09,166.4 v2(204.85,166.16) 204.45,165.77 204.03,165.77 203.93,165.66 203.49,165.66
RST#: length 3.8
  TOP w0.107: CE55.2 331.99,39.22 v2(332.41,38.81) ; CE55.2 RE91.2 ; CE55.2 331.42,39.78 331.04,40.16 UE6.3
RT8812_PVCC: length 4.8
  TOP w0.107: v2(274.65,157.7) 274.77,157.58 v1(275.22,157.58)
  TOP w0.203: v1(275.22,157.58) 275.22,157.58 275.26,157.62 PU8200.18
  BOTTOM w0.508: v1(275.22,157.58) 274.33,157.58 274.27,157.51 PC8200.1 273.88,157 PR8200.1
RTD3_CIO_PWR_EN: length 188
  TOP w0.107: RT16.2 v1(171.71,163.51)
  IN2 w0.091: v1(195.33,69.46) 193.47,71.33 193.47,72.7 191.98,74.18 191.43,74.18 191.17,74.44 191.17,106.04 191.75,106.61 191.75,108.55 195.51,112.32 195.51,143.99 190.25,149.26 190.25,150.42 188.7,151.97 185.71,151.97 185.12,152.56 177.59,152.56 177.41,152.38 172.44,152.38 170.7,154.12 170.29,154.12 168.58,155.83 168.58,157.29 168.34,157.54 168.34,160.55 168.62,160.83 168.62,161.72 169.32,162.42 171.35,162.42 171.71,162.78 v1(171.71,163.51)
  IN3 w0.089: 198.74,42.08 198.74,39.69 199.14,39.29 200.4,39.29 200.94,38.76 200.94,37.49 201.43,36.99 201.43,34.38 200.9,33.86 200.9,32.9 200.48,32.48 200.47,32.48 200.38,32.38 200.38,27.4 201.07,26.71 201.07,24.26 201.7,23.64 202.35,23.64 203.16,22.83 204.1,22.83 205.76,21.17 207.13,21.17 207.34,21.37 207.34,21.62 207.62,21.9 208.01,21.9 208.16,21.75 208.16,21.12 208.36,20.92 208.36,20.5 208.65,20.21 208.65,19.74 208.93,19.46 209.34,19.46 209.97,18.83 v1(211.15,18.83)
  IN3 w0.091: v1(195.33,69.46) 194.6,69.46 193.77,68.63 193.77,59.02 194.33,58.46 194.33,56.86 193.77,56.3 193.77,54.51 196.33,51.95 196.33,50.74 198.74,48.33 198.74,42.08
  BOTTOM w0.089: v1(211.15,18.83) 211.34,18.63 UH1.AR44
RTD3_CIO_PWR_EN_R: length 6.9
  TOP w0.089: 175.47,167.52 175.49,167.54 UT1.F1
  TOP w0.107: RT16.1 RT36.1 172.15,164.5 172.15,164.78 173.19,165.83 174.12,165.83 174.12,165.83 174.45,165.83 174.76,166.14 v2(174.76,166.29) 174.76,166.96 175.32,167.52 175.47,167.52
RTD3_USB_PWR_EN: length 192
  TOP w0.107: RT12.2 168.53,166.19 v1(168.45,166.1)
  IN2 w0.091: v1(195.77,68.17) 195.2,68.17 192.81,70.57 192.81,71.26 190.52,73.55 190.52,93.12 189.67,93.97 189.67,97.44 190.2,97.97 190.2,105.99 190.26,106.05 190.26,107.99 194.86,112.59 194.86,143.72 187.28,151.3 185.46,151.3 184.85,151.91 177.87,151.91 177.68,151.72 172.17,151.72 170.44,153.46 169.2,153.46 166.25,156.41 166.25,159.59 167.96,161.3 167.96,164.99 167.67,165.28 167.67,165.61 168.15,166.1 v1(168.45,166.1)
  IN3 w0.089: 200.21,42.08 200.21,41.96 200.98,41.18 200.98,40.22 202.71,38.49 202.71,36.75 203.11,36.36 203.11,32.5 201.34,30.73 201.34,29 201.96,28.37 201.96,25.52 202.88,24.6 203.85,24.6 205.05,23.4 205.05,23.21 205.41,22.85 206.03,22.85 206.46,23.29 207.16,23.29 207.48,23.61 207.48,23.98 207.67,24.16 208.57,24.16 208.76,23.97 208.76,22.97 209.03,22.7 209.42,22.7 211.07,21.05 211.51,21.05 v1(212.2,20.37)
  IN3 w0.091: v1(195.77,68.17) 194.43,66.83 194.43,60.94 195.59,59.78 198.75,59.78 200.9,57.63 200.9,51.17 200.21,50.47 200.21,42.08
  BOTTOM w0.107: UH1.AR41 211.64,19.81 v1(212.2,20.37)
RTD3_USB_PWR_EN_R: length 12.7
  TOP w0.102: UT1.D4 177.4,168.36 v1(177.43,168.36)
  TOP w0.107: v1(168.65,165.49) RT37.1 169.31,165.54 169.9,166.12 RT12.1
  IN1 w0.097: v1(168.65,165.49) 169.02,165.49 170.11,166.58 170.9,166.58 171.71,165.77 173.14,165.77 174.05,166.68 175.71,166.68 177.37,168.34 177.41,168.34 v1(177.43,168.36)
SATA_DET#: length 3.3
  TOP w0.356: RS8.2 124.44,9.49 v2(123.58,9.49) 123.14,9.49 v1(122.56,8.92)
  BOTTOM w0.254: v1(122.56,8.92) 122.42,9.07 JHDD.19
SATA_GP0: length 306.7
  TOP w0.107: R364.1 236.28,7.87 v1(236.23,7.92) ; v1(100.81,13.46) 100.66,13.61 100.51,13.61 100.25,13.35 v2(100.25,12.73) 100.25,12.59 97.73,10.07 96.53,10.07 96.2,10.4 96.2,18.62 100.22,22.64 101.51,22.64 103.29,24.42 106.37,24.42 v1(109.55,27.59)
  IN4 w0.097: v1(206.83,21.69) 205.5,21.69 204.03,23.16 204.03,24 203.63,24.4 202.98,24.4 201.43,25.96 194.04,25.96 192.5,27.49 187.17,27.49 183.05,23.37 183.05,23.19 177.38,17.52 138.68,17.52 135.61,14.44 125.1,14.44 122.23,11.58 120.16,11.58 119.9,11.84 119.9,12.64 120.22,12.96 v1(120.57,12.96)
  BOTTOM w0.089: UH1.AG36 207.16,21.95 206.89,21.69 v1(206.83,21.69)
  BOTTOM w0.107: JSSD3.69 237.02,11.71 236.09,10.77 236.09,8.8 236.23,8.66 v1(236.23,7.92) 236.09,7.92 235.14,8.87 233.95,8.87 229.31,4.22 191.4,4.22 188.92,6.7 188.92,9.96 186.14,12.74 186.14,17.17 185.94,17.37 185.94,21.89 185.43,22.39 184.6,22.39 179.01,27.98 128.73,27.98 127.44,29.28 114.79,29.28 113.8,28.29 110.24,28.29 v1(109.55,27.59) ; v1(120.57,12.96) 119.66,13.88 110.14,13.88 107.99,16.02 105.3,16.02 104.66,15.37 104.66,14.6 104.06,14 101.35,14 v1(100.81,13.46)
SATA_GP1: length 135.5
  TOP w0.107: R363.1 327.38,31.26 v1(327.22,31.11)
  IN1 w0.097: v1(265.06,22.51) 265.63,23.08 268.3,23.08 268.42,22.96 279.63,22.96 281.8,20.8 296.23,20.8 298.4,22.96 301.05,22.96 302.08,21.94 310.27,21.94 313.91,25.58 314.95,25.58 319.42,30.05 325.62,30.05 326.67,31.11 v1(327.22,31.11)
  IN3 w0.089: v1(207.8,23.07) 207.8,22.93 208.7,22.03 208.7,21.47 209.06,21.1 210.28,21.1 210.57,20.81 210.57,20.35 210.77,20.16 211.69,20.16 211.84,20.01 212.12,20.01 212.71,19.42 213.52,19.42 214.13,20.03 214.13,20.61 214.83,21.3
  IN3 w0.091: v1(265.06,22.51) 264.87,22.32 258.93,22.32 255.74,19.13 251.73,19.13 250.18,17.58 246.56,17.58 246.36,17.37 240.38,17.37 239.76,17.99 227.46,17.99 226.16,19.29 222.25,19.29 220.24,21.3 214.83,21.3
  BOTTOM w0.089: UH1.AG35 207.44,22.71 v1(207.8,23.07)
  BOTTOM w0.107: JSSD1.69 v1(327.22,31.11)
SATA_GP3: length 119.3
  IN4 w0.097: v1(120.91,11.98) 122.32,11.98 125.01,14.67 135.51,14.67 138.59,17.74 177.29,17.74 181.96,22.42 182.83,23.28 182.83,23.46 187.08,27.72 192.54,27.72 193.51,26.75 200.9,26.75 203.06,24.59 203.71,24.59 204.22,24.07 204.22,23.22 204.74,22.71 v1(206.83,22.71)
  BOTTOM w0.089: UH1.AD35 v1(206.83,22.71)
  BOTTOM w0.107: JHDD.16 120.92,11.26 120.92,11.97 v1(120.91,11.98) 119.25,13.64 110.04,13.64 107.9,15.78 105.39,15.78 104.89,15.28 104.89,14.36 v2(104.62,14.09) 104.21,13.68 103.83,13.68 103.53,13.39 103.48,13.39 103.2,13.1 RS2.1 102.9,13.09 102.88,13.11 RS3.1
SATA_GP4: length 83.8
  TOP w0.107: v2(271.65,9.75) 273.19,8.22 v1(273.19,7.27) R365.1
  IN2 w0.091: v1(206.73,24.61) 207.03,24.92 208.16,24.92 208.62,24.46 216.18,24.46 216.8,23.84 222.74,23.84 226.48,20.1 226.48,19.16 228.65,16.99 230.98,16.99 231.38,16.59 246.3,16.59 246.94,15.94 262.74,15.94 v1(262.96,16.16)
  IN3 w0.091: v1(267.03,11.98) 267.03,11.77 267.51,11.28 272.83,11.28 273.99,10.13 273.99,8.07 v1(273.19,7.27)
  BOTTOM w0.089: UH1.AD31 206.55,24.79 v1(206.73,24.61)
  BOTTOM w0.107: v1(262.96,16.16) 262.96,15.65 263.86,14.75 264.37,14.75 265.38,13.75 265.38,13.75 267.03,12.1 v1(267.03,11.98) ; v1(273.19,7.27) 273.17,7.26 JSSD2.69
SATA_PRX_DTX_N3: length 115.6
  IN3 w0.099: v1(107.25,15.26) 107.34,15.18 107.34,14.81 107.54,14.6 109.78,14.6 110.79,15.61 146.55,15.61 147.78,16.84 181.15,16.84 186.96,22.64 189.76,22.64 191.22,24.1 191.96,24.1 192.81,23.24 194.44,23.24 194.63,23.06 194.63,20.03 194.92,19.74 195.5,19.74 196.4,18.84 196.7,18.84 v1(196.84,18.7)
  BOTTOM w0.099: v1(107.25,15.26) 107.47,15.04 107.47,14.4 107.25,14.18 107.25,12.13 108.09,11.3 v3(108.86,11.3) 110.08,11.3 110.18,11.2 110.18,10.7 110.46,10.42 110.99,10.42 111.2,10.63 111.2,11.87 111.3,11.97 111.79,11.97 111.89,11.87 111.89,10.63 112.11,10.42 112.7,10.42 112.91,10.63 112.91,11.93 113.01,12.03 113.47,12.03 113.57,11.93 113.57,10.79 113.42,10.63 JHDD.1 ; v1(196.84,18.7) 196.58,18.44 UH1.D43
SATA_PRX_DTX_P3: length 115.5
  IN3 w0.099: v1(196.86,19.27) 196.86,19.21 196.67,19.03 196.47,19.03 195.58,19.92 195,19.92 194.82,20.11 194.82,23.13 194.52,23.43 192.89,23.43 192.03,24.29 191.14,24.29 189.68,22.83 186.88,22.83 181.07,17.02 147.71,17.02 146.47,15.79 110.71,15.79 109.7,14.78 107.62,14.78 107.52,14.88 107.52,14.96 107.83,15.26 v1(107.84,15.26)
  BOTTOM w0.099: v1(107.84,15.26) 107.67,15.09 107.67,14.32 107.45,14.1 107.45,12.21 108.17,11.49 108.54,11.49 108.57,11.52 109.15,11.52 109.18,11.49 110.16,11.49 110.37,11.28 110.37,10.78 110.54,10.61 110.91,10.61 111.01,10.71 111.01,11.95 111.22,12.16 111.87,12.16 112.09,11.95 112.09,10.71 112.19,10.61 112.62,10.61 112.72,10.71 112.72,12.01 112.93,12.22 113.55,12.22 113.77,12.01 113.77,10.79 113.92,10.63 JHDD.2 ; v1(196.86,19.27) 196.76,19.37 196.61,19.37 196.45,19.21 UH1.E42
SATA_PTX_DRX_N3: length 102.5
  IN3 w0.099: v1(108.19,12.85) 108.58,13.25 110.32,13.25 111.34,14.28 147.1,14.28 148.33,15.51 190.54,15.51 193.17,18.14 193.17,19.28 193.54,19.64 v1(193.79,19.64)
  BOTTOM w0.099: JHDD.4 114.92,10.68 114.97,10.73 115.06,10.73 115.16,10.82 115.16,11.19 114.97,11.38 114.58,11.38 114.37,11.59 114.37,12.08 114.61,12.31 v3(114.99,12.31) 115.44,12.31 115.56,12.44 115.56,12.81 115.41,12.96 109.68,12.96 109.4,13.24 108.58,13.24 v1(108.19,12.85) ; UH1.A41 194.58,19.82 193.97,19.82 v1(193.79,19.64)
SATA_PTX_DRX_P3: length 102.5
  IN3 w0.099: v1(108.19,13.44) 110.24,13.44 111.26,14.46 147.03,14.46 148.26,15.69 190.47,15.69 192.99,18.21 192.99,19.35 193.79,20.16 v1(193.79,20.19)
  BOTTOM w0.099: UH1.A40 194.62,20.01 193.97,20.01 v1(193.79,20.19) ; v1(108.19,13.44) 109.48,13.44 109.76,13.16 115.49,13.16 115.76,12.89 115.76,12.36 115.52,12.12 115.31,12.12 115.28,12.09 114.69,12.09 114.56,11.97 114.56,11.67 114.66,11.57 115.05,11.57 115.35,11.27 115.35,10.75 115.42,10.68 JHDD.5
SCL: length 16.1
  IN3 w0.089: v1(225.37,93.8) 225.37,94.08 225.18,94.27 219.02,94.27 216.23,97.06 216.23,98.58 215.97,98.84 v1(215.97,99.41)
  BOTTOM w0.1: v1(225.37,93.8) 225.37,93.95 UG1.AF34
  BOTTOM w0.107: v1(215.97,99.41) 215.97,100.63 RG12.2
SDA: length 16.2
  IN3 w0.089: v1(226.17,93.8) 226.17,94.04 225.69,94.52 219.21,94.52 216.54,97.19 v1(216.54,98.84)
  BOTTOM w0.1: v1(226.17,93.8) 226.17,93.95 UG1.AF33
  BOTTOM w0.107: v1(216.54,98.84) 215.72,98.84 v2(215.53,99.03) 215.36,99.19 RG13.2
SERIRQ: length 122.1
  TOP w0.107: UE5.3 304.74,22.8 303.59,21.65 303.59,18.63 301.7,16.74 v1(301.7,15.46)
  IN2 w0.091: v1(301.7,15.46) 301.29,15.05 297.99,15.05 297.73,15.31 292.56,15.31 291.87,16 278.48,16 274.53,19.95 272.63,19.95 271.06,21.52 269.73,21.52 268.29,20.09 265.83,20.09 264.33,18.59 261.02,18.59 260.11,17.68 231.83,17.68 231.43,18.08 229.11,18.08 227.57,19.61 227.57,21.22 227.57,21.41 226.86,22.12 226.19,22.12 225.04,23.27 225.04,26.37 222.05,29.36 220.68,29.36 219.61,30.43 216.2,30.43 v1(214.45,32.17)
  BOTTOM w0.089: v1(214.45,32.17) 214.46,32.17 214.46,31.6 UH1.BA17 214.51,31.46 215.04,30.93 215.04,30.85 215.16,30.72 216,30.72 216.12,30.84 216.12,31.03 216.53,31.44 217.4,31.44 217.69,31.15 217.69,30.59 218.43,29.85 218.43,28.56 v2(218.51,28.48) 219.18,28.48
  BOTTOM w0.107: RH111.1 222.39,28.88 221.28,28.88 220.88,28.48 219.18,28.48
SLEEVE: length 10.4
  IN1 w1.016: 28.62,30.95 28.62,26.78 31.12,24.28 31.12,22.38 30.55,21.81
  vias: v1(27.09,31.11) v1(27.69,31.11) v1(29.28,21.81) v1(29.28,21.18) v2(28.46,21.24)
SLEEVE_R: length 32.2
  TOP w0.107: v1(29.13,19.48) v2(29.13,18.69)
  IN3 w1.016: 16.7,15.97 16.7,13.7 17.09,13.3 17.09,5.18 14.65,2.74 8.99,2.74 8.27,3.45 JACK1.3 ; 20.41,19.06 20.42,19.07 20.42,20.17 20.99,20.75 23.69,20.75 24.11,21.16 25.95,21.16 27.64,19.48
  vias: v1(17.37,16.59) v1(17.4,17.18) v1(20.2,18.13) v1(20.81,18.13) v1(28.55,19.48)
SLP_S3: length 68.1
  TOP w0.107: v1(314.14,16.35) 313.32,15.53 UE1.26 ; v1(294.19,16.1) 294.47,16.38 294.47,17.74 293.99,18.22 293.99,21.82 290.6,25.21 290.6,25.92 289.43,27.08 v2(289.43,27.39) 289.61,27.57 290.55,27.57 RE15.2 ; QE1.3 323.95,40.96 323.68,40.7 323.68,40.46 v1(323.39,40.16)
  IN1 w0.097: v1(314.14,16.35) 312.68,14.89 307.73,14.89 307.09,15.53 305.63,15.53 305.13,15.02 295.86,15.02 294.78,16.1 v1(294.19,16.1)
  IN3 w0.091: v1(314.14,16.35) 314.91,17.11 315.1,17.11 316.75,18.77 316.75,25.9 320.67,29.82 320.67,33.25 324.16,36.73 324.16,39.19 323.39,39.96 v1(323.39,40.16)
SLP_S5: length 31.9
  TOP w0.107: v1(322.27,44.36) 322.64,44.72 QE4.3 322.64,45.55 322.65,45.56 RE16.2 ; v1(315.72,19.2) 316.2,18.72 UE1.21
  IN3 w0.091: v1(315.72,19.2) 315.81,19.29 315.81,26.16 319.82,30.18 319.82,33.74 322.99,36.91 322.99,42.55 322.86,42.68 322.86,43.77 v1(322.27,44.36)
SM_PG_CTRL: length 44.8
  TOP w0.127: v1(97.53,48.1) 102.29,48.1 106.22,52.03 106.22,53.39 107.58,54.75 107.58,55.98 115.07,63.47 v2(115.07,64.8) 115.07,65.62 RH525.2 124.85,75.4 124.85,76.18 124.28,76.75 UC1.4
  BOTTOM w0.254: PR211.2 96.83,47.34 97.53,48.04 v1(97.53,48.1)
SML0CLK: length 208.4
  TOP w0.089: RH501.2 215.46,18.26 214.9,18.82 214.9,19.12 v1(214.77,19.25) 214.77,19.33 v2(214.19,19.91)
  IN1 w0.097: v1(188.98,106.93) 189.17,107.11 189.48,107.11 190.19,106.39 192.35,106.39 193.02,105.73 193.02,86.17 191.87,85.02 191.87,78.65 193.82,76.69 193.82,71.93 191.86,69.96 191.86,63.93 191.5,63.57 190.46,62.53 190.46,53.7 189.63,52.87 189.63,48.86 189.8,48.69 189.8,43.79 192.79,40.79 192.79,35.59 193.55,34.83 194.57,34.83 195.34,35.6 196.94,35.6 197.3,35.96 197.3,37.29 198.14,38.14 199.14,38.14 199.53,37.75 201.62,37.75 202.2,37.17 202.2,36.48 202.67,36.01 202.67,30.75 203.29,30.13 206.88,30.13 207.19,29.82 207.19,19.22 207.61,18.8 208.33,18.8 208.68,19.15 209.56,19.15 210.51,18.2 211.4,18.2 211.51,18.31 212.6,18.31 213.78,19.49 214.53,19.49 v1(214.77,19.25)
  IN3 w0.091: v1(166.76,157.32) 167.14,157.7 167.78,157.7 168.55,156.93 168.55,156.57 169.69,155.43 176.32,155.43 177.07,154.68 180.28,154.68 181.03,153.92 186.79,153.92 188.25,152.46 188.55,152.46 193.56,147.46 193.56,124.48 188.35,119.28 188.35,111.35 190.16,109.54 190.16,107.32 189.76,106.93 v1(188.98,106.93)
  BOTTOM w0.089: v1(214.77,19.25) 214.77,19.09 214.27,18.59 UH1.AY44
  BOTTOM w0.107: RV632.1 189.69,108.22 189.69,107.36 189.44,107.1 189.16,107.1 v1(188.98,106.93) ; UM4.11 165.34,157.19 165.65,156.88 166.63,156.88 166.76,157 v1(166.76,157.32)
SML0DATA: length 206.3
  TOP w0.089: RH502.2 215.12,19.69 v1(214.88,19.94)
  IN1 w0.097: v1(214.88,19.94) 214.61,19.68 213.7,19.68 212.52,18.5 211.44,18.5 211.32,18.38 210.58,18.38 209.63,19.34 208.6,19.34 208.25,18.99 207.68,18.99 207.38,19.29 207.38,29.9 206.96,30.31 203.37,30.31 202.85,30.83 202.85,36.14 202.38,36.61 202.38,37.25 201.7,37.94 199.6,37.94 199.22,38.32 198.07,38.32 197.11,37.37 197.11,36.04 196.86,35.78 195.26,35.78 194.5,35.02 193.63,35.02 193.36,35.28 193.36,35.34 193.02,35.68 193.02,40.88 190.02,43.88 190.02,48.78 189.85,48.95 189.85,52.78 190.68,53.61 190.68,62.43 191.6,63.35 192.08,63.83 192.08,69.87 194.05,71.83 194.05,76.78 192.09,78.74 192.09,84.92 193.24,86.08 193.24,105.82 192.44,106.62 190.29,106.62 189.57,107.33 189.17,107.33 v1(188.98,107.51)
  IN3 w0.091: v1(188.98,107.51) 188.98,107.49 189.33,107.14 189.67,107.14 189.94,107.41 189.94,109.45 188.13,111.26 188.13,119.37 193.34,124.57 193.34,147.37 188.46,152.24 188.16,152.24 186.7,153.71 180.94,153.71 180.18,154.46 176.98,154.46 176.23,155.21 169.6,155.21 168.33,156.48 168.33,156.84 167.69,157.48 167.23,157.48 167.16,157.41 167.16,156.92 v1(167.26,156.82)
  BOTTOM w0.089: UH1.BB39 215.31,20.4 215.4,20.31 215.4,20.09 215.25,19.94 v1(214.88,19.94)
  BOTTOM w0.107: UM4.10 165.34,156.41 165.57,156.64 166.73,156.64 166.9,156.82 v1(167.26,156.82) ; RV633.1 189.46,108.22 189.46,107.45 189.34,107.33 189.16,107.33 v1(188.98,107.51)
SML1CLK: length 10.2
  TOP w0.107: v1(213.57,18.76) 213.07,18.26 212.91,18.26 212.67,18.02 212.67,17.09 210.87,15.29 210.82,15.29 210.42,14.9 209.86,14.9 209.58,14.61 209.58,14.49 v1(209.33,14.24) 209.44,14.13 209.44,13.63 RH460.2
  BOTTOM w0.089: v1(213.57,18.76) 213.39,18.95 UH1.AW42
  BOTTOM w0.107: v1(209.33,14.24) 209.33,15.03 208.88,15.48 QH5.6
SML1DATA: length 8.8
  TOP w0.107: v1(213.44,17.32) 213.44,17.74 213.11,18.07 212.99,18.07 212.86,17.94 212.86,17 210.52,14.66 209.96,14.66 209.81,14.52 209.81,14.34 v1(209.91,14.24) 209.7,14.02 209.7,13.59 RH461.2
  BOTTOM w0.089: UH1.AW45 213.46,17.35 v1(213.44,17.32)
  BOTTOM w0.107: v1(209.91,14.24) 209.98,14.18 QH5.3
SNB_+VGA_PCIE: length 2.7
  TOP w0.107: v2(199.14,79.53) 198.87,79.26 PC802.1
  TOP w0.254: PR803.2 197.83,77.54 PC802.1
SNB_VCCIO: length 1.3
  BOTTOM w0.107: PC591.1 v2(119.71,108.11)
SPEAKER_SEL: length 347.8
  TOP w0.107: UE10.2 v1(307.55,47.96) ; v1(180.95,27.53) v2(180.95,28.48) 180.95,32.19 182.6,33.84 182.6,41.43 181.9,42.13 v1(179.91,42.13)
  IN2 w0.091: v1(195.97,69.5) 199.92,65.56 202.16,65.56 202.92,64.79 203.85,64.79 204.52,65.46 206.2,65.46 207.36,64.3 212.87,64.3 213.95,65.37 223.83,65.37 224.34,65.88 224.48,65.88 224.63,66.04 249.17,66.04 249.36,65.85 267.13,65.85 267.28,66 273.65,66 279.04,60.61 279.04,47.5 282.29,44.25 298.74,44.25 300.34,45.85 305.08,45.85 307.22,47.99 307.52,47.99 v1(307.55,47.96)
  IN4 w0.097: v1(195.97,69.5) 195.4,70.07 187.52,70.07 186.25,68.8 186.25,62.05 181.34,57.13 181.34,51.75 181.14,51.56 181.14,43.36 v1(179.91,42.13) ; v1(43.32,15.59) 43.6,15.59 45.42,13.77 50.47,13.77 52.34,11.9 72.58,11.9 74.56,13.88 93.6,13.88 95.64,11.84 103.85,11.84 104.21,11.48 110.2,11.48 114.4,15.68 135.27,15.68 137.99,18.41 176.73,18.41 180.95,22.63 v1(180.95,27.53)
  BOTTOM w0.107: JSPK.5 47.18,15.41 46.36,16.22 43.95,16.22 v1(43.32,15.59)
SPI_MOCLK: length 243.2
  TOP w0.107: v1(99.85,18.14) 99.55,18.44 97.86,18.44 v2(97.23,17.81) 96.61,17.19 v1(96.61,11.14) ; UE1.2 314.6,8.14 314.74,8 CE57.1 314.18,7.56 v1(313.44,6.83)
  IN1 w0.097: v1(313.44,6.83) 312.65,7.62 308.39,7.62 307.87,8.15 305.31,8.15 304.59,8.87 302.49,8.87 302.21,9.15 302.21,10.45 299.65,13.01 297.33,13.01 296.28,14.06 294.81,14.06 291.8,17.07 274.85,17.07 273.44,15.65 267.61,15.65 267.07,15.11 265.45,15.11 263.96,13.63 240.63,13.63 239.42,12.41 233.21,12.41 232.71,11.91 232.71,11.91 232.1,11.29 214.49,11.29 213.72,10.52 207.39,10.52 207.18,10.74 203.88,10.74 203.67,10.52 202.5,10.52 202.17,10.86 199.06,10.86 199.05,10.85 191.96,10.85 191.06,11.76 186.93,11.76 179.93,18.76 179.93,20.26 177.43,22.77 174.82,22.77 v1(174.06,22)
  IN4 w0.097: v1(99.85,18.14) 100.86,18.14 102.75,20.03 135.53,20.03 137.05,21.56 173.62,21.56 v1(174.06,22)
  BOTTOM w0.107: v1(96.61,11.14) RE11.2
SPI_MOCS#: length 236
  TOP w0.107: UE1.31 311.48,11.53 311.16,11.21 311.16,10.57 311.61,10.12 v1(311.61,9.52) 311.61,9.31 v2(311.03,8.73)
  IN2 w0.091: v1(311.61,9.52) 310.93,8.84 309.33,8.84 309.1,8.61 306.76,8.61 306.53,8.84 292.93,8.84 291.9,9.88 288.75,9.88 288.16,10.46 278.15,10.46 274.96,13.66 267.16,13.66 266.83,13.32 257.07,13.32 256.33,12.58 233.68,12.58 233.47,12.79 231.83,12.79 231.07,12.03 230.86,11.82 227.56,11.82 226.08,13.31 215.68,13.31 213.24,10.87 207.47,10.87 206.55,9.95 204.36,9.95 203.95,9.53 202.19,9.53 201.97,9.31 194.04,9.31 192.25,11.1 187.94,11.1 183.38,15.67 101.88,15.67 v1(101.6,15.39)
  BOTTOM w0.107: RE12.2 97.61,12.43 97.61,12.06 98.08,11.59 98.83,11.59 100.28,13.03 100.28,14.07 v1(101.6,15.39) 101.66,15.45 101.66,15.96 102.31,16.61 103.64,16.61 104.02,16.99 104.02,18.45 103.91,18.56 UE2.1
SPI_MOSI: length 264.2
  TOP w0.107: v1(99.39,22.38) 99.39,22.19 95.76,18.57 v2(95.76,16.1) v1(95.76,11.22) ; v1(318.05,16.51) 318.05,15.94 316.01,13.91 316.01,11.27 315.47,10.73 UE1.32
  IN2 w0.091: v1(318.05,16.51) 316.65,17.91 314.75,17.91 312.88,19.78 302.5,19.78 301.64,18.93 297.9,18.93 296.55,20.28 288.28,20.28 283.23,25.33 279.97,25.33 277.65,27.66 265.51,27.66 257.23,35.93 240.06,35.93 239.61,36.38 233.41,36.38 232.98,36.81 224.81,36.81 223.9,35.9 223.9,35.41 223.28,34.78 222.17,34.78 221.51,34.12 220.84,34.12 220.04,34.92 220.04,37.74 219.08,38.69 218.59,38.69 218.1,39.18 217.41,39.18 217.08,39.5 214.21,39.5 214.21,39.5 211.75,39.5 211.07,38.82 207.37,38.82 207.3,38.76 205.19,38.76 205.12,38.82 198.95,38.82 197.87,37.75 197.86,37.75 197.65,37.53 197.65,37.01 196.91,36.28 196.91,36.27 196.7,36.06 196.69,36.06 196.15,35.52 194.89,35.52 192.95,33.58 188.37,33.58 186.68,31.89 176.81,31.89 168.91,23.99 126.91,23.99 126.82,24.08 103.22,24.08 101.65,22.51 99.51,22.51 v1(99.39,22.38)
  BOTTOM w0.107: RE9.2 95.76,11.76 v1(95.76,11.22)
SPI_MOSO: length 239.1
  TOP w0.107: UE1.1 313.8,7.81 v1(312.81,6.83)
  IN1 w0.097: v1(175.4,22) 175.84,22.45 177.43,22.45 179.71,20.17 179.71,18.66 186.84,11.53 190.97,11.53 191.87,10.63 199.15,10.63 199.15,10.63 202.07,10.63 202.41,10.3 203.76,10.3 203.97,10.51 207.09,10.51 207.3,10.3 213.81,10.3 214.58,11.07 232.19,11.07 233.31,12.19 239.51,12.19 240.73,13.41 264.05,13.41 265.54,14.89 267.2,14.89 267.65,15.34 274.27,15.34 274.96,16.04 277.9,16.04 278.57,15.36 293.19,15.36 294.72,13.83 296.19,13.83 297.24,12.79 299.55,12.79 301.99,10.35 301.99,9.06 302.4,8.65 304.5,8.65 305.22,7.93 307.77,7.93 308.3,7.4 312.24,7.4 v1(312.81,6.83)
  IN4 w0.097: v1(175.4,22) 174,20.61 137.24,20.61 135.64,19.02 103.58,19.02 101.74,17.18 99.45,17.18 v1(98.6,18.03)
  BOTTOM w0.107: RE10.2 98.41,12.02 97.93,12.5 97.93,13.3 98.4,13.78 98.4,17.84 v1(98.6,18.03)
SPK_L+_CONN: length 26.7
  IN1 w1.016: 43.54,12.57 42.62,11.65 42.62,9.3 41.21,7.89 38.86,7.89 37.11,6.14 36.09,6.14
  IN3 w1.016: 36.78,6.45 37.6,7.27 37.6,12.22 36.46,13.37 32.14,13.37 30.43,15.08 30.43,15.84
  vias: v1(29.78,16.93) v1(30.37,16.93) v1(36.01,5.24) v1(36.46,4.86) v1(44.65,12.48) v1(45.28,12.48) v1(47.89,12.48) v1(48.48,12.48) v2(44.84,13.05)
SPK_L-_CONN: length 28.6
  IN1 w1.016: 43.95,10.74 43.95,7.4 42.81,6.26 40.33,6.26 39.06,4.99
  IN3 w1.016: 38.74,4.6 41.16,7.02 41.16,9.18 40.2,10.13 40.2,14.13 38.61,15.72 32.39,15.72
  vias: v1(32.13,16.99) v1(32.72,16.99) v1(39.31,3.85) v1(39.31,3.21) v1(45.54,11.4) v1(45.54,10.76) v1(47.82,10.67) v1(48.46,10.67) v2(44.84,11.4)
SPK_R+_CONN: length 24.8
  IN3 w1.016: 27.76,4.54 28.71,5.49 28.71,7.65 28.46,7.91 28.46,10.19 28.01,10.64
  IN4 w1.016: 27.76,4.6 29.6,6.45 31.5,6.45 31.82,6.13 37.28,6.13 39.06,7.91 41.35,7.91 41.54,8.1 44.01,8.1
  vias: v1(27.06,11.78) v1(27.06,11.14) v1(27.06,3.84) v1(27.69,3.84) v1(44.97,7.97) v1(45.47,8.35) v1(47.86,8.44) v1(48.49,8.44) v2(44.84,8.48)
SPK_R-_CONN: length 28.1
  TOP w0.107: v1(45.53,6.24) v2(44.67,6.24)
  IN3 w1.016: 28.01,13.81 28.01,13.11 30.49,10.64 30.49,7.53 30.04,7.08 30.04,5.05 30.17,4.92 30.17,3.52
  IN4 w1.016: 30.49,2.32 32.58,2.32 33.32,3.05 35.33,3.05 35.99,3.72 37.73,3.72 40.22,6.2 44.59,6.2
  vias: v1(27.06,14.32) v1(27.06,13.68) v1(28.94,1.62) v1(29.54,1.62) v1(45.51,6.84) v1(47.86,6.4) v1(48.49,6.4)
SUSACK#: length 107.5
  TOP w0.107: v1(300.67,13.68) 300.67,12.15 302.68,10.15 305.24,10.15 305.58,9.81 UE5.97
  IN2 w0.091: v1(300.67,13.68) 298.08,13.68 297.48,14.29 295.18,14.29 294.82,14.65 292.14,14.65 291.44,15.35 278.21,15.35 274.26,19.3 272.36,19.3 271.41,20.24 269.37,20.24 267.94,18.81 265.47,18.81 263.83,17.16 262.69,17.16 261.91,16.38 256.07,16.38 255.42,17.02 231.56,17.02 231.16,17.43 228.83,17.43 226.92,19.34 226.92,20.28 224.38,22.82 224.38,26.1 223.1,27.38 221.13,27.38 219.91,28.61 217.62,28.61 217.42,28.81 217.42,29.15 v1(216.84,29.73)
  BOTTOM w0.089: UH1.BB19 215.11,30.36 215.41,30.06 216.5,30.06 v1(216.84,29.73)
SUSCLK: length 191.3
  IN4 w0.097: v1(210.97,33.09) 210.97,29.73 212.92,27.79 213.37,27.79 214.2,26.96 216.16,26.96 216.48,27.28 217.29,27.28 218.28,26.29 219.21,26.29 221.53,23.96 222.79,23.96 223.9,22.85 223.9,21.63 227.91,17.63 236.63,17.63 v1(238.07,16.19) 238.24,16.19 238.65,16.61 239.47,16.61 240.6,15.48 242.2,15.48 243.99,13.68 246.46,13.68 246.93,13.21 250.59,13.21 250.82,12.99 264.16,12.99 265.94,14.77 265.94,15.59 267.41,17.06 274.35,17.06 v1(274.9,16.51) 279.99,16.51 281.37,17.88 299.15,17.88 v1(299.94,17.09)
  BOTTOM w0.089: v1(210.97,33.09) 210.67,32.77 UH1.AN15
  BOTTOM w0.107: JSSD3.68 237.27,6.03 237.44,6.19 237.96,6.19 238.16,6.39 238.16,6.93 237.62,7.47 237.62,10.62 237.92,10.93 v2(237.92,15.21) 237.92,16.04 v1(238.07,16.19) ; v1(274.9,16.51) 274.9,10.19 277.19,7.91 278.2,7.91 278.6,7.5 JSSD2.68 ; v1(299.94,17.09) 299.51,17.52 299.51,21.47 300.04,22 300.97,22 304.09,25.12 304.09,27 306.62,29.53 306.62,38.05 307.43,38.86 311.5,38.86 312.57,39.94 JWLAN.42 312.57,42.34 313.42,43.18 317.28,43.18 318.08,42.39 319.41,42.39 321.99,39.81 321.99,36.91 322.29,36.61 322.29,34.03 323.32,33.01 326.82,33.01 328.48,31.36 JSSD1.68
SUSP#: length 727.6
  TOP w0.107: U16.4 v1(315.84,54.44) ; Q8.3 v1(321.24,41.8) ; v1(64.91,18.39) 68.53,18.39 68.75,18.61 75.14,18.61 v2(77.27,20.75) 77.59,21.06 77.59,26.63 76.34,27.88 76.34,31.97 82.97,38.6 82.97,38.86 89.17,45.07 94.13,45.07 94.47,44.72 97.68,44.72 v1(98.94,45.99) 99.35,45.99 100.54,47.17 101.75,47.17 107.33,52.76 v1(107.33,53.23) ; UE5.116 306.19,17.41 306.01,17.24 305.92,17.24 v1(305.35,16.67) ; U20.4 182.52,78.32 182.62,78.21 182.78,78.21 v1(183.16,78.59) ; v1(126.06,117.44) 126.82,116.68 126.82,113.95 128.91,111.86 128.91,101.31 126.92,99.32 126.92,96.7 v1(128.12,95.5)
  IN1 w0.254: v1(230.39,41.12) 229.71,40.44 v1(225.87,40.44)
  IN2 w0.091: v1(183.16,78.59) 182.44,77.88 182.44,74.71 179.59,71.85 137.21,71.85 128.7,80.35 128.7,94.91 v1(128.12,95.5) ; v1(168.07,165.45) 168.18,165.34 168.18,161.21 167.08,160.11 167.08,157.77 168.13,156.71 168.13,156.02 167.86,155.75 167.86,155.1 169.29,153.67 170.53,153.67 172.26,151.94 177.59,151.94 177.77,152.13 184.94,152.13 185.53,151.53 188.52,151.53 189.81,150.24 189.81,149.07 195.08,143.81 195.08,112.5 190.64,108.06 190.64,106.32 190.74,106.22 190.74,73.78 193.02,71.49 193.02,70.66 195.11,68.57 195.94,68.57 199.39,65.12 201.98,65.12 202.74,64.36 204.29,64.36 v1(204.38,64.45) 204.42,64.45 204.52,64.55 204.74,64.55 205.42,63.86 213.06,63.86 214.14,64.94 224.15,64.94 224.82,65.6 248.99,65.6 249.18,65.41 267.31,65.41 267.46,65.57 272.99,65.57 277.62,60.94 277.62,53.57 278.6,52.58 278.6,47.32 282.11,43.82 294.12,43.82 296.46,41.47 300.46,41.47 300.78,41.8 v1(321.24,41.8)
  IN3 w0.091: v1(321.24,41.8) 320.81,41.37 320.81,36.1 318.78,34.07 318.78,31.08 314.19,26.49 314.19,23 313.23,22.05 313.23,17.92 312.26,16.94 310.48,16.94 309.7,16.16 309.7,15.27 309.37,14.95 307.07,14.95 v1(305.35,16.67)
  IN4 w0.097: v1(168.07,165.45) 166.36,165.45 162.86,161.95 162.86,159.71 162.1,158.95 152.38,158.95 150.9,157.47 149.73,157.47 149.33,157.07 141.86,157.07 141.17,156.38 137.11,156.38 136.51,155.78 135.21,155.78 134.06,156.93 134.06,157.86 133.11,158.81 127.99,158.81 125.91,160.9 117.24,160.9 114.82,158.48 114.82,155.35 115.56,154.61 117.27,154.61 118.6,153.28 118.6,152.74 119.36,151.98 119.36,149.35 118.49,148.49 118.49,148.17 117.96,147.64 117.96,130.82 126.5,122.28 126.5,117.89 v1(126.06,117.44)
  BOTTOM w0.107: v1(128.12,95.5) 128.12,94.34 128.27,94.19 128.27,87.04 125.28,84.05 121.28,84.05 112.95,75.72 111.58,75.72 108.63,72.78 108.63,72.13 109.17,71.6 114.69,71.6 116.15,70.14 116.15,63.89 113.32,61.06 111.56,61.06 111.05,60.55 111.05,57.11 111.78,56.39 111.78,55.44 109.57,53.23 v1(107.33,53.23) ; v1(321.24,41.8) 320.33,41.8 316.43,45.7 316.43,51.53 315.84,52.12 v1(315.84,54.44) ; PR209.1 98.54,46.39 v1(98.94,45.99) ; R182.1 R174.1 64.91,18.31 v1(64.91,18.39) ; v1(168.07,165.45) 168.04,165.48 168.04,166.35 168.37,166.68 168.9,166.68 169.36,166.21 170.01,166.21 170.32,166.52 170.96,166.52 171.17,166.31 RT15.2 ; v1(126.06,117.44) 125.61,117.44 125.48,117.32 PR5007.2
  BOTTOM w0.127: UZ21.3 128.1,95.52 v1(128.12,95.5)
  BOTTOM w0.254: PR807.2 230.17,40.9 v1(230.39,41.12) ; v1(225.87,40.44) 225.31,41 225.31,44.67 222.79,47.18 217.71,47.18 216.35,48.54 215.77,48.54 212.3,52 210.06,52 207.46,54.59 207.46,57.39 204.38,60.48 v1(204.38,64.45)
