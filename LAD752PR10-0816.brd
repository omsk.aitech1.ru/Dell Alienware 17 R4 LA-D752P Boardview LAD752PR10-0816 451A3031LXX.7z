# Allegro board LAD752PR10-0816.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_A_DQS2: length 51.2
  IN4 w0.089: v1(135.08,88.68) 134.85,88.91 134.67,88.91 134.54,88.78 134.54,87.56 135.19,86.91 135.19,83.87 135.2,83.86 135.2,83.85
  IN4 w0.099: v1(124.69,56.22) 124.83,56.36 125.61,56.36 125.96,56.7 125.96,57.69 125.74,57.9 125.74,58.46 126,58.71 126,58.81 126,58.81 126,61.99 127.01,63.01 127.01,65.38 131.2,69.57 131.2,73.99 135.2,77.99 135.2,83.85
  BOTTOM w0.076: CPU1.BF3 138.73,94.77 138.73,94.53 138.57,94.37 138.57,93.3 138.6,93.26 138.62,93.26 138.87,93.02 138.87,92.36 138.84,92.33 138.82,92.33 138.82,92.17 135.57,88.93 135.34,88.93 v1(135.08,88.68)
  BOTTOM w0.107: JDIMM1.55 125.19,58.97 125.1,58.88 125.1,58.26 125.55,57.82 125.55,56.78 125.18,56.42 124.89,56.42 v1(124.69,56.22)
DDR_A_DQS3: length 49.8
  IN4 w0.089: 139.65,83.85 139.65,83.86 139.63,83.87 139.63,83.92 139.63,83.93 139.63,86.21 139.44,86.4 139.44,89.56 139.66,89.78 v1(139.95,89.78)
  IN4 w0.099: 139.65,83.85 139.65,76.3 135.18,71.83 135.18,66.37 132.22,63.4 132.22,58.64 131.71,58.13 131.71,55.72 131.38,55.39 130.66,55.39 130.29,55.01 v1(130.29,54.95)
  BOTTOM w0.076: CPU1.BC3 141.08,94.61 141.08,92.17 141.21,92.05 141.21,90.56 140.81,90.16 140.2,90.16 139.95,89.91 v1(139.95,89.78)
  BOTTOM w0.107: v1(130.29,54.95) 130.14,55.1 129.95,55.1 129.79,54.93 129.79,53.85 130.31,53.33 130.31,52.96 130.44,52.83 JDIMM1.76
DDR_A_DQS4: length 49.3
  IN4 w0.089: v1(158.24,88.97) 158.22,88.71 157.89,88.37 157.89,88.03 161.28,84.64 161.28,83.88 161.27,83.87 161.27,83.85
  IN4 w0.099: v1(158.09,56.33) 157.49,56.33 157.25,56.58 157.25,57.83 157.88,58.46 158.15,58.46 158.25,58.56 158.25,58.9 158.15,59 157.78,59 157.56,59.21 157.56,59.67 157.81,59.91 158.04,59.91 158.18,60.05 158.18,60.35 158.05,60.48 157.89,60.48 157.61,60.76 157.61,63.41 161.27,67.06 161.27,83.85
  BOTTOM w0.076: CPU1.AB3 158.52,94.59 158.52,91.08 159.23,90.37 159.23,89.78 158.41,88.97 v1(158.24,88.97)
  BOTTOM w0.107: JDIMM1.179 158.19,58.59 158.77,58.01 158.77,56.81 158.5,56.55 158.31,56.55 v1(158.09,56.33)
DDR_A_DQS5: length 49.9
  IN4 w0.089: v1(161.66,89.14) 161.66,88.81 161.52,88.67 161.52,88.4 162.3,87.61 162.75,87.61 165.49,84.87 165.49,83.88 165.48,83.87 165.48,83.85
  IN4 w0.099: v1(163.51,55.07) 163.28,55.3 162.83,55.3 162.56,55.56 162.56,56.31 162.88,56.63 162.88,57.24 163.13,57.48 163.42,57.48 163.52,57.58 163.52,57.86 163.31,58.07 163.04,58.07 162.77,58.33 162.77,59.12 163.01,59.36 163.01,63.27 165.48,65.75 165.48,83.85
  BOTTOM w0.076: CPU1.V3 160.94,94.89 161.04,94.8 161.04,92.57 162.15,91.46 162.15,89.31 161.97,89.14 v1(161.66,89.14)
  BOTTOM w0.107: v1(163.51,55.07) 163.35,55.23 163.06,55.23 162.95,55.12 162.95,53.82 163.33,53.44 163.33,52.94 163.44,52.83 JDIMM1.200
DDR_A_DQS6: length 50.1
  IN4 w0.089: v1(165.13,89.48) 165.4,89.48 165.58,89.66 165.85,89.66 169.07,86.43 169.07,86.18
  IN4 w0.099: 169.07,86.18 169.07,86.08 169.16,85.99 169.76,85.4 169.76,63.75 168.06,62.05 168.06,58.33 168.16,58.23 168.38,58.23 168.6,58.01 168.6,57.56 168.38,57.35 168.02,57.35 167.91,57.23 167.91,56.9 168.07,56.74 168.78,56.74 v1(169.02,56.98)
  BOTTOM w0.076: v1(165.13,89.48) 165.55,89.48 166.15,90.08 166.15,90.52 163.55,93.12 163.55,94.7 163.64,94.79 163.64,94.88 163.57,94.96 163.33,94.96 CPU1.R3
  BOTTOM w0.107: v1(169.02,56.98) 168.83,56.78 168.25,56.78 168.03,57.01 168.03,57.56 168.54,58.07 168.54,58.84 168.69,58.99 JDIMM1.221
DDR_A_DQS7: length 49.8
  IN4 w0.097: 172.07,89.18 172.07,89.18 172.02,89.23 172.02,89.23 168.45,92.81 167.98,92.81 167.86,92.69 v1(167.86,92.36)
  IN4 w0.099: v1(174.74,55.01) 174.54,55.21 174.27,55.21 173.99,55.49 173.99,87.25 172.07,89.18
  BOTTOM w0.076: v1(167.86,92.36) 167.79,92.42 166.84,92.42 166.06,93.2 166.06,94.59 CPU1.M3
  BOTTOM w0.107: JDIMM1.242 173.94,52.79 173.79,52.95 173.79,53.48 174.06,53.75 174.06,55.07 174.22,55.23 174.52,55.23 v1(174.74,55.01)
DDR_A_DQS#0: length 57.2
  IN4 w0.089: v1(131.14,95.22) 130.87,95.22 130.81,95.28 130.4,95.28 129.99,94.87 129.99,94.73 129.55,94.29
  IN4 w0.099: 129.55,94.29 129.55,94.29 127.45,92.2 127.45,86.47 125.91,84.93 125.91,81.82 121.22,77.14 121.22,72.15 116.21,67.14 116.21,65.82 115.76,65.37 115.13,65.37 114.63,64.87 114.63,60.58 114.53,60.48 114.18,60.48 113.94,60.24 113.94,59.8 114.15,59.59 114.54,59.59 114.64,59.49 114.64,59.19 114.54,59.08 114.16,59.08 113.94,58.87 113.94,58.41 114.17,58.18 114.52,58.18 114.64,58.06 114.64,56.73 114.52,56.61 114.32,56.61 114.07,56.85 v1(114.07,56.86)
  BOTTOM w0.076: v1(131.14,95.22) 131.14,95.51 131.33,95.69 131.53,95.69 131.76,95.92 132.7,95.92 132.84,96.07 133.13,96.07 133.49,95.71 133.49,95.55 133.39,95.46 132.97,95.46 132.89,95.53 132.89,95.64 CPU1.BR5
  BOTTOM w0.107: JDIMM1.11 114.19,58.97 114.33,58.84 114.33,58.35 114.63,58.05 114.63,56.82 114.42,56.61 114.23,56.61 114.07,56.76 v1(114.07,56.86)
DDR_A_DQS#1: length 54.5
  IN4 w0.089: v1(132.72,90.98) 132.41,90.98 132.24,91.15 131.9,91.15 131.01,90.27 131.01,83.87 131,83.86 131,83.85
  IN4 w0.099: v1(119.19,55.59) 119.37,55.41 119.61,55.41 119.71,55.51 119.71,57.43 119.26,57.88 119.26,59.53 120.53,60.8 120.53,66.08 126.71,72.26 126.71,76.31 131,80.61 131,83.85
  BOTTOM w0.076: v1(132.72,90.98) 132.72,90.84 132.87,90.7 133.6,90.7 136.28,93.38 136.28,93.69 135.9,94.07 135.9,94.75 135.76,94.89 CPU1.BL3
  BOTTOM w0.107: v1(119.19,55.59) 119.01,55.4 118.63,55.4 118.3,55.08 118.3,54.07 118.81,53.56 119.18,53.56 119.6,53.15 119.6,52.88 119.44,52.73 JDIMM1.32
DDR_A_DQS#2: length 51.2
  IN4 w0.089: v1(135.08,89.31) 134.85,89.08 134.6,89.08 134.37,88.85 134.37,87.48 135.02,86.83 135.02,83.88 135.01,83.87 135.01,83.85 135,83.85
  IN4 w0.099: v1(124.69,56.86) 124.99,56.55 125.53,56.55 125.76,56.78 125.76,57.61 125.55,57.82 125.55,58.54 125.8,58.79 125.8,58.89 125.8,58.89 125.8,62.07 126.82,63.09 126.82,65.46 131.01,69.65 131.01,74.07 135,78.07 135,83.85
  BOTTOM w0.076: CPU1.BG3 138.11,94.98 138.21,95.07 138.47,95.07 138.55,95 138.55,94.59 138.4,94.44 138.4,93.17 138.65,92.93 138.65,92.24 135.51,89.1 135.29,89.1 v1(135.08,89.31)
  BOTTOM w0.107: JDIMM1.53 124.69,58.97 124.87,58.8 124.87,58.16 125.31,57.72 125.31,56.88 125.09,56.66 124.89,56.66 v1(124.69,56.86)
DDR_A_DQS#3: length 49.7
  IN4 w0.089: 139.45,83.85 139.45,86.14 139.26,86.32 139.26,89.63 139.95,90.31 v1(139.95,90.41)
  IN4 w0.099: v1(130.29,55.59) 131.3,55.59 131.51,55.8 131.51,58.22 132.02,58.72 132.02,63.49 134.98,66.45 134.98,71.91 139.45,76.38 139.45,83.85
  BOTTOM w0.076: CPU1.BD3 140.92,94.59 140.92,92.1 141.04,91.98 141.04,90.63 140.75,90.33 140.03,90.33 v1(139.95,90.41)
  BOTTOM w0.107: JDIMM1.74 129.94,52.83 130.07,52.96 130.07,53.23 129.55,53.75 129.55,55.03 129.85,55.34 130.04,55.34 v1(130.29,55.59)
DDR_A_DQS#4: length 49.3
  IN4 w0.089: v1(158.69,88.44) 158.57,88.58 158.36,88.6 158.06,88.29 158.07,88.1 161.46,84.71 161.46,83.88 161.47,83.87 161.47,83.85
  IN4 w0.099: v1(158.09,56.96) 158.09,56.9 157.71,56.52 157.58,56.52 157.44,56.66 157.44,57.75 157.96,58.27 158.23,58.27 158.44,58.48 158.44,58.98 158.23,59.19 157.86,59.19 157.76,59.29 157.76,59.59 157.89,59.72 158.13,59.72 158.38,59.97 158.38,60.43 158.13,60.67 157.97,60.67 157.81,60.84 157.81,63.32 161.47,66.98 161.47,83.85
  BOTTOM w0.076: v1(158.69,88.44) 158.59,88.54 158.59,88.86 159.39,89.66 159.39,90.44 158.69,91.14 158.69,94.61 CPU1.AA3
  BOTTOM w0.107: JDIMM1.177 157.69,58.97 157.96,58.71 157.96,58.49 158.54,57.91 158.54,56.91 158.41,56.78 158.27,56.78 v1(158.09,56.96)
DDR_A_DQS#5: length 49.9
  IN4 w0.089: v1(162.11,88.69) 161.78,88.69 161.69,88.6 161.69,88.47 162.38,87.79 162.82,87.79 165.67,84.94 165.67,83.88 165.68,83.87 165.68,83.85
  IN4 w0.099: v1(163.51,55.71) 163.29,55.49 162.91,55.49 162.76,55.64 162.76,56.23 163.08,56.55 163.08,57.16 163.21,57.29 163.5,57.29 163.71,57.5 163.71,57.94 163.39,58.26 163.12,58.26 162.97,58.41 162.97,59.04 163.2,59.27 163.2,63.19 165.68,65.67 165.68,83.85
  BOTTOM w0.076: v1(162.11,88.69) 162.11,89.04 162.31,89.24 162.31,91.6 161.2,92.71 161.2,94.61 CPU1.U3
  BOTTOM w0.107: JDIMM1.198 162.94,52.83 163.09,52.98 163.09,53.34 162.71,53.72 162.71,55.22 162.96,55.47 163.26,55.47 v1(163.51,55.71)
DDR_A_DQS#6: length 50.1
  IN4 w0.089: 168.88,85.99 168.88,86.2 168.89,86.21 168.89,86.22 168.9,86.23 168.9,86.35 165.77,89.48 165.65,89.48 165.58,89.4 v1(165.58,89.03)
  IN4 w0.099: 168.88,85.99 169.56,85.32 169.56,63.83 167.86,62.13 167.86,58.24 168.07,58.03 168.3,58.03 168.41,57.93 168.41,57.64 168.3,57.54 167.94,57.54 167.71,57.31 167.71,56.82 167.99,56.54 168.81,56.54 168.81,56.54 168.82,56.54 v1(169.02,56.34)
  BOTTOM w0.076: v1(165.58,89.03) 165.58,89.27 166.32,90.01 166.32,90.59 163.71,93.19 163.71,94.61 CPU1.P3
  BOTTOM w0.107: v1(169.02,56.34) 168.82,56.55 168.16,56.55 167.79,56.91 167.79,57.66 168.3,58.17 168.3,58.86 168.19,58.97 JDIMM1.219
DDR_A_DQS#7: length 49.7
  IN4 w0.097: 172.21,89.31 168.52,93 167.91,93 167.72,92.81 v1(167.41,92.81)
  IN4 w0.099: v1(174.74,55.65) 174.5,55.4 174.35,55.4 174.19,55.57 174.19,87.33 172.21,89.31
  BOTTOM w0.076: CPU1.L3 166.23,94.61 166.23,93.27 166.91,92.59 167.3,92.59 167.41,92.7 v1(167.41,92.81)
  BOTTOM w0.107: JDIMM1.240 173.44,52.82 173.55,52.93 173.55,53.58 173.83,53.85 173.83,55.17 174.13,55.47 174.56,55.47 v1(174.74,55.65)
DDR_A_MA0: length 48
  IN4 w0.089: v1(152.31,89.23) 152.01,89.23 151.77,89 151.77,88.49 152.04,88.22 152.04,85.94 152.41,85.57 152.41,84.8 152.65,84.57 152.65,83.85
  IN4 w0.152: v1(148.86,55.45) 147.74,56.57 147.74,59.18 147.88,59.32 147.88,66.17 152.65,70.93 152.65,83.85
  BOTTOM w0.076: CPU1.AH3 153.48,94.61 153.48,89.56 153.15,89.23 v1(152.31,89.23)
  BOTTOM w0.175: v1(148.86,55.45) 147.44,54.04 JDIMM1.144
DDR_A_MA1: length 43.4
  IN4 w0.152: v1(147.3,90.91) 148.83,89.37 148.83,85.84 148.94,85.73 148.94,71.57 144.79,67.42 144.79,62.63 144.91,62.5 144.91,60.92 144.04,60.05 v1(144.04,57.87)
  BOTTOM w0.076: CPU1.AP4 147.88,95.24 147.88,94.35 147.73,94.2 147.73,93.34 147.85,93.21 147.85,91.46 v1(147.3,90.91)
  BOTTOM w0.175: v1(144.04,57.87) 144.69,58.52 JDIMM1.133
DDR_A_MA2: length 48
  IN4 w0.152: v1(149.4,95.21) 148.92,94.72 148.92,91.73 149.74,90.9 149.74,86.01 149.86,85.89 149.86,80.25 150.38,79.73 150.38,71.72 145.7,67.04 145.7,63.01 145.83,62.88 145.83,60.53 144.96,59.67 144.96,56.24 v1(145.62,55.58)
  BOTTOM w0.076: v1(149.4,95.21) 149.08,95.54 CPU1.AN4
  BOTTOM w0.175: JDIMM1.132 144.44,53.23 144.67,53.45 144.67,54.64 v1(145.62,55.58)
DDR_A_MA3: length 47.6
  IN4 w0.152: v1(147.3,91.54) 149.36,89.47 149.36,85.76 149.4,85.72 149.4,80.06 149.92,79.54 149.92,71.9 145.25,67.23 145.25,62.82 145.37,62.69 145.37,60.72 144.5,59.86 144.5,57.06 v1(144.04,56.6)
  BOTTOM w0.076: CPU1.AP5 147.62,95.64 147.62,94.41 147.56,94.34 147.56,92.53 147.67,92.42 147.67,91.92 v1(147.3,91.54)
  BOTTOM w0.175: v1(144.04,56.6) 143.47,57.18 143.47,57.97 144.19,58.7 JDIMM1.131
DDR_A_MA4: length 47.1
  IN4 w0.152: v1(144.05,54.11) 143.29,54.11 142.65,54.75 142.65,59.96 143.49,60.8 143.49,62.6 143.87,62.98 143.87,67.8 148.02,71.95 148.02,85.76 147.92,85.86 147.92,87.06 146.9,88.08 146.9,89.12 v1(147.3,89.51)
  BOTTOM w0.076: v1(147.3,89.51) 147.72,89.94 147.72,90.86 148.05,91.19 148.05,93.31 147.89,93.47 147.89,93.96 CPU1.AP2
  BOTTOM w0.175: JDIMM1.128 143.44,53.5 v1(144.05,54.11)
DDR_A_MA5: length 46.1
  IN4 w0.152: v1(144.05,55.33) 143.11,56.26 143.11,59.76 143.95,60.61 143.95,62.41 144.33,62.79 144.33,67.61 148.48,71.76 148.48,85.68 148.38,85.79 148.38,87.83 v1(147.33,88.88)
  BOTTOM w0.076: v1(147.33,88.88) 147.38,88.88 147.97,89.47 147.97,90.65 148.26,90.94 148.26,93.5 CPU1.AP1
  BOTTOM w0.175: v1(144.05,55.33) 143.43,55.33 142.94,54.84 JDIMM1.126
DDR_A_MA6: length 48.4
  IN4 w0.152: v1(141.72,56.52) 142.19,56.99 142.19,60.15 143.03,60.99 143.03,62.79 143.42,63.17 143.42,63.58 143.26,63.73 143.09,63.73 142.94,63.88 142.94,64.19 143.09,64.34 143.26,64.34 143.42,64.49 143.42,67.99 147.56,72.14 147.56,85.71 147.47,85.81 147.47,86.82 v1(146.16,88.13)
  BOTTOM w0.076: v1(146.16,88.13) 146.4,87.89 147.44,87.89 148.28,88.73 148.28,90.45 148.49,90.66 148.49,93.26 148.45,93.29 148.45,94.61 CPU1.AP3
  BOTTOM w0.175: JDIMM1.127 143.19,58.6 142.98,58.39 142.98,57.47 142.03,56.52 v1(141.72,56.52)
DDR_A_MA7: length 49
  IN4 w0.152: v1(146.16,86.22) 146.42,86.22 146.64,86 146.64,73.54 143.06,69.95 143.06,69.73 143.33,69.45 143.33,69.23 143.11,69.02 142.9,69.02 142.62,69.29 142.4,69.29 142.02,68.92 142.02,68.61 142.15,68.49 142.35,68.49 142.5,68.33 142.5,68.03 142.38,67.9 142.19,67.9 142.02,67.74 142.02,63.12 141.27,62.37 141.27,62.15 141.43,61.99 141.59,61.99 141.74,61.84 141.74,61.53 141.59,61.38 141.41,61.38 141.26,61.23 141.26,55.33 141.42,55.17 v1(141.72,55.17)
  BOTTOM w0.076: v1(146.16,86.22) 146.68,86.22 148.91,88.45 CPU1.AN1
  BOTTOM w0.175: v1(141.72,55.17) 142.07,55.17 142.26,54.98 142.26,53.39 141.94,53.07 JDIMM1.122
DDR_A_MA8: length 49.2
  IN4 w0.152: v1(141.73,57.88) 141.73,60.33 142.57,61.17 142.57,62.8 142.48,62.9 142.48,64.63 142.63,64.78 142.81,64.78 142.96,64.94 142.96,65.24 142.81,65.39 142.63,65.39 142.48,65.54 142.48,65.85 142.63,66 142.81,66 142.96,66.15 142.96,66.46 142.81,66.61 142.63,66.61 142.48,66.76 142.48,67.13 142.63,67.28 142.81,67.28 142.96,67.43 142.96,68.21 144.09,69.34 144.09,69.56 143.82,69.83 143.82,70.06 144.13,70.38 144.35,70.38 144.61,70.11 144.83,70.11 145.05,70.33 145.05,70.55 144.79,70.81 144.79,71.03 145.01,71.25 145.23,71.25 145.52,70.96 145.74,70.96 145.96,71.18 145.96,71.4 145.66,71.69 145.66,71.91 145.88,72.13 146.1,72.13 146.4,71.83 146.61,71.83 146.84,72.06 146.84,72.27 146.54,72.57 146.54,72.79 147.1,73.35 147.1,86.56 146.8,86.86 v1(146.16,86.86)
  BOTTOM w0.076: v1(146.16,86.86) 146.87,86.86 148.69,88.68 148.69,93.29 148.63,93.35 148.63,94.61 CPU1.AN3
  BOTTOM w0.175: JDIMM1.125 142.69,58.84 142.5,58.65 142.5,58.12 142.26,57.88 v1(141.73,57.88)
DDR_A_MA9: length 46.7
  IN4 w0.152: v1(146.84,95.21) 145.72,94.1 145.72,73.92 141.1,69.3 141.1,63.5 140.34,62.74 140.34,56.88 v1(139.85,56.39)
  BOTTOM w0.076: v1(146.84,95.21) 146.51,95.54 CPU1.AT4
  BOTTOM w0.175: v1(139.85,56.39) 141.29,57.83 141.29,58.5 141.69,58.9 JDIMM1.121
DDR_A_MA10: length 46.5
  IN4 w0.089: 154.22,83.85 154.22,84.77 153.12,85.87 153.12,90.64 152.68,91.07 v1(152.31,91.07)
  IN4 w0.152: v1(148.86,53.93) 149.47,54.54 149.47,62.18 150.46,63.18 150.46,66.52 154.22,70.28 154.22,83.85
  BOTTOM w0.076: CPU1.AH2 152.91,93.94 152.91,91.67 v1(152.31,91.07)
  BOTTOM w0.175: v1(148.86,53.93) 149.94,52.84 JDIMM1.146
DDR_A_MA11: length 50.4
  IN4 w0.152: v1(146.16,84.95) 146.18,84.93 146.18,73.73 141.56,69.11 141.56,63.31 140.8,62.55 140.8,53.13 140.93,53 142.35,53 142.5,53.16 142.5,53.82 142.35,53.98 v1(141.73,53.98)
  BOTTOM w0.076: CPU1.AN2 149.26,93.88 v2(149.26,89.76) 149.26,88.05 v1(146.16,84.95)
  BOTTOM w0.175: v1(141.73,53.98) 141.44,53.69 JDIMM1.120
DDR_A_MA12: length 47.5
  IN4 w0.152: v1(139.85,57.74) 139.6,57.74 139.45,57.9 139.45,58.72 139.6,58.87 139.73,58.87 139.88,59.03 139.88,59.34 139.73,59.49 139.6,59.49 139.45,59.65 139.45,59.96 139.6,60.11 139.73,60.11 139.88,60.27 139.88,60.58 139.73,60.73 139.6,60.73 139.45,60.89 139.45,62.79 139.79,63.13 140.09,63.13 140.64,63.69 140.64,69.49 145.26,74.11 145.26,85.85 145.42,86.01 145.42,92.3 145.15,92.57 v1(144.46,92.57)
  BOTTOM w0.076: CPU1.AU4 145.42,95.54 145.21,95.32 145.21,92.4 144.98,92.17 144.75,92.17 144.46,92.45 v1(144.46,92.57)
  BOTTOM w0.175: v1(139.85,57.74) 140.03,57.56 140.34,57.56 140.81,58.03 140.81,58.53 141.19,58.92 JDIMM1.119
DDR_A_MA13: length 51.5
  IN4 w0.152: v1(154.82,89.86) 155.41,89.86 155.71,89.57 155.71,87.73 159.1,84.34 159.1,67.95 154.87,63.73 154.87,58.99 154.71,58.83 154.71,55.45 155.46,54.71 155.46,53.27 155.3,53.11 154.83,53.11 154.67,53.27 154.67,53.79 154.52,53.94 154.21,53.94 154.05,53.79 154.05,53.27 153.9,53.11 v1(153.45,53.11)
  BOTTOM w0.076: v1(154.82,89.86) 154.96,89.86 v2(155.73,90.63) 155.99,90.9 155.99,94.61 CPU1.AE3
  BOTTOM w0.175: v1(153.45,53.11) 153.41,53.11 152.94,52.64 JDIMM1.158
DDR_A_PAR: length 50
  IN4 w0.089: v1(152.29,88.61) 152.6,88.61 152.76,88.45 152.76,85.09 153.2,84.64
  IN4 w0.152: 153.2,84.64 153.2,70.7 148.44,65.94 148.44,58.93 148.3,58.78 148.3,57.53 v1(148.86,56.97)
  BOTTOM w0.076: CPU1.AG3 153.64,94.59 153.64,88.52 152.6,87.47 151.84,87.47 151.65,87.66 151.65,88.36 151.9,88.61 v1(152.29,88.61)
  BOTTOM w0.175: v1(148.86,56.97) 148.43,56.55 147.52,56.55 147.19,56.87 JDIMM1.143
DDR_A_RAS#: length 48.9
  IN4 w0.089: v1(154.38,95.74) 153.47,94.83 153.47,86.28 155.14,84.62 155.14,83.85
  IN4 w0.152: 155.14,83.85 155.14,69.89 151.38,66.14 151.38,62.8 150.92,62.34 150.92,61.97 150.38,61.43 150.38,55.72 v1(150.91,55.2)
  BOTTOM w0.076: v1(154.38,95.74) 154.27,95.85 153.51,95.85 CPU1.AH4
  BOTTOM w0.175: JDIMM1.152 151.44,53.24 151.66,53.45 151.66,54.45 v1(150.91,55.2)
DDR_A_WE#: length 50.5
  IN4 w0.089: 155.59,83.85 155.59,84.54 153.65,86.48 153.65,94.41 v1(154.38,95.14)
  IN4 w0.152: 155.59,83.85 155.59,68.63 155.39,68.42 155.16,68.42 154.85,68.73 154.63,68.73 154.41,68.51 154.41,68.3 154.73,67.97 154.73,67.76 154.51,67.54 154.29,67.54 153.98,67.85 153.74,67.85 153.53,67.64 153.53,67.42 153.85,67.1 153.85,66.88 153.63,66.66 153.41,66.66 153.11,66.96 152.85,66.96 152.65,66.76 152.65,66.54 152.97,66.22 152.97,66 152.75,65.78 152.54,65.78 152.28,66.04 152.06,66.04 151.84,65.82 151.84,65.6 152.09,65.35 152.09,65.12 151.84,64.87 151.84,62.61 151.38,62.15 151.38,60.83 151.22,60.67 151,60.67 150.84,60.52 150.84,60.21 151,60.05 151.22,60.05 151.38,59.9 151.38,59.62 151.22,59.46 151,59.46 150.84,59.31 150.84,59 151,58.84 151.22,58.84 151.38,58.69 151.38,58.4 151.22,58.24 v1(150.91,58.24)
  BOTTOM w0.076: v1(154.38,95.14) 154.35,95.17 153.56,95.17 153.49,95.24 153.49,95.46 153.56,95.54 CPU1.AG4
  BOTTOM w0.175: v1(150.91,58.24) 151.18,57.98 151.43,57.98 151.61,58.16 151.61,58.81 151.19,59.22 JDIMM1.151
DDR_B_ACT#: length 67.1
  IN1 w0.089: v1(146.09,98.47) 145.34,97.72 145.34,91.45 143.9,90.01 143.9,86.46 141.91,84.46 141.91,83.85
  IN1 w0.152: 141.91,83.85 141.91,81.53 136.29,75.92 136.29,63.04 136.08,62.83 136.08,59.98 135.49,59.39 135.49,51.21 135.07,50.79 135.07,43.99 v1(136.66,42.4)
  BOTTOM w0.076: v1(146.09,98.47) CPU1.AT9
  BOTTOM w0.175: JDIMM2.114 139.94,39.88 137.42,42.4 v1(136.66,42.4)
DDR_B_ALERT#: length 65
  IN1 w0.089: 144.18,83.85 144.18,85.14 145.04,86.01 145.04,87.86 146.31,89.13 146.31,91.79 147.47,92.95 147.47,97.05 147.57,97.15 147.73,97.31 147.73,98.28 v1(147.92,98.47)
  IN1 w0.152: 144.18,83.85 144.18,80.59 138.66,75.08 138.66,59.14 138.15,58.63 138.15,46.72 138.68,46.19 138.68,43.34 v1(139.72,42.3)
  BOTTOM w0.076: v1(147.92,98.47) CPU1.AR8
  BOTTOM w0.175: v1(139.72,42.3) 140.44,41.58 JDIMM2.116
DDR_B_BG0: length 62.9
  IN1 w0.089: 143.39,83.85 143.39,84.95 144.79,86.35 144.79,87.85 145.99,89.05 145.99,91.77 147.29,93.07 147.29,97.13 147.39,97.23 147.46,97.3 147.46,98.26 147.25,98.48 v1(147.02,98.48)
  IN1 w0.152: v1(138.12,44.94) 136.97,46.08 136.97,58.78 137.56,59.36 137.56,62.22 137.77,62.42 137.77,75.3 143.39,80.92 143.39,83.85
  BOTTOM w0.076: v1(147.02,98.48) 147.34,98.8 CPU1.AR9
  BOTTOM w0.175: v1(138.12,44.94) 138.2,45.03 139.09,45.03 140.19,46.14 JDIMM2.115
DDR_B_BG1: length 64.6
  IN1 w0.089: v1(146.88,97.11) 145.81,96.04 145.81,89.26 144.53,87.98 144.53,86.35 142.93,84.74 142.93,83.85
  IN1 w0.152: 142.93,83.85 142.93,81.11 137.31,75.49 137.31,62.62 137.1,62.41 137.1,59.55 136.51,58.97 136.51,45.29 v1(138.13,43.67)
  BOTTOM w0.076: CPU1.AR7 147.27,97.5 v1(146.88,97.11)
  BOTTOM w0.175: JDIMM2.113 139.69,46.36 138.85,45.51 137.71,45.51 137.42,45.22 137.42,44.38 v1(138.13,43.67)
DDR_B_BS0: length 67.7
  IN1 w0.089: v1(153.41,98.47) 153.81,98.07 153.81,97.68 153.66,97.54 153.66,94.13 154.07,93.72 154.07,86.82 155.24,85.65 155.24,83.85
  IN1 w0.152: v1(150.99,41.13) 150.62,41.5 149.52,41.5 149.37,41.65 149.37,41.95 149.52,42.1 149.9,42.1 150.05,42.26 150.05,42.57 149.9,42.72 149.52,42.72 149.37,42.88 149.37,46.13 149.28,46.22 149.28,49.38 149.43,49.53 149.8,49.53 149.96,49.69 149.96,50 149.8,50.15 149.43,50.15 149.28,50.31 149.28,50.74 149.43,50.9 150.15,50.9 150.3,51.05 150.3,59.26 149.71,59.85 149.71,68.77 155.24,74.3 155.24,83.85
  BOTTOM w0.076: v1(153.41,98.47) CPU1.AH8
  BOTTOM w0.175: JDIMM2.150 150.94,41.08 v1(150.99,41.13)
DDR_B_BS1: length 67.5
  IN1 w0.089: v1(152.49,98.44) 152.93,98.44 153.04,98.33 153.04,96.99 153.31,96.73 153.31,93.98 153.68,93.61 153.68,86.14 154.32,85.5 154.32,83.85
  IN1 w0.152: 154.32,83.85 154.32,76.39 154.17,76.23 153.89,76.23 153.74,76.08 153.74,75.77 153.89,75.61 154.17,75.61 154.32,75.46 154.32,74.68 150,70.36 149.78,70.36 149.25,70.89 149.03,70.89 148.77,70.62 148.77,70.41 149.3,69.88 149.3,69.69 148.71,69.1 148.71,59.42 149.29,58.84 149.29,52.19 148.36,51.26 148.36,45.81 v1(148.47,45.7)
  BOTTOM w0.076: v1(152.49,98.44) 152.85,98.8 CPU1.AH9
  BOTTOM w0.175: v1(148.47,45.7) 148.15,45.7 148,45.85 148,47.99 148.18,48.17 148.67,48.17 148.85,47.99 148.85,46.14 149.03,45.96 149.52,45.96 149.69,46.14 JDIMM2.145
DDR_B_CAS#: length 70.4
  IN1 w0.089: v1(155.24,98.48) 154.85,98.1 154.85,97.68 155.2,97.33 155.2,94.76 156.04,93.92 156.04,87.96 157.74,86.27 157.74,83.85
  IN1 w0.152: v1(153.61,41.89) 153.18,41.45 152.64,41.45 152.29,41.81 152.29,48.48 153.13,49.32 153.13,51.05 154.39,52.32 154.39,55.96 154.24,56.12 153.94,56.12 153.78,56.27 153.78,56.58 153.94,56.73 154.24,56.73 154.39,56.89 154.39,57.2 154.24,57.35 153.94,57.35 153.78,57.51 153.78,57.82 153.94,57.97 154.24,57.97 154.39,58.13 154.39,59.64 153.97,60.07 153.75,60.07 153.49,59.81 153.27,59.81 153.05,60.03 153.05,60.25 153.31,60.5 153.31,60.72 152.86,61.17 152.86,62.07 152.21,62.71 152.21,67.72 157.74,73.25 157.74,83.85
  BOTTOM w0.076: v1(155.24,98.48) CPU1.AF8
  BOTTOM w0.175: JDIMM2.156 152.44,40.82 153.52,41.89 v1(153.61,41.89)
DDR_B_D0: length 73.3
  IN1 w0.097: v1(112.06,45.39) 112.06,48.57 111.72,48.91 111.72,50.52 112.27,51.07 112.27,51.48 112.37,51.58 112.97,51.58 113.06,51.68 113.06,51.87 112.97,51.97 112.37,51.97 112.27,52.07 112.27,52.27 112.37,52.37 112.97,52.37 113.06,52.47 113.06,52.67 112.97,52.76 112.37,52.76 112.27,52.86 112.27,53.06 112.37,53.16 112.97,53.16 113.06,53.26 113.06,53.46 112.97,53.56 112.37,53.56 112.27,53.66 112.27,59.01 112.37,59.11 112.97,59.11 113.06,59.21 113.06,59.41 112.97,59.51 112.37,59.51 112.27,59.61 112.27,59.81 112.37,59.91 112.97,59.91 113.06,60.01 113.06,60.2 112.97,60.3 112.37,60.3 112.27,60.4 112.27,63.48 118.61,69.82 118.61,81.62 126.92,89.93 126.92,96.8 130.07,99.95 130.44,99.95 v1(130.45,99.94)
  BOTTOM w0.076: v1(130.45,99.94) 130.47,99.92 131.5,99.92 131.62,100.04 CPU1.BT11
  BOTTOM w0.107: JDIMM2.3 112.19,45.53 v1(112.06,45.39)
DDR_B_D1: length 73.3
  IN1 w0.097: v1(112.06,42.85) 112.53,43.33 112.53,50.63 113.37,51.47 113.37,58.45 113.47,58.55 113.65,58.55 113.75,58.65 113.75,58.84 113.65,58.94 113.47,58.94 113.37,59.04 113.37,59.24 113.47,59.34 113.65,59.34 113.75,59.44 113.75,59.64 113.65,59.74 113.47,59.74 113.37,59.84 113.37,60.03 113.47,60.13 113.65,60.13 113.75,60.23 113.75,60.43 113.65,60.53 113.47,60.53 113.37,60.63 113.37,62.98 118.91,68.52 118.91,81.49 127.22,89.8 127.22,96.67 129.46,98.91 v1(129.95,98.91)
  BOTTOM w0.076: v1(129.95,98.91) 130.43,98.91 131.25,99.73 132.47,99.73 132.77,100.04 CPU1.BR11
  BOTTOM w0.107: v1(112.06,42.85) 113.44,41.47 JDIMM2.8
DDR_B_D2: length 72.9
  IN1 w0.097: v1(130.17,97.31) 130.35,97.13 130.35,96.58 129.29,95.52 129.29,89.75 120.6,81.05 120.6,67.55 116.34,63.3 116.34,61.04 116.05,60.75 115.54,60.75 115.44,60.65 115.44,60.39 115.54,60.29 115.97,60.29 116.06,60.19 116.06,59.96 115.97,59.86 115.54,59.86 115.44,59.76 115.44,59.57 115.54,59.47 115.97,59.47 116.06,59.37 116.06,59.17 115.97,59.07 115.54,59.07 115.44,58.97 115.44,58.77 115.54,58.68 115.97,58.68 116.06,58.58 116.06,53.67 115.97,53.57 115.54,53.57 115.44,53.47 115.44,53.27 115.54,53.17 115.97,53.17 116.06,53.07 116.06,52.87 115.97,52.78 115.54,52.78 115.44,52.68 115.44,52.48 115.54,52.38 115.97,52.38 116.06,52.28 116.06,52 115.07,51 115.07,50.35 114.94,50.23 114.94,46.3 114.64,46 114.64,41.9 v1(115.34,41.2)
  BOTTOM w0.076: CPU1.BT8 132.11,97.99 131.5,97.99 131.03,97.53 130.7,97.53 130.44,97.27 130.21,97.27 v1(130.17,97.31)
  BOTTOM w0.107: v1(115.34,41.2) 115.45,41.1 JDIMM2.16
DDR_B_D3: length 73.2
  IN1 w0.097: v1(130.45,97.78) 130.64,97.59 130.64,96.54 129.63,95.53 129.63,89.66 122.52,82.55 122.52,81.14 120.9,79.52 120.9,67.43 116.64,63.17 116.64,59.57 116.37,59.29 116.37,51.35 116.27,51.25 115.8,51.25 115.71,51.15 115.71,50.95 115.8,50.85 116.27,50.85 116.37,50.75 116.37,50.11 116.27,50.01 115.34,50.01 115.24,49.92 115.24,49.65 115.34,49.55 116.27,49.55 116.37,49.46 116.37,49.22 116.27,49.12 115.76,49.12 115.66,49.02 115.66,48.6 115.56,48.5 115.34,48.5 115.24,48.4 115.24,48.21 115.34,48.11 115.56,48.11 115.66,48.01 115.66,47.81 115.56,47.71 115.34,47.71 115.24,47.61 115.24,47.41 115.34,47.31 115.9,47.31 116,47.22 116,46.99 115.91,46.9 115.37,46.9 115.24,46.77 115.24,46.18 114.94,45.87 114.94,44.14 v1(115.34,43.74)
  BOTTOM w0.076: v1(130.45,97.78) 130.5,97.73 131.01,97.73 131.43,98.16 131.88,98.16 132.29,98.57 132.9,98.57 CPU1.BR8
  BOTTOM w0.107: JDIMM2.21 116.69,45.09 v1(115.34,43.74)
DDR_B_D4: length 73.5
  IN1 w0.097: v1(112.06,44.12) 111.42,44.76 111.42,45.67 111.52,45.77 111.66,45.77 111.76,45.87 111.76,46.07 111.66,46.17 111.52,46.17 111.42,46.27 111.42,46.46 111.52,46.56 111.66,46.56 111.76,46.66 111.76,46.86 111.66,46.96 111.52,46.96 111.42,47.06 111.42,47.26 111.52,47.36 111.66,47.36 111.76,47.46 111.76,47.65 111.66,47.75 111.52,47.75 111.42,47.85 111.42,48.05 111.52,48.15 111.66,48.15 111.76,48.25 111.76,48.45 111.66,48.55 111.52,48.55 111.42,48.64 111.42,50.65 111.97,51.2 111.97,63.61 118.31,69.95 118.31,81.75 126.62,90.05 126.62,96.92 130.09,100.4 130.75,100.4 v1(130.78,100.37)
  BOTTOM w0.076: CPU1.BP11 133.36,100.33 131.68,100.33 131.43,100.08 131.14,100.08 130.85,100.37 v1(130.78,100.37)
  BOTTOM w0.107: v1(112.06,44.12) 112.59,44.65 112.59,45.41 113.19,46.02 JDIMM2.7
DDR_B_D5: length 73.5
  IN1 w0.097: v1(131.32,100.47) 131.32,100.28 130.55,99.51 130.55,98.99 130.08,98.52 129.5,98.52 127.52,96.55 127.52,89.68 119.21,81.37 119.21,68.4 113.71,62.9 113.71,61.08 114.05,60.74 114.05,58.04 113.67,57.66 113.67,51.34 112.83,50.5 112.83,42.36 v1(112.06,41.58)
  BOTTOM w0.076: CPU1.BN11 134.07,100.04 133.57,100.53 131.38,100.53 v1(131.32,100.47)
  BOTTOM w0.107: v1(112.06,41.58) 112.44,41.2 JDIMM2.4
DDR_B_D6: length 73.2
  IN1 w0.097: v1(115.34,45.01) 115.34,45.8 116.67,47.12 116.67,47.48 116.57,47.57 116.06,47.57 115.96,47.67 115.96,47.87 116.06,47.97 116.57,47.97 116.67,48.07 116.67,59.17 116.94,59.44 116.94,63.05 121.2,67.3 121.2,67.62 121.3,67.72 121.61,67.72 121.71,67.82 121.71,68.01 121.61,68.11 121.3,68.11 121.2,68.21 121.2,68.41 121.3,68.51 121.61,68.51 121.71,68.61 121.71,68.81 121.61,68.91 121.3,68.91 121.2,69 121.2,69.2 121.3,69.3 121.61,69.3 121.71,69.4 121.71,69.6 121.61,69.7 121.3,69.7 121.2,69.8 121.2,70 121.3,70.09 121.61,70.09 121.71,70.19 121.71,70.39 121.61,70.49 121.3,70.49 121.2,70.59 121.2,73.92 121.29,74.02 121.53,74.02 121.63,74.11 121.63,74.31 121.53,74.4 121.29,74.4 121.2,74.5 121.2,74.69 121.29,74.79 121.53,74.79 121.63,74.89 121.63,75.08 121.53,75.18 121.29,75.18 121.2,75.27 121.2,75.46 121.29,75.56 121.53,75.56 121.63,75.66 121.63,75.85 121.53,75.95 121.29,75.95 121.2,76.04 121.2,76.24 121.29,76.33 121.53,76.33 121.63,76.43 121.63,76.62 121.53,76.72 121.29,76.72 121.2,76.82 121.2,77.01 121.29,77.11 121.53,77.11 121.63,77.2 121.63,79.82 122.82,81.02 122.82,82.43 130.45,90.05 130.45,90.98 132.21,92.74 132.21,97.39 131.27,98.33 131.27,98.53 v1(131.2,98.59)
  BOTTOM w0.076: CPU1.BP8 133.36,98.75 132.25,98.75 131.82,98.32 131.47,98.32 v1(131.2,98.59)
  BOTTOM w0.107: JDIMM2.17 115.69,45.36 v1(115.34,45.01)
DDR_B_D7: length 73.4
  IN1 w0.097: v1(131.74,98.81) 131.78,98.76 131.78,98.2 132.41,97.57 132.41,92.61 130.7,90.91 130.7,89.83 123.12,82.25 123.12,80.89 121.93,79.7 121.93,73.82 121.83,73.72 121.59,73.72 121.5,73.63 121.5,73.43 121.59,73.34 121.83,73.34 121.93,73.24 121.93,72.96 121.83,72.86 121.6,72.86 121.5,72.77 121.5,72.57 121.6,72.47 121.91,72.47 122.01,72.37 122.01,72.17 121.91,72.07 121.6,72.07 121.5,71.97 121.5,71.77 121.6,71.68 121.91,71.68 122.01,71.58 122.01,71.38 121.91,71.28 121.6,71.28 121.5,71.18 121.5,70.98 121.6,70.88 121.91,70.88 122.01,70.78 122.01,67.69 117.24,62.92 117.24,59.31 116.97,59.04 116.97,47 116.16,46.19 116.16,43.28 v1(115.34,42.47)
  BOTTOM w0.076: CPU1.BN8 134.01,98.75 133.66,98.75 133.49,98.92 131.87,98.92 131.84,98.89 131.82,98.89 v1(131.74,98.81)
  BOTTOM w0.107: v1(115.34,42.47) 116.45,41.37 JDIMM2.20
DDR_B_D8: length 71.4
  IN1 w0.097: v1(117.63,41.2) 116.92,41.9 116.92,45.91 118.33,47.32 118.33,53.33 117.88,53.78 117.88,58.91 118.52,59.55 118.52,63.17 123.21,67.86 123.21,71.71 122.77,72.15 122.77,72.41 122.87,72.51 123.12,72.51 123.21,72.61 123.21,72.8 123.12,72.9 122.87,72.9 122.77,72.99 122.77,74.32 122.66,74.43 122.66,79.39 123.85,80.59 123.85,81.95 130.89,88.99 130.89,90.77 132.99,92.87 132.99,96.8 134.41,98.23 134.41,99.19 135.28,100.06 v1(135.28,100.43)
  BOTTOM w0.076: CPU1.BL12 135.61,100.76 v1(135.28,100.43)
  BOTTOM w0.107: v1(117.63,41.2) 117.45,41.01 JDIMM2.24
DDR_B_D9: length 71.8
  IN1 w0.097: v1(117.63,42.47) 117.23,42.87 117.23,45.79 118.63,47.19 118.63,53.45 118.18,53.9 118.18,58.79 118.82,59.42 118.82,63.05 123.51,67.74 123.51,73.19 123.42,73.29 123.17,73.29 123.07,73.39 123.07,73.58 123.17,73.68 123.42,73.68 123.51,73.77 123.51,74 122.96,74.55 122.96,79.26 124.15,80.46 124.15,81.82 131.13,88.81 131.13,90.57 133.17,92.61 133.17,96.73 134.64,98.19 134.64,98.87 136.08,100.31 v1(136.08,100.42)
  BOTTOM w0.076: v1(136.08,100.42) CPU1.BL11
  BOTTOM w0.107: v1(117.63,42.47) 118.45,41.65 JDIMM2.28
DDR_B_D10: length 71.6
  IN1 w0.097: v1(135.28,98.86) 134.87,98.44 134.87,98.15 133.36,96.65 133.36,92.48 131.32,90.44 131.32,88.57 124.45,81.7 124.45,80.33 123.31,79.19 123.31,78.28 123.54,78.05 123.72,78.05 123.81,77.95 123.81,77.76 123.72,77.66 123.35,77.66 123.26,77.56 123.26,77.37 123.35,77.27 123.72,77.27 123.81,77.18 123.81,76.98 123.72,76.89 123.35,76.89 123.26,76.79 123.26,76.6 123.35,76.5 123.72,76.5 123.81,76.41 123.81,76.21 123.72,76.12 123.35,76.12 123.26,76.02 123.26,75.83 123.35,75.73 123.72,75.73 123.81,75.63 123.81,75.44 123.72,75.34 123.35,75.34 123.26,75.25 123.26,74.68 123.81,74.12 123.81,67.61 119.12,62.92 119.12,60.9 119.22,60.81 119.58,60.81 119.68,60.71 119.68,60.52 119.58,60.42 119.22,60.42 119.12,60.32 119.12,60.13 119.22,60.03 119.58,60.03 119.68,59.94 119.68,59.74 119.58,59.65 119.22,59.65 119.12,59.55 119.12,59.3 118.48,58.66 118.48,58.34 118.58,58.24 118.93,58.24 119.03,58.14 119.03,57.95 118.93,57.85 118.58,57.85 118.48,57.75 118.48,57.55 118.58,57.45 118.93,57.45 119.03,57.35 119.03,57.15 118.93,57.05 118.58,57.05 118.48,56.95 118.48,54.02 118.93,53.58 118.93,47.07 117.63,45.76 v1(117.63,45.01)
  BOTTOM w0.076: v1(135.28,98.86) CPU1.BL8
  BOTTOM w0.107: v1(117.63,45.01) 117.69,45.07 JDIMM2.25
DDR_B_D11: length 71.8
  IN1 w0.097: v1(136.95,98.47) 136.54,98.07 136.54,97.56 137.55,96.55 137.55,92.43 137.24,92.12 137.24,92.1 135.47,90.34 135.47,87.98 132.36,84.86 132.14,84.86 126.71,79.43 126.71,67.52 122.24,63.06 122.24,58.6 122.05,58.41 122.05,46.21 121.8,45.97 121.8,43.35 121.64,43.19 121.52,43.19 121.42,43.09 121.42,42.89 121.52,42.79 121.75,42.79 121.85,42.69 121.85,42.47 121.75,42.37 121.53,42.37 121.42,42.26 121.42,42.07 121.52,41.97 121.7,41.97 121.8,41.87 121.8,41.66 121.7,41.56 121.09,41.56 120.99,41.66 120.99,42.06 v1(120.59,42.47)
  BOTTOM w0.076: v1(136.95,98.47) CPU1.BJ8
  BOTTOM w0.107: JDIMM2.42 121.94,41.33 120.81,42.47 v1(120.59,42.47)
DDR_B_D12: length 71.1
  IN1 w0.097: v1(120.59,45.01) 120.59,45.61 121.45,46.46 121.45,47.44 121.35,47.54 120.96,47.54 120.86,47.64 120.86,47.84 120.96,47.94 121.35,47.94 121.45,48.04 121.45,58.66 121.64,58.85 121.64,63.31 125.32,66.99 125.32,67.63 125.42,67.73 125.76,67.73 125.86,67.82 125.86,68.02 125.76,68.12 125.42,68.12 125.32,68.22 125.32,68.42 125.42,68.52 125.76,68.52 125.86,68.62 125.86,68.82 125.76,68.91 125.42,68.91 125.32,69.01 125.32,69.21 125.42,69.31 125.76,69.31 125.86,69.41 125.86,69.61 125.76,69.71 125.42,69.71 125.32,69.81 125.32,70 125.42,70.1 125.76,70.1 125.86,70.2 125.86,70.4 125.76,70.5 125.42,70.5 125.32,70.6 125.32,70.8 125.42,70.9 125.76,70.9 125.86,70.99 125.86,71.19 125.76,71.29 125.42,71.29 125.32,71.39 125.32,71.59 125.42,71.69 125.76,71.69 125.86,71.79 125.86,71.99 125.76,72.08 125.42,72.08 125.32,72.18 125.32,78.89 133.55,87.12 133.55,89.95 136.48,92.88 136.48,93.88 135.59,94.77 135.59,96.36 136.16,96.93 136.16,98.63 136.53,99 136.53,99.36 v1(136.95,99.77)
  BOTTOM w0.076: v1(136.95,99.77) CPU1.BJ11
  BOTTOM w0.107: JDIMM2.37 120.69,45.11 v1(120.59,45.01)
DDR_B_D13: length 71.3
  IN1 w0.097: v1(120.59,43.74) 120.93,43.74 121.23,44.04 121.23,45.82 121.75,46.34 121.75,58.54 121.94,58.73 121.94,63.19 126.16,67.4 126.16,72.45 126.06,72.55 125.72,72.55 125.62,72.65 125.62,72.85 125.72,72.95 126.06,72.95 126.16,73.05 126.16,73.25 126.06,73.34 125.72,73.34 125.62,73.44 125.62,73.64 125.72,73.74 126.06,73.74 126.16,73.84 126.16,74.04 126.06,74.14 125.72,74.14 125.62,74.24 125.62,77.17 125.71,77.27 126.09,77.27 126.18,77.36 126.18,77.55 126.09,77.65 125.71,77.65 125.62,77.75 125.62,77.94 125.71,78.04 126.09,78.04 126.18,78.13 126.18,78.33 126.09,78.42 125.71,78.42 125.62,78.52 125.62,78.77 126.72,79.87 133.87,87.02 133.87,90 136.67,92.8 136.67,93.96 136.38,94.24 136.38,96.26 136.35,96.3 136.35,98.53 v1(136.95,99.12)
  BOTTOM w0.076: v1(136.95,99.12) CPU1.BJ10
  BOTTOM w0.107: v1(120.59,43.74) 121.69,44.84 JDIMM2.41
DDR_B_D14: length 71.8
  IN1 w0.097: v1(135.32,98.04) 135.32,97.41 134.22,96.3 134.22,94.81 135.28,93.74 135.28,92.66 132.15,89.52 132.15,88.97 124.75,81.58 124.75,80.09 124.11,79.45 124.11,67.49 120.04,63.42 120.04,62.96 119.94,62.86 119.52,62.86 119.42,62.76 119.42,62.57 119.52,62.47 119.94,62.47 120.04,62.38 120.04,62.18 119.94,62.09 119.52,62.09 119.42,61.99 119.42,61.8 119.52,61.7 119.94,61.7 120.04,61.6 120.04,59.42 119.33,58.71 119.33,56.93 118.79,56.39 118.79,54.15 119.23,53.7 119.23,53.31 119.33,53.21 119.5,53.21 119.6,53.11 119.6,52.91 119.5,52.81 119.36,52.81 119.23,52.69 119.23,52.51 119.33,52.42 119.5,52.42 119.6,52.32 119.6,52.12 119.5,52.02 119.36,52.02 119.23,51.9 119.23,51.72 119.33,51.62 119.5,51.62 119.6,51.53 119.6,51.33 119.5,51.23 119.36,51.23 119.23,51.1 119.23,50.09 119.33,50 119.5,50 119.6,49.9 119.6,49.7 119.5,49.6 119.33,49.6 119.23,49.5 119.23,48.09 119.33,47.99 119.5,47.99 119.59,47.89 119.59,47.69 119.5,47.59 119.33,47.59 119.23,47.49 119.23,46.76 118.63,46.15 118.63,44.74 v1(117.63,43.74)
  BOTTOM w0.076: v1(135.32,98.04) CPU1.BL7
  BOTTOM w0.107: v1(117.63,43.74) 118.69,44.8 JDIMM2.29
DDR_B_D15: length 71.8
  IN1 w0.097: v1(136.95,97.82) 137.81,96.96 137.81,92.41 135.7,90.3 135.7,87.67 132.66,84.63 132.33,84.63 127.01,79.3 127.01,67.4 122.55,62.94 122.55,60.32 122.64,60.22 122.98,60.22 123.07,60.12 123.07,59.93 122.98,59.83 122.64,59.83 122.55,59.74 122.55,59.54 122.64,59.45 122.98,59.45 123.07,59.35 123.07,59.16 122.98,59.06 122.64,59.06 122.55,58.96 122.55,53.83 122.78,53.59 122.78,53.2 122.68,53.1 122.45,53.1 122.35,53 122.35,52.8 122.45,52.7 122.68,52.7 122.78,52.6 122.78,52.4 122.68,52.3 122.45,52.3 122.35,52.2 122.35,52.01 122.45,51.91 122.68,51.91 122.78,51.81 122.78,51.61 122.68,51.51 122.45,51.51 122.35,51.41 122.35,51.21 122.45,51.11 122.68,51.11 122.78,51.02 122.78,50.82 122.68,50.72 122.45,50.72 122.35,50.62 122.35,41.78 121.76,41.2 v1(120.59,41.2)
  BOTTOM w0.076: v1(136.95,97.82) CPU1.BJ7
  BOTTOM w0.107: JDIMM2.38 120.94,40.84 v1(120.59,41.2)
DDR_B_D16: length 68.2
  IN1 w0.089: v1(138.78,100.41) 138.23,99.86 138.23,98.35 137.98,98.1 137.98,97.53 138.34,97.16 138.34,92.51 136.08,90.25 136.08,87.79 133.41,85.11 133.41,84.54 132.71,83.85
  IN1 w0.097: v1(122.95,45.01) 123.66,45.72 123.66,46.27 123.76,46.37 124.2,46.37 124.3,46.46 124.3,46.66 124.2,46.75 123.76,46.75 123.66,46.85 123.66,58.15 124.3,58.78 124.3,60.44 124.2,60.54 123.93,60.54 123.83,60.64 123.83,60.83 123.93,60.93 124.2,60.93 124.3,61.02 124.3,61.25 124.2,61.34 123.93,61.34 123.83,61.44 123.83,61.63 123.93,61.73 124.2,61.73 124.3,61.83 124.3,62.02 124.2,62.11 123.93,62.11 123.83,62.21 123.83,62.4 123.93,62.5 124.2,62.5 124.3,62.6 124.3,63.65 127.74,67.09 127.74,78.87 132.71,83.85
  BOTTOM w0.076: v1(138.78,100.41) CPU1.BG11
  BOTTOM w0.107: v1(122.95,45.01) 122.69,45.26 JDIMM2.45
DDR_B_D17: length 68.6
  IN1 w0.089: v1(138.78,99.77) 138.41,99.41 138.41,98.27 138.16,98.02 138.16,97.6 138.52,97.24 138.52,92.44 136.3,90.22 136.3,87.48 133.7,84.88 133.7,84.41 133.14,83.85
  IN1 w0.097: v1(122.95,43.74) 123.39,44.17 123.39,44.94 124.6,46.14 124.6,47.02 124.47,47.15 124.06,47.15 123.96,47.25 123.96,47.48 124.06,47.58 124.31,47.58 124.41,47.67 124.41,47.87 124.31,47.96 124.08,47.96 123.99,48.06 123.99,58.05 124.6,58.66 124.6,63.52 128.04,66.97 128.04,78.75 133.14,83.85
  BOTTOM w0.076: v1(138.78,99.77) CPU1.BG10
  BOTTOM w0.107: v1(122.95,43.74) 123.69,44.48 JDIMM2.49
DDR_B_D18: length 68.7
  IN1 w0.089: 133.57,83.85 134.03,84.31 134.03,84.9 136.5,87.37 136.5,90.17 138.7,92.36 138.7,97.31 138.6,97.42 138.37,97.65 138.37,97.93 138.78,98.34 v1(138.78,98.47)
  IN1 w0.097: 133.57,83.85 128.34,78.62 128.34,66.84 124.89,63.4 124.89,58.53 124.29,57.93 124.29,55.18 124.38,55.08 124.73,55.08 124.83,54.99 124.83,54.8 124.73,54.7 124.42,54.7 124.32,54.6 124.32,48.39 124.89,47.81 124.89,46.02 123.69,44.81 123.69,43.2 v1(122.95,42.47)
  BOTTOM w0.076: v1(138.78,98.47) CPU1.BG8
  BOTTOM w0.107: JDIMM2.50 123.94,41.63 123.11,42.47 v1(122.95,42.47)
DDR_B_D19: length 68.5
  IN1 w0.089: 135.69,83.85 135.69,84.01 140.67,88.99 140.67,96.9 140.06,97.51 140.06,97.97 139.69,98.35 v1(139.69,98.48)
  IN1 w0.097: 135.69,83.85 135.69,83.21 130.17,77.68 130.17,66.01 127.4,63.24 127.4,59.48 127.3,59.38 127.3,59.16 127.4,59.06 127.74,59.06 127.83,58.96 127.83,58.76 127.74,58.66 127.4,58.66 127.3,58.56 127.3,58.37 127.4,58.27 127.74,58.27 127.83,58.17 127.83,57.97 127.74,57.87 127.4,57.87 127.3,57.77 127.3,57.57 127.4,57.47 127.74,57.47 127.83,57.37 127.83,57.18 127.74,57.08 127.4,57.08 127.3,56.98 127.3,56.78 127.4,56.68 127.74,56.68 127.83,56.58 127.83,56.38 127.74,56.28 127.4,56.28 127.3,56.19 127.3,44.41 v1(126.63,43.74)
  BOTTOM w0.076: v1(139.69,98.48) 139.35,98.15 CPU1.BF8
  BOTTOM w0.107: v1(126.63,43.74) 126.19,44.18 JDIMM2.59
DDR_B_D20: length 68.6
  IN1 w0.089: 136.3,83.85 136.3,84.05 141.03,88.78 141.03,97.05 140.47,97.61 140.47,98.14 140.24,98.37 140.24,99.86 v1(139.69,100.41)
  IN1 w0.097: 136.3,83.85 136.3,82.95 130.77,77.43 130.77,65.76 128.64,63.63 128.64,59.7 128.44,59.5 128.44,55.04 127.91,54.51 127.91,42.47 v1(126.63,41.2)
  BOTTOM w0.076: v1(139.69,100.41) CPU1.BF11
  BOTTOM w0.107: JDIMM2.62 126.94,40.89 v1(126.63,41.2)
DDR_B_D21: length 68.7
  IN1 w0.089: v1(139.69,99.77) 140.07,99.4 140.07,98.26 140.26,98.06 140.26,97.56 140.85,96.97 140.85,88.92 136,84.06 136,83.85
  IN1 w0.097: 136,83.85 136,83.08 130.47,77.55 130.47,65.89 128.34,63.76 128.34,59.83 128.14,59.63 128.14,56.26 127.61,55.73 127.61,55.5 127.71,55.4 127.97,55.4 128.07,55.3 128.07,55.11 127.97,55.01 127.71,55.01 127.61,54.91 127.61,43.44 v1(126.63,42.47)
  BOTTOM w0.076: v1(139.69,99.77) CPU1.BF10
  BOTTOM w0.107: JDIMM2.58 125.94,41.78 v1(126.63,42.47)
DDR_B_D22: length 68
  IN1 w0.089: 134,83.85 134.34,84.19 134.34,84.82 136.7,87.19 136.7,90.12 138.89,92.3 138.89,97.71 v1(138.78,97.82)
  IN1 w0.097: 134,83.85 128.64,78.5 128.64,66.72 125.19,63.27 125.19,45.9 123.99,44.69 123.99,42.59 124.09,42.49 124.29,42.49 124.39,42.39 124.39,42.19 124.29,42.09 123.96,42.09 123.86,41.99 123.86,41.79 123.96,41.69 124.24,41.69 124.34,41.6 124.34,41.32 124.22,41.2 v1(122.95,41.2)
  BOTTOM w0.076: v1(138.78,97.82) CPU1.BG7
  BOTTOM w0.107: v1(122.95,41.2) 122.94,41.19 JDIMM2.46
DDR_B_D23: length 68.3
  IN1 w0.089: 135.39,83.85 135.39,84.04 140.49,89.14 140.49,96.78 139.69,97.58 v1(139.69,97.82)
  IN1 w0.097: 135.39,83.85 135.39,83.33 129.87,77.81 129.87,66.14 127.1,63.37 127.1,60.97 127,60.87 126.6,60.87 126.5,60.77 126.5,60.58 126.6,60.48 127,60.48 127.1,60.39 127.1,60.16 127,60.07 126.6,60.07 126.5,59.97 126.5,59.78 126.6,59.68 126.91,59.68 127,59.59 127,59.39 126.9,59.29 126.6,59.29 126.5,59.19 126.5,58.99 126.6,58.89 126.9,58.89 127,58.79 127,53.51 126.9,53.41 126.71,53.41 126.61,53.31 126.61,53.11 126.71,53.01 126.9,53.01 127,52.92 127,52.72 126.9,52.62 126.71,52.62 126.61,52.52 126.61,52.32 126.71,52.22 126.9,52.22 127,52.12 127,51.92 126.9,51.83 126.71,51.83 126.61,51.73 126.61,51.53 126.71,51.43 126.9,51.43 127,51.33 127,49.91 126.9,49.81 126.71,49.81 126.61,49.72 126.61,49.52 126.71,49.42 126.9,49.42 127,49.32 127,48.1 126.9,48 126.71,48 126.61,47.9 126.61,47.7 126.71,47.6 126.9,47.6 127,47.51 127,47.31 126.9,47.21 126.71,47.21 126.61,47.11 126.61,46.91 126.71,46.81 126.9,46.81 127,46.71 127,46.52 126.9,46.42 126.71,46.42 126.61,46.32 126.61,46.12 126.71,46.02 126.9,46.02 127,45.92 127,45.38 v1(126.63,45.01)
  BOTTOM w0.076: v1(139.69,97.82) CPU1.BF7
  BOTTOM w0.107: v1(126.63,45.01) 127.19,45.57 JDIMM2.63
DDR_B_D24: length 67.9
  IN1 w0.089: 140.17,83.85 140.17,84.25 141.36,85.44 141.87,85.44 143.43,87 143.43,90.12 143.96,90.65 143.96,97.32 142.98,98.3 142.98,99.88 v1(142.43,100.42)
  IN1 w0.097: v1(132.17,41.2) 133.65,42.68 133.65,53.86 134.27,54.48 134.27,59.9 134.86,60.48 134.86,63.34 135.08,63.56 135.08,76.43 140.17,81.52 140.17,83.85
  BOTTOM w0.076: v1(142.43,100.42) CPU1.BB11
  BOTTOM w0.107: JDIMM2.84 132.44,40.92 v1(132.17,41.2)
DDR_B_D25: length 67.6
  IN1 w0.089: v1(141.52,100.41) 140.97,99.86 140.97,98.29 140.8,98.12 140.8,97.52 141.21,97.12 141.21,88.71 137.03,84.53 137.03,83.85
  IN1 w0.097: 137.03,83.85 137.03,82.65 131.5,77.12 131.5,65.46 129.43,63.38 129.43,53.55 129.53,53.45 130.05,53.45 130.14,53.35 130.14,53.15 130.05,53.05 129.53,53.05 129.43,52.95 129.43,52.75 129.53,52.65 130.05,52.65 130.14,52.55 130.14,52.36 130.05,52.26 129.53,52.26 129.43,52.16 129.43,51.96 129.53,51.86 130.05,51.86 130.14,51.76 130.14,51.56 130.05,51.46 129.53,51.46 129.43,51.37 129.43,45.42 v1(129.02,45.01)
  BOTTOM w0.076: v1(141.52,100.41) CPU1.BC11
  BOTTOM w0.107: JDIMM2.67 128.19,45.84 v1(129.02,45.01)
DDR_B_D26: length 68.5
  IN1 w0.089: 139.57,83.85 139.57,84.35 142.45,87.23 142.45,89.64 143.61,90.8 143.61,97.17 142.43,98.34 v1(142.43,98.47)
  IN1 w0.097: 139.57,83.85 139.57,81.77 134.48,76.68 134.48,70.54 134.3,70.36 134.07,70.36 133.97,70.26 133.97,70.06 134.07,69.96 134.3,69.96 134.4,69.86 134.4,69.67 134.3,69.57 134.07,69.57 133.97,69.47 133.97,69.27 134.07,69.17 134.3,69.17 134.4,69.07 134.4,68.87 134.3,68.78 134.07,68.78 133.97,68.68 133.97,68.48 134.07,68.38 134.3,68.38 134.4,68.28 134.4,68.08 134.3,67.98 134.07,67.98 133.97,67.88 133.97,67.69 134.07,67.59 134.3,67.59 134.4,67.49 134.4,67.29 134.3,67.19 134.07,67.19 133.97,67.09 133.97,66.89 134.07,66.79 134.3,66.79 134.4,66.7 134.4,66.5 134.3,66.4 134.07,66.4 133.97,66.3 133.97,66.1 134.07,66 134.3,66 134.4,65.9 134.4,65.7 134.3,65.61 134.07,65.61 133.97,65.51 133.97,61.84 133.67,61.53 133.67,54.73 133.05,54.11 133.05,44.12 132.67,43.74 v1(132.17,43.74)
  BOTTOM w0.076: v1(142.43,98.47) CPU1.BB8
  BOTTOM w0.107: JDIMM2.79 131.19,46.14 131.39,45.94 131.39,44.51 v1(132.17,43.74)
DDR_B_D27: length 68.4
  IN1 w0.089: 137.63,83.85 137.63,84.25 141.56,88.18 141.56,90.09 142.33,90.86 142.33,96.65 141.59,97.39 141.44,97.39 141.16,97.67 141.16,97.97 141.52,98.33 v1(141.52,98.47)
  IN1 w0.097: 137.63,83.85 137.63,82.41 132.11,76.88 132.11,65.22 130.77,63.88 130.77,60.37 130.75,60.34 130.75,46.87 130.06,46.18 130.06,43.4 129.99,43.33 129.99,41.91 129.89,41.82 129.58,41.82 129.49,41.91 129.49,42.31 129.32,42.47 v1(129.02,42.47)
  BOTTOM w0.076: v1(141.52,98.47) CPU1.BC8
  BOTTOM w0.107: v1(129.02,42.47) 127.94,41.39 JDIMM2.66
DDR_B_D28: length 67.7
  IN1 w0.089: 137.33,83.85 137.33,84.58 141.38,88.63 141.38,97.19 140.98,97.6 140.98,98.05 141.15,98.22 141.15,99.4 v1(141.52,99.77)
  IN1 w0.097: v1(129.02,43.74) 129.75,44.47 129.75,50.58 130.45,51.28 130.45,53.58 129.75,54.28 129.75,57.69 129.86,57.8 130.35,57.8 130.45,57.89 130.45,58.09 130.35,58.19 129.85,58.19 129.73,58.32 129.73,60.43 130.47,61.18 130.47,64 131.81,65.34 131.81,77 137.33,82.53 137.33,83.85
  BOTTOM w0.076: v1(141.52,99.77) CPU1.BC10
  BOTTOM w0.107: JDIMM2.71 129.19,45.86 129.56,45.49 129.56,44.27 v1(129.02,43.74)
DDR_B_D29: length 68.3
  IN1 w0.089: 139.87,83.85 139.87,84.33 142.63,87.09 142.63,89.57 143.78,90.73 143.78,97.24 142.8,98.22 142.8,99.4 v1(142.43,99.77)
  IN1 w0.097: 139.87,83.85 139.87,81.65 134.78,76.55 134.78,63.68 134.56,63.46 134.56,61.99 133.97,61.4 133.97,60.97 134.07,60.87 134.4,60.87 134.5,60.77 134.5,60.57 134.4,60.47 134.07,60.47 133.97,60.38 133.97,54.6 133.35,53.98 133.35,42.81 133.01,42.47 v1(132.17,42.47)
  BOTTOM w0.076: v1(142.43,99.77) CPU1.BB10
  BOTTOM w0.107: v1(132.17,42.47) 131.44,41.75 JDIMM2.80
DDR_B_D30: length 68.2
  IN1 w0.089: v1(141.52,97.82) 141.52,97.71 142.51,96.72 142.51,90.78 141.74,90.01 141.74,87.98 137.94,84.17 137.94,83.85
  IN1 w0.097: v1(129.02,41.2) 128.85,41.02 128.85,40.47 129.15,40.16 130.06,40.16 130.29,40.4 130.29,42.81 130.36,42.88 130.36,46.05 131.05,46.74 131.05,60.21 131.07,60.24 131.07,63.66 132.47,65.06 132.47,76.8 137.94,82.27 137.94,83.85
  BOTTOM w0.076: v1(141.52,97.82) CPU1.BC7
  BOTTOM w0.107: v1(129.02,41.2) 128.94,41.12 JDIMM2.70
DDR_B_D31: length 68
  IN1 w0.089: 139.27,83.85 139.27,84.42 142.27,87.43 142.27,89.72 143.43,90.87 143.43,96.83 v1(142.43,97.82)
  IN1 w0.097: v1(132.17,45.01) 132.49,45.01 132.75,45.27 132.75,46.82 132.65,46.92 132.35,46.92 132.25,47.01 132.25,47.22 132.35,47.31 132.65,47.31 132.75,47.41 132.75,47.61 132.65,47.71 132.35,47.71 132.25,47.81 132.25,48.01 132.35,48.1 132.65,48.1 132.75,48.2 132.75,51.43 132.65,51.53 132.44,51.53 132.34,51.62 132.34,51.83 132.44,51.92 132.65,51.92 132.75,52.02 132.75,52.22 132.65,52.32 132.38,52.32 132.28,52.42 132.28,52.62 132.38,52.72 132.65,52.72 132.75,52.82 132.75,53.01 132.65,53.11 132.38,53.11 132.28,53.21 132.28,53.37 132.42,53.51 132.65,53.51 132.75,53.61 132.75,54.23 133.36,54.85 133.36,62.33 133.68,62.64 133.68,71.1 133.86,71.28 134.08,71.28 134.18,71.38 134.18,71.58 134.08,71.67 133.86,71.67 133.76,71.77 133.76,71.97 133.86,72.07 134.08,72.07 134.18,72.17 134.18,72.37 134.08,72.47 133.86,72.47 133.76,72.57 133.76,72.76 133.86,72.86 134.08,72.86 134.18,72.96 134.18,73.16 134.08,73.26 133.86,73.26 133.76,73.36 133.76,73.56 133.86,73.66 134.08,73.66 134.18,73.75 134.18,73.95 134.08,74.05 133.86,74.05 133.76,74.15 133.76,74.35 133.86,74.45 134.08,74.45 134.18,74.55 134.18,74.75 134.08,74.84 133.86,74.84 133.76,74.94 133.76,75.14 133.86,75.24 134.08,75.24 134.18,75.34 134.18,75.54 134.08,75.64 133.86,75.64 133.76,75.74 133.76,76.39 139.27,81.9 139.27,83.85
  BOTTOM w0.076: v1(142.43,97.82) CPU1.BB7
  BOTTOM w0.107: JDIMM2.83 132.19,45.03 v1(132.17,45.01)
DDR_B_D32: length 65.6
  IN1 w0.089: 163.51,83.85 163.51,88.41 160.19,91.73 160.19,96.64 159.76,97.07 159.76,98.06 159.44,98.38 159.44,99.54 159.36,99.62 159.36,99.96 v1(158.89,100.42)
  IN1 w0.097: 163.51,83.85 163.51,71.18 160.15,67.83 160.15,58.83 160.73,58.25 160.73,50.27 159.55,49.09 159.55,48.55 159.65,48.45 159.96,48.45 160.05,48.35 160.05,48.15 159.96,48.05 159.65,48.05 159.55,47.95 159.55,47.51 159.45,47.41 159.3,47.41 159.2,47.31 159.2,47.11 159.3,47.01 159.7,47.01 159.8,46.91 159.8,46.71 159.7,46.61 159.3,46.61 159.2,46.52 159.2,46.32 159.3,46.22 159.7,46.22 159.8,46.12 159.8,45.93 159.69,45.82 159.27,45.82 159.2,45.75 159.2,45.5 159.3,45.4 159.55,45.4 159.63,45.32 v1(159.63,45.07)
  BOTTOM w0.076: v1(158.89,100.42) CPU1.AA11
  BOTTOM w0.107: JDIMM2.187 160.2,45.63 v1(159.63,45.07)
DDR_B_D33: length 66.1
  IN1 w0.089: 163.17,83.85 163.17,86.19 163.05,86.32 163.05,88.58 159.98,91.65 159.98,96.59 159.59,96.99 159.59,97.95 159.26,98.27 159.26,99.4 v1(158.89,99.77)
  IN1 w0.097: v1(159.63,43.8) 158.9,44.53 158.9,47.43 159.25,47.79 159.25,49.21 159.92,49.88 159.92,50.79 160.02,50.88 160.18,50.88 160.28,50.98 160.28,51.18 160.18,51.28 159.99,51.28 159.89,51.38 159.89,51.58 159.99,51.68 160.2,51.68 160.3,51.78 160.3,51.97 160.2,52.07 159.99,52.07 159.89,52.17 159.89,52.37 159.99,52.47 160.2,52.47 160.3,52.57 160.3,52.77 160.2,52.87 159.99,52.87 159.89,52.96 159.89,53.25 160.4,53.76 160.4,58.16 159.85,58.71 159.85,67.95 163.17,71.27 163.17,83.85
  BOTTOM w0.076: v1(158.89,99.77) CPU1.AA10
  BOTTOM w0.107: JDIMM2.183 159.2,44.23 v1(159.63,43.8)
DDR_B_D34: length 66.2
  IN1 w0.089: v1(157.98,100.42) 157.53,99.97 157.53,99.69 157.2,99.36 157.2,97.5 157.76,96.95 157.76,90.6 159.99,88.37 159.99,83.85
  IN1 w0.097: 159.99,83.85 159.99,72.32 156.76,69.09 156.76,51.52 156.08,50.83 156.08,48.4 155.21,47.54 155.21,42.49 v1(156.46,41.24)
  BOTTOM w0.076: v1(157.98,100.42) CPU1.AC11
  BOTTOM w0.107: JDIMM2.174 156.94,40.74 156.46,41.22 v1(156.46,41.24)
DDR_B_D35: length 66.2
  IN1 w0.089: v1(157.98,99.77) 157.41,99.2 157.41,97.59 157.99,97.01 157.99,90.75 160.29,88.45 160.29,83.85
  IN1 w0.097: v1(156.46,42.51) 155.51,43.46 155.51,47.41 156.38,48.28 156.38,50.71 157.06,51.39 157.06,68.97 160.29,72.19 160.29,79.87 160.39,79.97 160.52,79.97 160.62,80.06 160.62,80.26 160.52,80.36 160.39,80.36 160.29,80.46 160.29,80.66 160.39,80.76 160.52,80.76 160.62,80.86 160.62,81.06 160.52,81.15 160.39,81.15 160.29,81.25 160.29,83.85
  BOTTOM w0.076: v1(157.98,99.77) 157.65,99.45 CPU1.AC10
  BOTTOM w0.107: JDIMM2.170 155.94,39.66 156.05,39.77 156.05,42.1 v1(156.46,42.51)
DDR_B_D36: length 66.2
  IN1 w0.089: 162.57,83.85 162.57,87.6 158.96,91.2 158.96,97.62 158.89,97.69 v1(158.89,97.82)
  IN1 w0.097: v1(159.63,41.26) 158.75,41.26 158.29,41.71 158.29,47.68 158.65,48.04 158.65,49.46 159.29,50.1 159.29,52.99 159.23,53.05 159.23,58.13 159.25,58.15 159.25,62.43 159.15,62.53 158.97,62.53 158.87,62.62 158.87,62.82 158.97,62.91 159.15,62.91 159.25,63.01 159.25,63.2 159.15,63.3 158.97,63.3 158.87,63.4 158.87,63.59 158.97,63.69 159.15,63.69 159.25,63.78 159.25,63.98 159.15,64.07 158.97,64.07 158.87,64.17 158.87,64.36 158.97,64.46 159.15,64.46 159.25,64.55 159.25,64.75 159.15,64.84 158.97,64.84 158.87,64.94 158.87,65.13 158.97,65.23 159.15,65.23 159.25,65.33 159.25,68.2 162.57,71.52 162.57,82.46 162.57,82.46 162.57,83.85
  BOTTOM w0.076: v1(158.89,97.82) CPU1.AA7
  BOTTOM w0.107: v1(159.63,41.26) 159.34,40.97 159.34,40.5 158.94,40.1 JDIMM2.182
