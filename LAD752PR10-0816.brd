# Allegro board LAD752PR10-0816.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+1.5V_VGAP: length 37.7
  TOP w0.508: v1(278.74,163.04) 278.14,162.43 PC8218.1 PR8209.2
  BOTTOM w0.508: 263.85,149.89 264.3,149.45 264.3,148.52 267.3,145.51 271.28,145.51 275.85,150.08 v4(275.85,151.19) 275.85,151.92 277.44,153.51 280.62,153.51 281.5,154.4 281.5,162.34 280.74,163.1 278.81,163.1 v1(278.74,163.04)
+1.5VS_B+: length 10.1
  TOP w0.254: PR8201.2 v1(280.46,161.56)
  IN3 w0.254: v1(280.46,161.56) 280.46,164.84 279.35,165.96 276.42,165.96 275.6,165.13 v1(275.6,164.56)
  vias: v1(272.61,163.93) v1(273.25,163.93) v2(273.25,160.94)
+1.8VA_TBTA_LDO: length 2.9
  TOP w0.102: v1(197.44,165.43) 196.86,165.43 v2(196.72,165.58)
  TOP w0.508: CT100.1 197.79,165.13 197.49,165.43 v1(197.44,165.43)
  BOTTOM w0.203: UT4.K1 197.44,165.28 v1(197.44,165.43)
+1.8VD_TBTA_LDO: length 2.5
  BOTTOM w0.254: UT4.A2 198.41,159.82 198.41,159.56 198.38,159.53
  BOTTOM w0.508: 198.38,159.53 197.68,158.83 197.68,158.15 CT99.1
+1.8VGS: length 169.5
  TOP w0.381: v1(224.57,102.2) 224.07,102.7 RG20.2
  TOP w0.508: PR6088.1 v1(299.34,55.54) ; PR6090.1 v1(296.62,62.66) ; RG5.2 RG6.2 232.85,79.66 LG1.1 231.92,79.55 231.42,79.04 230.6,79.04 230.31,79.33 230.17,79.33 v1(230.17,79.33) 230.17,77.95 230.91,77.21 v1(231.53,77.21) 231.53,77.16 232.16,76.53 v1(233.39,76.53) 233.65,76.53 233.88,76.3 235.8,76.3 236.87,77.36 v1(236.93,77.36) ; RG20.2 224.05,102.81 RG17.2 ; v1(233.18,85.88) 233.18,86.01 CG32.1
  IN3 w0.508: v1(299.34,55.54) 300.02,56.23 300.02,59.48 296.85,62.66 v1(296.62,62.66)
  IN4 w0.508: v1(299.34,55.54) 298.32,55.54 296.05,57.82 292.93,57.82 292.01,58.74 292.01,61.19 292.83,62.02 292.83,65.81 287.68,70.96 283.27,70.96 282.59,70.29 280.54,70.29 279.21,71.62 277.4,71.62 276.88,71.1 276.88,70.58 272.25,65.95 247.48,65.95 246,67.43 246,68.76 239.59,75.16 239.59,76.45 238.68,77.36 v1(236.93,77.36) ; v1(211.4,102.84) 212.95,102.84 213.74,102.05 223.25,102.05 223.4,102.2 v1(224.57,102.2) 224.57,102.08 225.08,101.57 228.91,101.57 229.42,101.06 229.42,92 229.89,91.53 231.58,91.53 231.65,91.6 232.8,91.6 233.82,90.58 233.82,89.28 233.28,88.75 v1(233.22,88.75)
  BOTTOM w0.254: v1(214.49,79.51) 215.1,80.12 215.34,80.12 215.63,80.41 215.63,80.96 215.24,81.35 CG34.2 CG31.1 213.96,82.04 213.88,81.95 YG1.4 ; 212.99,80.23 212.23,80.99 210.45,80.99 210.23,81.21 RG158.2
  BOTTOM w0.381: RG151.2 RG149.2 237.48,77.37 236.94,77.37 v1(236.93,77.36) 236.87,77.36 236.27,76.77 RG164.2 RG160.2 ; RG169.2 RG167.2 231.57,77.17 v1(231.53,77.21) ; v1(233.39,76.53) 233.49,76.44 RG162.2 ; UG1.AP27 231.67,87.6 v1(232.02,87.95) 232.17,87.95 UG1.AN26 232.97,88.75 v1(233.22,88.75) 233.67,89.2 UG1.AM25
  BOTTOM w0.4: 233.7,88.28 233.37,87.95 v1(233.22,87.95) 232.87,87.6 UG1.AP26 232.17,87.15 v1(232.02,87.15) 231.67,86.8 UG1.AR27
  BOTTOM w0.406: UG1.AN25 233.7,88.28
  BOTTOM w0.508: RV260.1 210.49,105.14 209.99,104.64 209.99,104.05 210.5,103.54 210.71,103.54 211.06,103.18 211.06,103.18 v1(211.4,102.84)
  vias: v1(213.9,79.51) v1(219.21,78.82) v1(219.85,78.82)
+1.8VGSP: length 1.7
  BOTTOM w0.107: PC1309.1 214.66,75.91 215.1,76.35 v2(215.63,76.35)
+1.8VGSP_ON: length 6.9
  TOP w0.107: v2(202.02,69.25) PR1303.1
  TOP w0.508: PR1303.1 PR1308.1 PC1311.1 202.02,73.96 v1(202.64,74.58)
  BOTTOM w0.508: PU1301.2 203.18,75.13 v1(202.64,74.58)
+1.8VGSP_VIN:
  vias: v2(201.24,74.2)
+1.8VS: length 453.8
  TOP w0.254: v1(326.59,12.41) 326.15,12.85 JIO.7
  TOP w0.508: PR6089.1 v1(296.73,61.77) ; PR6087.1 v1(299.31,56.42) ; v1(225.23,37.43) 225.65,37.02 232.66,37.02 233.32,36.36 v4(235.3,36.36) 238.42,36.36 240.39,34.38 240.39,24.56 241.24,23.71 241.24,16.63 v1(240.65,16.03)
  IN1 w0.508: v1(33.38,20.51) 33.85,20.99 36.83,20.99 39.54,23.7 39.54,26.91 38.16,28.29 38.16,30.66 38.8,31.3 39.7,31.3 40.78,32.38 v1(40.78,32.42)
  IN2 w0.508: v1(34.62,14.26) 34.62,16.22 34.55,16.29 34.55,17.7 33.28,18.97 33.28,20.42 v1(33.38,20.51) ; v1(53.23,12.55) 53.23,11.58 56.47,8.34 63.41,8.34 65.08,10 69.2,10 70.61,11.41 84.85,11.41 86.27,12.83 97.77,12.83 99.04,14.1 104.57,14.1 104.93,14.46 108.85,14.46 109.19,14.8 183.33,14.8 188.97,9.16 190.45,9.16 191.23,9.94 192.51,9.94 193.78,8.67 206.19,8.67 207.74,10.22 213.51,10.22 215.95,12.66 225.81,12.66 227.29,11.18 231.13,11.18 231.48,11.53 232.51,11.53 233.14,12.15 241.05,12.15 v1(241.7,11.5) 242.36,12.15 257.91,12.15 258.11,12.35 265.77,12.35 266.04,12.62 274.05,12.62 276.88,9.79 287.93,9.79 288.54,9.18 291.51,9.18 292.49,8.2 306.26,8.2 306.49,7.97 309.37,7.97 309.6,8.2 314.78,8.2 315.7,9.11 319.62,9.11 322.92,12.41 v1(326.59,12.41)
  IN3 w0.508: v1(296.73,61.77) 299.31,59.19 v1(299.31,56.42) 298.66,55.77 298.66,50.42 299.84,49.25 299.84,41.97 300.86,40.95 303.25,40.95 304.37,39.82 304.37,33.87 309.87,28.37 309.87,26.93 v1(309.94,26.87)
  IN4 w0.508: v1(40.78,32.42) 40.78,31.95 41.47,31.25 41.47,19.4 44.46,16.42 45.7,16.42 46.02,16.1 49.68,16.1 v1(53.23,12.55) ; v1(326.59,12.41) 326.55,12.41 325.67,13.29 325.67,14.66 324.59,15.75 324.37,15.75 319.72,20.4 319.72,21.35 316.39,24.69 316.12,24.69 313.94,26.87 v1(309.94,26.87)
  BOTTOM w0.508: v1(240.65,16.03) 240.54,16.03 239.16,14.65 239.16,12.07 239.73,11.5 v1(241.7,11.5)
+1.8VSP: length 12.2
  BOTTOM w0.254: PR810.2 237.3,41.01 237.03,41.01 236.36,41.69 PC819.1 234.88,41.69 234.63,41.43 233.77,41.43 232.85,42.35 v2(232.18,42.35) 230.86,42.35 229.5,40.99 229.5,39.64 230.2,38.94 PL801.2
+1.35VS_VGA_PGOOD: length 3.6
  TOP w0.203: PU8200.13 277.64,159.95 v1(277.62,159.97)
  BOTTOM w0.254: PR8203.1 275.34,159.32 v4(276.96,159.32) v1(277.62,159.97)
+1V_MPHY: length 2.7
  BOTTOM w0.152: v1(202.86,28.99) UH1.U21 ; UH1.U25 v1(202.86,27.44) ; v1(202.86,28.21) UH1.U23 ; v1(202.86,26.66) UH1.U26 ; v1(203.63,26.66) UH1.V26
  vias: v1(193.64,17.98) v1(194.19,18.07) v2(201.62,28.61)
+1V_PCH: length 14.5
  TOP w0.508: v1(205.96,31.31) 206.03,31.24 CH185.1
  BOTTOM w0.152: UH1.AD15 206.24,32.42 v1(206.73,32.66) ; v1(210.32,30.83) 210.67,30.37 UH1.AN19 ; UH1.K3 199.23,38.66 199.14,38.75 UH1.K2 199.35,39.24 v1(199.35,40.06) ; v1(202.01,30.85) 201.76,31.1 UH1.R17 ; v1(203.63,31.31) UH1.V17 ; UH1.AC17 v1(205.96,31.31) ; UH1.AJ5 UH1.AL5 ; v1(202.86,29.76) UH1.U20 ; v1(201,32.45) UH1.N17
  BOTTOM w0.203: v1(210.21,37.08) 210,37.08 UH1.AL5 ; UH1.AL22 209.38,28.78 v1(209.58,28.57)
  BOTTOM w0.254: v1(201.88,29.81) 201.76,29.93 UH1.R19
  BOTTOM w0.508: v1(199.35,40.06) 199.35,41.19 199.34,41.21 CH179.1 199.46,41.92 199.93,41.92 CH178.1 ; CH177.1 203.44,41.52 v1(203.97,40.99)
  vias: v4(194.95,41.18)
+1V_PCH_PRIM: length 18.7
  TOP w0.508: RH196.1 215.53,24.91 v1(215.36,25.08)
  IN1 w0.508: v1(208.28,28.21) 208.32,28.21 208.85,27.67 208.85,26.77 210,25.62 215.02,25.62 215.36,25.28 v1(215.36,25.08)
  BOTTOM w0.152: UH1.AE23 v1(205.96,28.21) UH1.AC23 ; v1(205.96,27.44) UH1.AE26 ; UH1.AJ20 v1(208.28,29.76) UH1.AJ21 v1(208.28,28.99) UH1.AJ23 v1(208.28,28.21) UH1.AJ25 ; UH1.AA26 v1(204.41,27.44) UH1.Y25 ; v1(205.18,26.66) UH1.AA28 ; v1(205.18,27.44) UH1.AC26 ; UH1.AA23 v1(204.41,28.21) UH1.Y23 ; v1(205.96,26.66) UH1.AC28
  vias: v2(203.34,39.28)
+1V_VCCDSW: length 3.9
  TOP w0.381: RH196.2 215.2,25.83 v2(215.07,25.7) 214.87,25.5 CH176.1 214.02,24.87 v1(213.99,24.85)
  BOTTOM w0.254: UH1.BA29 214.06,24.96 214.05,24.96 v1(213.99,24.85)
+1VALW: length 165.8
  TOP w0.254: v1(115.9,155.48) 116.06,155.31 JPCMC.22
  TOP w0.508: RC353.1 129.24,159.91 v1(128.79,160.37)
  IN2 w0.508: v1(120.4,132.79) 120.51,132.79 121.8,131.5 121.8,131.48 121.85,131.43 121.85,129.33 129.99,121.19 129.99,118.08 130.69,117.38 131.77,117.38 132.41,116.75 132.41,111.09 132.85,110.65 134.88,110.65 135.26,110.27 135.26,109.51 135.9,108.87 135.9,106.33 132.72,103.16 132.72,93.12 130.37,90.77 130.37,79.29 137.38,72.28 178.76,72.28 181.05,74.57 v1(181.05,74.64)
  BOTTOM w0.508: v1(128.79,160.37) 128.41,159.99 124.02,159.99 123.39,159.35 118.82,159.35 118.44,158.97 116.59,158.97 115.55,157.93 115.55,155.82 v1(115.9,155.48) 116.59,154.78 117.42,154.78 117.93,154.27 117.93,152.81 117.42,152.31 117.42,150.59 117.86,150.15 117.86,148.56 116.91,147.61 116.91,133.32 117.44,132.79 v1(120.4,132.79)
  vias: v1(181.05,75.28) v1(181.16,77.92) v1(181.16,77.22) v1(181.16,76.59) v1(181.16,75.95) v1(181.81,77.25) v1(181.8,76.59) v1(181.8,75.95) v1(182.88,76.18) v1(187.65,32.29) v1(188.06,32.71) v1(188.22,32.1) v1(188.48,33.12) v1(203.26,43.13) v1(203.91,43.15) v1(204.29,42.68) v1(204.67,43.15) v1(242.81,37.85) v1(243.39,38.49) v1(243.39,37.85) v1(244.03,39.07) v1(244.03,38.49) v1(244.03,37.85) v1(244.66,39.07) v1(244.66,38.49) v1(244.66,37.85) v1(245.3,39.07) v1(245.3,38.49) v1(245.3,37.85) v1(245.93,39.07) v1(245.93,38.49) v1(245.93,37.85) v1(246.57,39.07) v1(246.57,38.49) v1(246.57,37.85) v1(247.2,39.07) v1(247.2,38.49) v1(247.21,37.88) v1(247.77,39.27) v1(247.77,38.69) v1(248.36,39.27) v1(248.36,38.69) v1(248.94,39.27) v1(248.94,38.69) v4(192.92,46.58)
+1VALWP: length 27.4
  TOP w0.254: PR307.2 250.9,16.48 249.94,15.52 245.85,15.52 245.32,16.06 244.65,16.06 241.98,18.73 241.98,26.14 241.16,26.96 v2(241.16,32.8) 241.16,33.91 v1(241.52,34.27)
+1VALWP_B+:
  vias: v1(255.34,28.63) v1(255.98,28.63) v2(258.14,27.53)
+1VALWP_PGOOD: length 98.6
  TOP w0.254: PR301.2 246.16,18.08 246.58,18.49 246.58,18.7 246.85,18.98 246.85,18.98 247.11,19.24 PU300.1
  TOP w0.508: PR301.2 245.49,18.08 244.99,18.57 244.99,19.42 243.37,21.04 243.37,25.8 242.06,27.11 242.06,32.87 244.06,34.87 v2(249.12,34.87) 263.89,34.87 267.04,38.02 v1(267.81,38.02)
  IN3 w0.508: v1(267.81,38.02) 269.61,38.02 269.9,37.74 284.04,37.74 286.25,35.53 287.85,35.53 292.36,31.02 302.49,31.02 305.34,28.17 305.34,24.59 306.4,23.53 306.4,19.59 305.7,18.89 v1(305.3,18.89)
+2.5V_MEM: length 88.8
  IN4 w1.016: 179.71,48.36 179.71,50.9 178.89,51.72 171.4,51.72 170.7,51.02 170.7,48.1 169.49,46.9 110.18,46.9
  BOTTOM w1.016: 179.39,59.88 181.04,58.23 181.04,55.37 180.07,54.39 180.07,49.53 179.9,49.36 179.9,48.32
  vias: v1(109.93,45.63) v1(109.93,44.93) v1(179.09,58.96) v1(179.1,58.37) v1(179.08,46.96) v1(179.52,47.4) v4(178.41,58.53)
+2.5V_MEMP: length 1.3
  BOTTOM w0.102: 102.37,38.97 v2(102.37,37.67)
+2.5VOUT: length 12.4
  BOTTOM w0.254: CM32.1 131.12,152.24 131.44,152.56 131.83,152.56 132.11,152.83 UM8.9 ; UM8.51 137.7,155.68 v1(137.74,155.64) ; CM36.1 130.74,160.32 131.61,159.45 UM8.36 ; UM8.41 134.11,160.39 CM9.1 ; CM35.1 129.6,153.37 UM8.14
  BOTTOM w0.508: v1(130.06,160.56) 130.22,160.39 CM36.1 ; CM35.1 v1(130.35,151.47) CM32.1 ; CM9.1 134.29,160.39 v1(134.76,160.87) ; v1(137.74,155.64) 138.33,155.64 CM34.1
  vias: v2(130.82,161)
+2.5VSP_ON: length 4.6
  BOTTOM w0.102: v2(97.32,50.71) PR1301.1
  BOTTOM w0.508: PR1301.1 PR1302.1 PC1301.1 100.25,50.59 PU1300.2
+2.5VSP_VIN: length 2.5
  BOTTOM w0.102: 101.22,53.38 99.55,53.38 v2(98.99,52.83)
+3.3V_1.8V_DVDD: length 45.7
  TOP w0.203: v1(36.5,14.25) 36.5,14.12 36.25,13.87 UA4.16
  TOP w0.381: v1(33.41,33.3) 33.57,33.46 RA21.1 ; RA70.1 37.9,16.41 37.9,17.29 37.63,17.56 36.9,17.56 36.51,17.18 v1(36.51,16.98)
  IN1 w0.508: v1(36.51,16.98) 36.51,19.77 40.18,23.44 40.18,27.97 40.47,28.26 40.47,29.05 40.07,29.44 v1(39.94,29.44)
  IN2 w0.508: v1(33.41,33.3) 34.57,34.46 35.63,34.46 36.23,35.06 37,35.06 37.54,34.52 37.54,31.6 38.44,30.69 v1(39.06,30.69)
  BOTTOM w0.203: UA1.7 36.18,30.71 36.43,30.45 37.38,30.45 CA12.1
  BOTTOM w0.457: v1(39.94,29.44) 39.68,29.44 39.03,28.79 RA32.1 ; v1(39.06,30.69) 38.92,30.56 CA13.1 CA12.1 ; CA64.1 CA65.1 36.45,15.91 35.65,15.91 RA66.1
  BOTTOM w0.508: v1(36.51,16.98) CA65.1 ; CA64.1 36.51,14.26 v1(36.5,14.25) 36.53,14.25 37.15,13.63 38.05,13.63 38.23,13.81 39.38,13.81 v2(39.98,13.21) 40.15,13.04 RA50.1 RA53.1
+3.3V_1.8V_DVDD_IO:
  vias: v2(33.41,25.88)
+3.3V_ANA_PCIE: length 1.4
  TOP w0.254: v1(183.25,165.76) UT1.L16
  BOTTOM w0.254: CT85.1 183.82,166.25 183.32,165.76 v1(183.25,165.76)
+3.3V_ANA_USB2: length 1
  TOP w0.254: UT1.J16 v1(182.6,165.76)
  BOTTOM w0.381: CT86.1 182.63,165.79 v1(182.6,165.76)
+3.3V_F383: length 546.2
  TOP w0.254: UE4.27 188.6,22.85 188.41,23.04 188.41,23.73 CE25.1 ; CE24.1 223.44,154.59 222.72,154.59 222.44,154.87 222.44,155.1 221.7,155.83 UE3.27
  TOP w0.508: RE43.1 224.08,158.26 223.53,158.81 RE40.1 224.5,159.58 v1(226.06,158.02) 226.53,157.55 226.53,156.57 ; RE15.1 290.7,28.3 289.63,29.37 289.63,32.76 288.54,33.86 288.54,37.8 287.98,38.36 v1(287.98,39) ; v1(311.56,21.24) RE1.1 RE2.1 ; 189.62,24.67 189.01,24.06 CE25.1 ; v1(322.83,8.81) 323.67,9.65 RE7.1 ; v1(314.97,21.3) 314.97,20.86 315.1,20.73 RE8.1 ; RE21.1 RE17.1 RE16.1 321.78,47.03 321.26,46.51 315.86,46.51 v1(315.79,46.58) v1(315.1,46.58) ; 226.53,156.57 226.87,156.22 226.87,152.39 226.37,151.89 v4(223.62,151.89) 222.68,150.95 221.15,150.95 ; 226.53,156.57 224.94,156.57 224.41,156.04 224.41,155.76 223.57,154.92 CE24.1 ; RE23.1 324.27,37.17 322.27,35.18 v1(322.27,33.12) ; RE652.1 v1(143,166.68)
  TOP w1.016: 190.93,74.27 190.93,84.91 192.29,86.27 192.29,96.46 191.74,97.01 191.74,101.09 189.91,102.92 189.91,120.59 191.67,122.35 196.36,122.35 199.56,125.54 199.56,140.41 205.49,146.35 209.85,146.35 210.35,145.85 213.39,145.85 214.09,146.54 214.09,147.17 216,149.08 217.46,149.08 219.41,151.04 ; 185.68,26.64 185.66,26.66 185.66,51.83 185.02,52.46 185.02,58.31 192.13,65.41 192.13,72.23
  IN1 w0.508: v1(151.61,173.77) 151.42,173.77 144.34,166.68 v1(143,166.68) ; v1(161.67,171.86) 163.18,173.37 163.83,173.37 164.49,174.03 167.36,174.03 168.3,173.09 169.66,173.09 170.54,172.21 175.42,172.21 177.82,174.61 183.19,174.61 184.05,173.74 193,173.74 193.97,172.77 194.82,172.77 196.26,171.33 197.04,171.33 197.79,170.58 197.79,169.12 198.57,168.33 201.08,168.33 v1(201.28,168.54)
  IN2 w0.508: v1(318.33,7.72) 320.06,7.72 321.15,8.81 v1(322.83,8.81) ; v1(311.56,21.24) 312.17,21.85 314.42,21.85 v1(314.97,21.3) ; v1(151.61,173.77) 152.41,174.57 159.83,174.57 160.83,173.57 160.83,173.42 161.67,172.58 v1(161.67,171.86)
  IN2 w1.016: 106.36,18.31 121.23,18.31 122.09,19.17 168.39,19.17 172.87,23.65 179.65,23.65 181.05,22.26 184.29,22.26 185.68,23.65 185.68,25.43 v1(186,25.75)
  IN3 w0.508: v1(201.28,168.54) 201.08,168.33 201.08,165.76 201.97,164.87 202.33,164.87 202.84,164.36 202.84,163.06 203.4,162.5 204.45,162.5 205.74,161.22 205.74,154.96 206.07,154.63 206.07,153.06 205.38,152.37 205.38,151.41 205.79,151.01 206.66,151.01 207.02,150.64 213.48,150.64 217.3,154.46 223.66,154.46 224.28,155.09 224.28,156.03 224.89,156.64 225.59,156.64 226.06,157.11 v1(226.06,158.02) ; v1(286.57,41.76) 286.69,41.88 286.69,44.15 288.9,46.36 v1(288.9,46.76)
  IN3 w1.016: 285.68,39.82 271.88,39.82 269.44,42.26 269.44,45.37 268.42,46.39 226.67,46.39 214.5,58.55 214.5,63.16
  IN4 w1.016: 213.05,63.98 212.47,63.98 211.12,65.32 207.24,65.32 205.13,67.43 202.02,67.43 197.16,72.29 194.75,72.29 194.75,72.3 193.11,72.3 192.73,72.68
  BOTTOM w0.254: UE8.27 288.47,42.55 288.38,42.64 286.84,42.64 CE168.1
  BOTTOM w0.508: UE2.8 97.04,18.56 97.82,19.34 98.81,19.34 99.12,19.64 CE19.1 98.5,20.1 v1(98.4,20) 98.34,20 98.24,20.1 RE13.1 ; v1(286.57,41.76) 286.57,42.37 CE168.1 ; RE165.1 289.4,48.24 288.9,47.73 v1(288.9,46.76) ; RE166.1 v1(285.77,41.76)
  vias: v1(97.34,11.02) v1(97.93,11.02) v1(100.64,20) v1(101.23,20) v1(104.65,18.45) v1(105.29,18.45) v1(191.59,73.57) v1(192.03,73.18) v1(214.13,63.98) v1(214.83,63.98) v1(302.21,11.59) v1(302.59,11.14) v1(315.03,29.75) v1(315.68,29.75) v1(317.7,7.72)
+3.3V_FLASH: length 53.1
  TOP w0.381: v1(206.96,161.7) 206.78,161.7 206.4,161.32 206.4,159.25 205.02,157.87 203.56,157.87 203.47,157.77 202.2,157.77 200.5,159.47 RT67.1 RT66.1 198.62,159.47 198.11,158.95 197.39,158.95 196.88,159.46 196.88,160.07
  TOP w0.508: 194.95,161.07 192.65,158.76 190.69,158.76 190.17,158.24 190.17,156.22 189.11,155.16 v1(187.71,155.16) ; 196.92,160.12 196.88,160.07
  BOTTOM w0.254: UT4.B1 197.89,160.57 v1(197.61,160.28) ; 195.6,162.41 196.26,163.07 196.65,163.07 196.75,163.16 197.57,163.16 197.67,163.07 197.95,163.07 197.95,163.07 UT4.G1
  BOTTOM w0.381: v1(206.96,161.7) 207.72,161.7 208.2,162.19 RT74.1
  BOTTOM w0.508: v1(195.27,162.97) 195.27,162.82 195.6,162.49 CT103.1 ; 187.71,155.8 188.43,156.51 RT51.1 ; 187.71,155.8 v1(187.71,155.16) 188.46,154.41 CT45.1 189.16,154.41 190.19,153.39 190.18,153.37 UT2.8 ; 187.71,155.8 185.05,155.8 184.46,156.38 184.46,159.21 184.79,159.54 184.79,159.8 185.56,160.56 185.56,162.21 186.05,162.7 186.79,162.7 187.08,162.99 RT50.1 RT49.2 RT48.1
  vias: v4(195.46,161.96)
+3.3V_LC: length 31.6
  TOP w0.127: v2(167.72,155.04) 167.55,155.21 v1(167.55,156.16)
  TOP w0.203: UT1.R6 v1(178.71,163.15)
  TOP w0.508: v1(167.55,156.16) 167.5,156.21 166.8,156.21 161.82,161.19 161.82,162.01 161.74,162.08
  IN3 w0.508: v1(171.78,159.23) 173.05,160.5 176.03,160.5 176.48,160.05 178.57,160.05 179.33,160.81 179.33,162.15 178.7,162.78 178.7,163.13 v1(178.71,163.15)
  IN4 w0.508: v1(171.78,159.23) 171.76,159.24 166.68,159.24 166.15,158.71 166.15,156.83 166.8,156.18 167.53,156.18 v1(167.55,156.16)
  BOTTOM w0.381: v1(178.71,163.15) 178.75,163.11 CT46.1
+3.3V_TBT_SX: length 54.3
  TOP w0.254: v1(174.03,161.58) 173.95,161.5 RT29.1 RT28.1 ; RT30.1 170.65,166.19 v1(170.58,166.11) ; RT32.1 170.02,164.85 170.49,164.85 v1(170.49,164.86) 170.5,164.85 171.03,164.85 RT33.1 ; RT31.1 172.79,162.69 v1(172.83,162.65) 172.87,162.69 RT26.1 RT27.1 ; UT1.F8 179.02,167.38 178.72,167.69 v1(178.71,167.69)
  TOP w0.381: RT61.2 v2(197.11,169.02) 197.11,169.53 v1(197.11,169.65)
  IN2 w0.381: v1(170.49,164.86) 170.49,164.85 169.95,164.85 169.68,165.12 169.68,165.74 170.03,166.08 170.55,166.08 v1(170.58,166.11)
  IN2 w0.508: v1(170.49,164.86) 170.5,164.85 171.36,164.85 172.67,163.54 172.83,163.38 v1(172.83,162.65) ; v1(173.87,170.91) 174.38,170.91 175.4,169.89 175.4,168.37 174.03,167.01 173.9,167.01 173.33,166.43 173.33,166.08 172.82,165.58 171.71,165.58 171.18,166.11 v1(170.58,166.11)
  IN3 w0.508: v1(178.71,167.69) 179.03,167.69 179.33,167.99 179.33,168.69 179.97,169.32 194.83,169.32 195.08,169.58 197.04,169.58 v1(197.11,169.65)
  BOTTOM w0.254: v1(170.49,164.86) 170.49,164.85 169.91,164.27 RT94.1
  BOTTOM w0.381: v1(174.03,161.58) 174.03,161.73 173.11,162.65 v1(172.83,162.65) ; RT70.1 197.11,169.2 v1(197.11,169.65) ; 177.36,168.94 RT86.1 ; 177.36,168.94 177.36,168.93 ; 177.36,168.94 177.8,168.94 178.11,168.62 CT47.1 178.7,167.68 v1(178.71,167.69)
  BOTTOM w0.508: v1(173.87,170.91) 174.39,170.91 RT97.2 175.05,170.61 175.68,169.98 175.68,169.46
+3.3V_TBT_SX_R: length 7.9
  TOP w0.381: RT61.1 CT102.1 v1(195.53,167.47)
  BOTTOM w0.076: UT4.H2 198.41,163.82 198.26,163.82 198.26,163.82 198.05,163.82 198.05,163.82 197.96,163.82
  BOTTOM w0.152: 197.96,163.82 197.89,163.82 197.69,164.03 197.46,164.03 196.64,164.84
  BOTTOM w0.508: 196.64,164.84 196.03,164.84 195.14,165.73 v2(195.14,166.97) 195.14,167.09 v1(195.53,167.47)
+3V_PCH: length 245.5
  TOP w0.381: RH23.2 211.12,24.75 210.69,25.18 RH130.1 209.18,25.69 208.73,25.24 208.73,24.23 209.13,23.82 v1(209.21,23.82) ; RH7.1 213.54,31.97 214.49,31.02 v1(214.49,30.96) 214.56,30.9 RH558.2
  TOP w0.508: RH78.1 221.37,21.91 221.67,22.22 v1(221.82,22.22) 221.23,22.8 RH75.1 RH524.1 220.95,25.63 v1(221.26,25.94) ; CH200.1 213,23.76 v1(213.31,24.07) ; RH460.1 RH461.1 210.22,12.38 211.15,13.31 v1(211.15,13.49) ; v1(214.49,30.96) 214.02,30.49 CH186.1 ; v1(127.64,160.88) RC9.1 ; v1(221.56,28.47) 221.56,28.75 RH506.2 ; CH191.1 209.57,19.73 v1(209.22,20.08) ; v1(215.37,17.25) 215.37,16.54 CH192.1 ; 203.92,57.84 202.37,57.84 200.5,59.7 R367.2 ; v1(206.77,20.39) 206.46,20.39 206.01,19.95 CH190.1
  IN2 w0.508: v1(204.19,55.44) 204.1,55.53 202.08,55.53 199.12,52.58 196.62,52.58 187.61,61.58 186.61,61.58 180.26,67.93 139.6,67.93 127.62,79.91 127.62,94.21 126.65,95.17 126.65,99.65 130.12,103.12 130.12,115.28 130.01,115.39 130.01,116.04 128.7,117.35 128.02,117.35 127.66,117.72 127.66,122.55 121.17,129.04 v1(121.17,131.22)
  IN4 w0.508: v1(221.34,19.31) 221.12,19.53 221.12,21.83 221.5,22.22 v1(221.82,22.22)
  BOTTOM w0.203: UH1.BE3 UH1.BD3 UH1.BE4 ; UH1.BA31 213.95,24.07 v1(213.31,24.07) ; UH1.BA20 214.46,30.73 214.49,30.77 v1(214.49,30.96)
  BOTTOM w0.254: RPH6.8 204.19,13.15 v1(204.43,12.9) 204.69,13.16 RPH6.7 ; RPH6.6 205.19,13.16 v1(205.43,12.92) 205.68,13.18 RPH6.5 ; UH1.BC42 215.73,20.02 UH1.BD40 ; v1(206.77,20.39) 206.7,20.34 206.68,20.23 206.29,19.96 UH1.AD41 ; v1(211.23,37.07) 210.73,37.35 UH1.AN5
  BOTTOM w0.381: RH21.2 195.61,13.5 v1(195.84,13.72) 195.61,13.95 RH27.2 ; v1(198.8,12.57) 198.95,12.73 RH25.2 RH29.2
  BOTTOM w0.508: v1(121.17,131.22) 121.17,131.12 120.66,130.61 117.33,130.61 115.32,132.61 115.32,151.86 113.84,153.34 113.84,158.95 116.59,161.7 122.12,161.7 122.94,160.88 v1(127.64,160.88) ; RH571.2 RH493.1 216.74,42.85 217.38,42.21 217.63,42.21 218.12,41.72 218.12,40.06 217.25,39.19 ; RH74.1 v1(221.34,19.31)
  vias: v1(210.14,20.08) v1(215.4,18.89) v1(216.87,38.63) v1(216.87,38.04) v1(220.63,38.31) v1(220.65,37.7) v1(228.74,14.19) v1(229.32,14.19) v4(214.26,47.53)
+3VALW: length 669.1
  TOP w0.102: v1(215.35,27.57) 215.17,27.57 v2(214.79,27.2)
  TOP w0.127: RA13.1 20.85,25.9 v1(20.62,26.13) 20.47,26.28 20.47,26.78 20.15,27.09 20.15,27.85 20.45,28.15 RA84.2
  TOP w0.254: CE56.1 328.3,41.45 UE6.24 ; UE10.24 304.97,49.58 CE62.1 ; JIO.8 v1(326.48,13.36)
  TOP w0.381: RU26.1 v1(304.63,54.12)
  TOP w0.508: v1(55.32,16.94) 55.63,16.94 56.14,17.45 PR718.2 ; CE56.1 327.81,42.2 v1(327.81,43.07) ; v1(286.84,12.35) 286.9,12.41 RE102.2 ; RU19.2 15.95,53.23 RU18.2 RU17.2 ; R325.1 326.53,36.06 327.1,35.48 v1(327.38,35.48) ; RE643.1 304.11,46.83 v1(304.87,47.59) CE62.1 ; RU15.2 19.52,52.28 19.19,52.61 RU16.2 ; RH2.1 208.69,35.94 208.69,37.73 208.44,37.98 208.44,38.85 210.51,40.93 v4(210.51,43.09) 210.51,44.48 210.99,44.96 210.99,48.7 v1(210.38,49.3) ; v1(59.25,15.23) PR709.2 ; RE70.1 310.35,16.84 v1(310.65,16.54) ; PC807.1 194.93,76.67 v1(194.54,77.06) 194.14,77.06 193.49,76.41 193.49,73.95 194.28,73.16 v1(194.6,73.16) 196.1,71.66 197.43,71.66 201.18,67.92 201.18,66.45 ; v1(194.67,165.22) 194.69,165.21 RT53.1 ; v1(310.9,24.99) 310.9,29.05 306.33,33.62 306.33,44.29 305.3,45.32 v1(304.87,45.32) ; v1(329.28,38.28) 330.44,38.28 RE91.1 ; RE79.1 310.31,9.98 v1(310.77,9.52) ; PR16.2 80.7,8.91 80.11,8.31 78.48,8.31 78.05,8.74 78.05,9.82 76.19,11.69 76.19,13.67 74.15,15.7 v4(71.13,15.7) 70.77,15.7 70.2,15.13 v1(68.04,15.13) ; CH82.1 203.79,32.78 v1(204.42,32.78) ; v1(276.04,35.02) 275.6,35.02 PR3.2 275.37,34.04 276.36,33.06 PR24.2 ; RE64.2 287.87,5.67 v1(287.22,6.32) ; 306.59,45.56 307.48,44.67 310.21,44.67 312.9,47.36 RE644.2 ; v1(66.75,16.38) 65.68,16.38 65.15,16.91 PR710.1 ; R307.1 321.19,36.56 v1(321.21,36.54)
  IN1 w0.127: v1(34.4,40.71) 34.4,38.3 32.43,36.33 29.05,36.33 27.47,34.75 24.85,34.75 21.83,31.73 21.83,30.17 20.62,28.96 v1(20.62,26.13)
  IN1 w0.508: v1(159.61,173.37) 159.83,173.16 162.07,173.16 162.92,174.01 163.56,174.01 164.22,174.67 167.62,174.67 168.56,173.73 173.19,173.73 174.19,174.73 v1(174.19,175.17) ; v1(55.32,16.94) 56.41,18.04 64.09,18.04 64.3,17.84 ; v1(94.5,19.93) 94.5,18.19 90.05,13.75 68.53,13.75 ; v1(297.57,5.3) 297.39,5.12 296.48,5.12 295.54,6.06 288.36,6.06 288.11,6.32 v1(287.22,6.32) ; v1(204.42,32.78) 205.61,32.78 206.3,32.09 208.68,32.09 209.31,31.46 210.6,31.46 211.16,30.9 211.16,29.37 211.92,28.61 213,28.61 213.45,28.16 214.79,28.16 215.35,27.6 v1(215.35,27.57)
  IN2 w0.508: v1(160.88,165.04) 161.23,165.39 161.23,166.24 159.6,167.87 159.6,172.08 159.69,172.17 159.69,173.3 v1(159.61,173.37) 159.26,173.72 154.73,173.72 153.19,172.18 v1(151.58,172.18) ; v1(321.21,36.54) 323.32,36.54 325.6,38.83 325.6,40.55 327.81,42.75 v1(327.81,43.07) ; v1(174.82,175.16) 175.56,174.42 182.36,174.42 185.43,171.36 187.12,171.36 189.8,168.67 189.8,168.21 190.81,167.2 190.81,165.5 191.07,165.25 192.59,165.25 193.32,164.52 194.12,164.52 194.67,165.08 v1(194.67,165.22) ; v1(94.5,19.93) 94.5,22.57 95.89,23.97 98.81,23.97 99.1,23.68 101.32,23.68 v1(102.69,25.05)
  IN2 w1.016: 216.55,148.5 216.09,148.04 212.46,148.04 211.65,147.23 205.83,147.23 203.96,145.35 202.32,143.71 202.32,122.56 204.39,120.49 204.39,111.6 204.62,111.38 204.62,99.17 205.96,97.82 205.96,91.17 206.41,90.72 206.41,87.31 207.26,86.46 208.87,86.46 209.51,85.81 209.51,84.99 208.86,84.34 208.86,83.22
  IN3 w0.381: v1(204.42,32.78) 204.62,32.78 205,33.16 205,39.11 202.61,41.5 202.61,42.08
  IN3 w0.508: v1(210.38,49.3) 210.38,50.15 210.96,50.73 210.96,57.7 v1(210.52,58.13) ; v1(151.58,172.18) 150.17,170.77 150.17,170.06 146.3,166.19 146.3,163.79 146.68,163.4 146.68,161.06 143.14,157.51 142.76,157.51 141.93,156.69 139.96,156.69 134.06,150.78 131.2,150.78 130.44,150.02 130.44,149.38 129.8,148.75 127.45,148.75 125.8,147.1 122.94,147.1 121.99,148.05 119.07,148.05 117.86,146.84 117.86,136.79 120.02,134.63 121.76,134.63 122.75,133.64 122.75,130.65 124.47,128.94 124.47,123.22 123.33,122.08 123.33,115.09 124.21,114.21 v1(124.21,112.94) ; v1(220.5,31.27) 221.2,31.27 224.16,34.23 227.33,34.23 228,33.56 v1(229.02,33.56) ; v1(59.25,15.23) 59.25,14.97 58.94,14.65 55.72,14.65 55.32,15.06 v1(55.32,16.94) ; v1(203.04,65.25) 203.04,59.26 202.2,58.42 202.2,50.63 201.51,49.93 201.51,43.62 202.61,42.51 202.61,42.08 ; 328.58,38.2 328.14,37.76 328.14,36.24 v1(327.38,35.48) ; 328.58,38.2 328.58,41.04 327.81,41.81 v1(327.81,43.07) ; 328.58,38.2 328.67,38.28 v1(329.28,38.28) ; v1(97.38,41.79) 96.78,42.39 96.78,45.93 98.24,47.39 v1(98.24,49.88) ; v1(287.22,6.32) 287.51,6.32 288.02,6.83 288.02,8.79 287.45,9.37 287.45,11.74 v1(286.84,12.35)
  IN4 w0.508: v1(174.19,175.17) 173.62,174.59 173.62,172.56 174.62,171.56 174.62,170.63 174.12,170.12 v1(173.9,170.12) ; v1(297.57,5.3) 298.45,4.42 302.4,4.42 303.79,5.81 304.61,5.81 v1(305.75,6.95) 306.32,7.53 308.77,7.53 v1(310.77,9.52) 310.77,9.54 311.48,10.26 318.01,10.26 319.66,8.6 321.76,8.6 322.23,8.13 v1(325.08,8.13) ; v1(194.67,165.22) 195.59,165.22 195.83,164.98 196.71,164.98 198.42,163.27 198.42,160.59 199.49,159.52 200.95,159.52 206.1,154.36 206.1,152.83 205.09,151.81 v1(205.09,149.71) ; v1(102.69,25.05) 102.71,25.07 102.71,29.12 102.22,29.61 99.96,29.61 99.45,30.12 99.45,41.35 98.94,41.85 97.45,41.85 v1(97.38,41.79)
  BOTTOM w0.127: v1(215.35,27.57) 215.09,27.83 214.61,27.83 UH1.BA24
  BOTTOM w0.203: v1(204.42,32.78) 204.04,32.41 UH1.W15
  BOTTOM w0.254: PU800.15 194.93,76.45 194.54,76.83 v1(194.54,77.06)
  BOTTOM w0.356: RM41.1 150.95,168.56 151.48,168.03 154.3,168.03 RE300.2
  BOTTOM w0.381: RM41.1 150.71,170.01 149.79,170.92 CM70.1 149.61,170.93 UM7.5 ; 124.53,114.21 124.6,114.21 125.04,114.65 125.05,114.65 125.43,115.03 PR5033.2
  BOTTOM w0.508: v1(304.87,45.32) v1(304.87,47.59) ; v1(194.6,73.16) 194.41,73.16 193.87,73.69 PR812.2 ; v1(173.9,170.12) 174.33,169.69 RT97.1 ; CV5.1 v1(160.88,165.04) ; RM41.1 151.22,170.01 151.61,170.4 151.61,172.16 v1(151.58,172.18) ; v1(272.38,30.34) 272.38,31.36 273.34,32.32 273.34,33.15 275.21,35.02 v1(276.04,35.02) ; PR1300.1 98.08,49.71 v1(98.24,49.88) ; RH453.2 220.77,32.01 RH533.2 ; RH453.2 RH515.2 RH545.2 ; RH453.2 v1(220.5,31.27) ; v1(102.69,25.05) CE22.1 102.36,23.77 UE9.5 ; v1(97.38,41.79) PR210.1 ; v1(325.08,8.13) 325.7,8.76 325.7,12.58 v1(326.48,13.36)
  vias: v1(11.63,50.83) v1(12.26,50.83) v1(12.9,50.83) v1(13.53,50.83) v1(14.17,50.83) v1(14.8,50.83) v1(44.59,21.88) v1(44.78,22.45) v1(45.16,23.02) v1(45.22,21.88) v1(45.41,22.45) v1(45.47,23.59) v1(45.86,23.02) v1(45.86,21.88) v1(46.11,23.59) v1(46.11,22.45) v1(46.49,23.02) v1(46.49,21.88) v1(46.74,23.59) v1(46.74,22.45) v1(47.13,23.02) v1(47.13,21.88) v1(47.38,23.59) v1(47.38,22.45) v1(47.76,23.02) v1(47.82,21.88) v1(48.01,22.45) v1(48.08,23.59) v1(48.4,23.02) v1(48.46,21.88) v1(48.71,23.59) v1(66.13,17.02) v1(66.18,15.77) v1(66.75,17.58) v1(66.75,17) v1(66.77,15.74) v1(66.77,15.16) v1(67.42,16.39) v1(67.42,15.72) v1(67.41,15.13) v1(68.32,17.61) v1(68.32,16.97) v1(160.85,164.41) v1(203.65,65.25) v1(208.73,82.01) v1(208.73,81.38) v1(223.62,149.14) v1(223.61,148.55) v1(229.02,30.19) v1(229.02,26.96) v1(229.37,23.72) v1(234.95,33.43) v1(234.95,30.19) v1(234.95,26.96) v1(234.95,23.72) v1(243.18,19.73) v1(243.77,19.73) v1(289.3,23.84) v1(289.94,23.84) v1(297.05,25.18) v1(302.51,25.07) v1(310.9,55.59) v1(310.9,54.96) v1(310.9,54.32) v1(311.54,55.59) v1(311.54,54.96) v1(311.54,54.32) v1(311.54,24.99) v1(312.17,55.59) v1(312.17,54.96) v1(312.17,54.32) v1(312.81,55.59) v1(312.81,54.96) v1(312.81,54.32) v1(316.75,56.48) v1(316.75,55.85) v1(317.38,56.48) v1(317.38,55.85) v4(205.63,69.23)
+3VALW_PD: length 2.2
  BOTTOM w0.152: v1(196.21,164.15) v4(196.78,164.15) 197.16,163.77 197.59,163.77 197.75,163.61 197.76,163.61 197.8,163.57 198.15,163.57 UT4.H1
+3VALWP: length 57.6
  IN1 w0.508: v1(42.24,25.24) 41.55,25.93 41.55,32.54 39.62,34.47 39.62,36.56 38.52,37.66 38.52,45.43 40.09,47 47.68,47 48.45,47.77 52.46,47.77 53.02,47.21 59.22,47.21 60.26,46.17 60.26,44.13 v1(60.33,44.05)
  BOTTOM w0.254: PC117.1 41.86,24.86 v1(42.24,25.24)
  BOTTOM w0.508: v1(60.33,44.05) 60.26,44.13 60.26,48.62 59.38,49.5 57.14,49.5 PR101.1
  vias: v1(43.95,19.72) v1(44.14,19.15) v1(44.52,18.64) v1(44.59,19.72) v1(44.84,19.18) v1(44.78,18.07) v1(45.16,18.64) v1(45.22,19.72) v1(45.22,17.49) v1(45.41,18.07) v1(45.54,19.21) v1(45.86,19.72) v1(45.86,18.64) v1(45.86,17.49) v1(46.11,18.07) v1(46.17,19.21) v1(46.49,19.72) v1(46.49,18.64) v1(46.49,17.49) v1(46.74,18.07) v1(46.87,19.21) v1(47.13,18.64) v1(47.13,17.49) v1(47.19,19.72) v4(50.62,19.27)
+3VGS: length 232.5
  TOP w0.356: v1(232.04,83.15) 231.57,83.62 RG402.2 ; RG400.2 215.57,102.28 214.5,103.35 213.48,103.35 212.42,102.29 v1(212.42,101.53)
  TOP w0.381: RG397.2 211.72,111.98 v1(211.46,111.73) ; v1(235.66,83.66) 235.66,83.73 235.34,84.04 235.34,84.09 235.28,84.16 RG19.2 235.39,84.22 235.88,84.71 235.88,85.53 235.43,85.99 RG18.2 ; RG402.2 RG157.2 ; RG7.2 216.75,110.35 v1(217.02,110.62)
  TOP w0.406: v1(215.92,122.78) 215.91,122.78 215.53,122.4 v1(212.99,122.4)
  TOP w0.508: v1(215.92,122.78) 216.8,123.66 216.8,145 v2(218.79,146.99) 220.76,148.96 222.58,148.96 224.86,151.25 226.69,151.25 227.51,152.07 227.51,157.47 226.5,158.48 226.5,159.2 226.87,159.56 v1(227.15,159.56) 227.4,159.56 228.07,158.9 RX7.1 228.23,158.53 228.56,158.2 229.28,158.2 229.69,158.61 RX5.1 ; v1(206.13,107.11) 209.74,110.73 210.46,110.73 v1(211.46,111.73)
  IN2 w0.508: v1(215.81,74.33) 215.81,75.22 212.86,78.16 212.86,79.89 214.33,81.35 214.33,85.05 213.2,86.18 213.2,87.01 v1(213.41,87.22)
  IN3 w0.508: v1(218.94,165.3) 218.94,164.27 219.72,163.49 222.88,163.49 225.94,160.43 225.94,160.22 226.59,159.56 v1(227.15,159.56) ; v1(208.61,66.82) 208.17,66.82 207.62,67.38 207.62,69.21 208.14,69.74 208.14,74.91 206.2,76.85 206.2,79.85 v1(205.53,80.51)
  IN4 w0.508: v1(234.42,88.75) 234.71,88.75 235.4,88.06 235.4,83.98 235.66,83.73 v1(235.66,83.66) ; v1(213.41,87.22) 212.7,87.92 212.7,97.54 211.86,98.38 211.86,100.97 v1(212.42,101.53)
  BOTTOM w0.356: QG1.5 213.28,122.69 v1(212.99,122.4) 213.28,122.1 QG1.2 213.28,120.91 213.11,120.75 212.04,120.75
  BOTTOM w0.381: v1(212.42,101.53) 212.38,101.57 212.38,102.55 214.13,104.3 RG153.2 ; 214.38,108.31 214.5,108.2 RG156.2 RG153.2 ; RG153.2 RG146.2 RG145.2 ; UG3.1 206.42,109.31 206.74,108.99 RG499.1 ; CG41.1 212.51,115.51 213.42,114.59 RG39.2
  BOTTOM w0.406: CG41.1 212.38,115.52 UG4.5 212.38,116.8 211.53,117.65 211.53,120.24 212.04,120.75 ; v1(211.46,111.73) 212.37,110.82 UV23.5
  BOTTOM w0.508: 232.03,77.69 231.79,77.93 231.07,77.93 230.56,77.42 230.56,77.16 229.77,76.36 229.77,75.93 229.06,75.22 220.28,75.22 219.46,76.04 216.71,76.04 215.81,75.14 v1(215.81,74.33) ; 214.38,108.31 213.88,108.82 RV536.1 CV651.1 216.08,109.68 v1(217.02,110.62) 217.02,112.2 214.63,114.59 RG39.2 ; v1(208.61,66.82) 207.36,65.58 UH5.7 ; 232.23,78.52 232.23,79.45 232.02,79.66 232.02,83.13 v1(232.04,83.15) ; v1(212.42,101.53) 212.43,101.54 214.14,101.54 RG12.1 214.45,101.24 RG13.1 ; v1(213.41,87.22) 212.52,86.33 210.64,86.33 208.63,84.32 QG2.1 ; RG499.1 206.52,107.5 v1(206.13,107.11) 206.08,107.07 204.17,107.07 C2499.1 R183.1 ; RV655.1 218.94,166.78 v1(218.94,165.3) ; CG41.1 212.1,115.51 211.72,115.13 211.72,111.98 v1(211.46,111.73) 211.36,111.63 210.31,111.63 208.97,112.96 RG170.1 ; v1(215.92,122.78) 215.91,122.78 215.81,122.88 RG41.1 215.06,123.76 214.46,124.37 RG42.1
  vias: v1(234.42,89.55)
+3VLP: length 392.1
  TOP w0.127: v1(21.42,26.18) 21.42,26.59 20.72,27.29 RA85.2
  TOP w0.381: CU26.1 27.92,43.68 28.05,43.81 UU5.5 28.88,43.81 29,43.68 29,43.6 29.3,43.3 30.65,43.3 30.7,43.25
  TOP w0.508: 26.83,42.74 26.16,43.42 RU7.1 ; 26.83,42.74 CU26.1 ; 26.83,42.74 25.75,41.66 RU1.1 ; RU5.1 RU4.1 33.14,45.27 DU8.1 34.93,46.29 v1(35.92,45.3) 35.92,43.95 34.29,42.32 v4(32.8,42.32) 32.43,42.32 31.51,43.25 30.7,43.25 ; v1(274.56,32.13) 274.56,32.27 275.07,32.78 PR25.2
  IN1 w0.127: v1(21.42,26.18) 21.42,28.86 22.46,29.91 22.46,31.47 25.11,34.12 29.52,34.12 31.1,35.69 32.69,35.69 35.04,38.03 35.04,39.36 35.92,40.25 v1(35.92,45.3)
  IN1 w0.508: v1(85.42,48.48) 84.91,48.99 67.13,48.99 66.66,49.46 54.03,49.46 53.42,50.08 v1(52.79,50.08) 51.83,49.12 46.49,49.12 45.54,50.07 43.19,50.07 42.36,49.24 39.44,49.24 35.92,45.72 v1(35.92,45.3)
  IN2 w0.508: v1(274.56,32.13) 263.9,42.79 234.36,42.79 233.67,43.48 227.94,43.48 226.87,44.55 215.16,44.55 214.27,45.44 214.26,45.44 213.91,45.8 207.23,45.8 206.5,45.07 203.27,45.07 200.92,47.43 191.84,47.43 190.76,46.35 190.76,44.34 189.78,43.36 183.36,43.36 180.29,40.29 178.74,40.29 178.36,39.9 174.51,39.9 174,40.41 174,45.66 172.72,46.94 107.66,46.94 107.36,46.64 101.9,46.64 101.05,47.49 95.77,47.49 94.92,48.33 85.57,48.33 v1(85.42,48.48)
  BOTTOM w0.203: PU100.3 53.86,47.97 53.95,48.06 PC101.1
  BOTTOM w0.508: v1(274.56,32.13) 274.56,33.3 274.95,33.69 277.92,33.69 279.36,32.25 281,32.25 281.63,32.89 281.63,33.01 282.19,33.56 PD5.3 282.72,34.06 282.4,34.38 281.68,34.38 281.33,34.03 280.74,34.03 280.24,34.54 280.24,36.44 283.42,39.62 288.71,39.62 289.41,38.91 296.18,38.91 297.19,37.9 297.19,31.21 298.33,30.08 298.33,27.14 297.66,26.47 297.66,24.93 297.16,24.43 297.16,19.79 297.97,18.99 297.97,14.43 300.17,12.22 306.59,12.22 307.41,13.05 307.41,14.35 v1(308.41,15.35) ; PC101.1 53.95,48.57 52.79,49.74 v1(52.79,50.08)
+3VS: length 608.6
  TOP w0.127: UA3.B2 19.02,22.7 v1(18.74,22.98)
  TOP w0.254: v1(324.37,13.05) 325.06,12.36 JIO.6
  TOP w0.305: CS2.1 181.72,68.08 182.4,68.76 US1.1 ; US1.14 180.31,71.08 CS7.1 ; US1.7 185.37,70.58 v1(185.62,70.83) 185.37,71.08 US1.8
  TOP w0.381: 216.67,22.38 216.57,22.28 CH201.1 ; CH188.1 206.32,33.79 v1(206.75,34.22) ; RH518.2 207.91,33.3 v1(207.79,33.19)
  TOP w0.406: UH3.5 215.7,22.26 216.39,22.26 CH201.1 ; 216.67,22.38 216.86,22.38 216.93,22.45 v1(216.99,22.45) ; UX1.5 v1(226.77,162.14)
  TOP w0.508: v1(185.62,71.66) 186.19,72.23 186.95,72.23 187.35,72.63 QS3.2 ; CS2.1 178.28,68.08 177.55,68.8 v1(177.55,70.58) ; v1(105.04,53.5) 105.7,53.5 106.49,54.28 106.49,56.25 105.94,56.8 RF1.2 108.09,57.31 114.12,63.34 114.12,65.29 119.52,70.69 119.52,71.53 v4(122.3,74.31) 123.74,75.76 RH525.1 ; v1(237.03,163.23) 236.36,163.23 236.32,163.19 234.63,163.19 v1(233.37,161.93) 230.68,159.24 230.68,158.54 228.3,156.16 228.3,148.98 CV37.1 228.04,146.82 v1(228.04,146.3) ; RF4.2 RF5.2 286.61,75.61 286.33,75.89 286.33,78.32 287.26,79.24 291.9,79.24 292.86,78.28 v1(292.86,76.8) ; CM31.1 126.69,153.77 125.93,154.53 v1(125.93,155.2) ; v1(179.27,54.83) 179.27,53.74 178.76,53.23 RD2.1 178.57,53.04 178.25,52.72 RD1.1 ; v1(277.95,151.8) 278.27,151.48 PR8215.1 ; v1(181.05,72.04) 180.74,72.04 180.3,71.6 CS7.1 ; v1(191.11,118.14) 191.11,117.92 192.48,116.56 192.48,111.09 192.79,110.78 RV625.2 ; RD4.1 RD5.1 177.57,39.62 CD34.1 178.19,45.75 v1(178.34,45.9) 178.26,45.97 CD35.1 ; v1(216.99,22.45) 217.81,22.45 218.45,21.81 218.45,20.35 218.86,19.94 ; RD3.1 156.55,48.49 157.43,49.37 v1(157.49,49.37) ; v1(157.43,40.29) 157.12,39.98 RD6.1 ; 218.86,19.94 218.25,19.33 217.37,19.33 217.01,19.69 RH502.1 RH501.1 ; 218.86,19.94 219.27,19.53 219.27,17.49 216.88,15.1 216.16,15.1 215.45,15.8 v1(215.08,15.8) 215.08,15.2 214.58,14.69 RH462.1 RH463.1 RH520.1 ; v1(125.93,152.24) 126.12,152.43 CM29.1 ; RE84.1 v1(310.66,12.01) ; v1(208.61,159.42) 206.38,157.19 v1(206.38,155.23) ; v1(213.14,151.25) 213.17,151.22 v1(213.17,146.88) ; v1(118.55,129.62) 121.41,129.62 122.31,130.52 122.31,135.1 122.5,135.29 PR515.1 ; RH85.2 221.06,27.79 v1(221.79,27.79) ; v1(192.32,108.39) 193.22,107.49 196.1,107.49 198.88,110.27 206.62,110.27 v1(208.02,111.67) ; RF2.2 105.04,59.85 v1(105.23,59.66) ; RN16.1 315.12,39.25 RN5.1 ; v1(302.85,49.97) 302.85,56.17 301.71,57.31 PR6075.2 PR6074.2 ; RA11.2 v1(40.79,27.53)
  IN1 w0.508: v1(207.79,33.19) 207.65,33.19 206.75,34.09 v1(206.75,34.22) ; v1(321.32,20.1) 320.53,20.1 313.75,13.32 311.28,13.32 310.66,12.7 v1(310.66,12.01) 311.18,11.49 316.33,11.49 317.89,13.05 v1(324.37,13.05) ; v1(103.21,11.19) 102.37,12.03 98.56,12.03 96.21,14.38 96.21,18.45 95.45,19.21 v1(95.45,19.95)
  IN2 w0.508: v1(40.79,27.53) 40.79,27.16 39.19,25.56 37.24,25.56 35.37,23.68 35.37,22.33 v1(35.86,21.84) 39.99,21.84 44.94,16.88 46.09,16.88 46.74,16.24 51.77,16.24 53.69,18.15 55.75,18.15 56.94,16.96 56.94,15.06 57.8,14.2 63.19,14.2 63.67,14.69 64.57,14.69 65.36,15.48 65.36,17.76 65.83,18.23 68.65,18.23 69.34,17.54 v1(70.4,17.54) ; v1(108.91,27.78) 107.13,26 104.05,26 103.39,25.34 103.39,24.85 101.55,23.02 98.75,23.02 98.5,23.27 96.85,23.27 95.45,21.88 v1(95.45,19.95) ; v1(177.19,61.39) 181.29,61.39 182.76,59.91 182.76,54.01 183.52,53.25 v1(184.16,53.25) ; v1(178.34,45.9) 178.34,45.89 178.34,44.88 178.88,44.34 180.78,44.34 181.31,44.87 v1(188.35,44.87) ; v1(237.66,162.59) 240.17,162.59 241.25,161.51 242.32,161.51 242.83,161 242.83,150.02 244.86,147.99 260.68,147.99 267.12,154.43 273.03,154.43 274.07,153.38 277.06,153.38 278.2,154.53 v1(278.2,155.29)
  IN3 w0.127: v1(18.74,22.98) 22.5,22.98 23.17,22.31 26.97,22.31 28.26,23.6 31.6,23.6 32.66,22.55 35.15,22.55 v1(35.86,21.84)
  IN3 w0.508: v1(277.95,151.8) 277.95,153.26 278.2,153.51 v1(278.2,155.29) ; v1(292.86,76.8) 292.86,76 297.8,71.06 297.8,63.68 302.85,58.62 v1(302.85,49.97) ; v1(207.79,33.19) 208.1,33.19 208.61,33.69 208.61,37.75 208.39,37.97 208.39,38.69 209.87,40.16 211.65,40.16 213.15,41.66 v1(213.15,43.44)
  IN4 w0.508: v1(170.3,150.83) 170.2,150.83 168.92,152.11 165.46,152.11 v1(165.22,152.36) ; v1(300.24,5.11) 299.2,6.15 299.2,6.87 300.36,8.03 301.57,8.03 301.95,8.41 308.36,8.41 310.66,10.71 v1(310.66,12.01) ; v1(124.14,120.66) 124.14,124.03 v1(118.55,129.62)
  BOTTOM w0.203: CV436.1 185.79,121.92 UV21.21 ; CV437.1 183.07,110.22 183.64,110.79 185.6,110.79 185.79,110.98 UV21.60 ; UV21.49 190.65,112.54 190.89,112.3 190.89,111.96 RV25.2 ; v1(191.11,118.14) UV21.35 ; v1(215.89,160.35) 216.36,159.87 U1.1 ; U1.24 222.17,154.38 222.39,154.17 CV447.1 ; v1(187.58,121.25) 187.79,121.04 UV21.26
  BOTTOM w0.254: v1(213.17,146.88) 213.75,147.47 U1302.5 ; UH1.AD13 206.25,33.73 v1(206.75,34.22)
  BOTTOM w0.305: JDIMM2.255 177.19,46.3 177.6,45.9 v1(178.34,45.9) ; JDIMM1.255 v1(177.19,61.39)
  BOTTOM w0.356: v1(206.88,14.22) 207.53,14.22 RH537.2 208.06,14.47 208.42,14.83 QH5.5 ; RV16.1 v1(233.37,161.93) ; v1(138.12,152.05) 138.12,151.8 138.5,151.42 RM86.1 ; v1(139.99,153.79) 139.99,152.78 139.45,152.24 RM79.1 ; v1(127.38,149.94) RM76.1 RM81.1
  BOTTOM w0.381: 168.59,158.4 168.59,157.97 169.21,157.35 ; 168.59,158.4 168.14,157.96 166.44,157.96 165.99,158.41 UM4.12 165.99,160.47 165.51,160.94 164.6,160.94 CM19.1 ; 168.59,158.4 UM4.16 168.59,160.41 168.41,160.58 CM18.1 ; 169.21,157.35 168.82,156.95 168.82,155.89 169.03,155.67 169.03,155.14 168.59,154.69 UM4.5 168.59,152.61 CM20.1 ; 169.21,157.35 169.3,157.26 172.52,157.26 172.9,157.64 v1(172.9,157.91) ; v1(103.21,11.19) 103.2,11.21 RS2.2 ; RT57.1 206.17,155.01 v1(206.38,155.23) ; RT57.1 RT58.1 ; RT57.1 205.47,155.04 RT107.1 ; v1(139.9,158.72) 140.42,159.24 140.42,160.86 140.15,161.13 139.2,161.13 138.92,160.85 RM26.1 ; v1(139.9,158.72) 139.43,158.25 RM66.2 ; v1(139.9,158.72) 139.77,158.85 RM85.1 ; v1(123.96,158.08) 123.96,157.82 124.32,157.46 RM14.1 ; UM4.9 165.99,152.36 CM21.1
  BOTTOM w0.432: v1(209.69,15.84) 209.69,15.45 210.31,14.83 QH5.2
  BOTTOM w0.508: RV629.2 RV21.2 v1(187.19,107.93) ; v1(165.22,152.36) CM21.1 CM20.1 ; v1(186.51,121.47) 186.03,121.96 CV436.1 ; RL5.2 227.94,146.23 228,146.3 v1(228.04,146.3) ; v1(278.2,155.29) 276.31,157.18 276.31,157.44 PR8203.2 ; RV658.2 v1(192.32,108.39) ; RA5.2 35.86,22.29 v1(35.86,21.84) ; v1(208.02,111.67) 208.07,111.73 RG171.1 ; RV659.2 v1(189.24,87.83) ; v1(124.14,120.66) 124.11,120.69 PR5016.1 ; CV36.1 232.51,147.78 v1(232.6,147.87) ; QX2.1 225.93,165.92 225.52,165.51 CV20.1 225.52,162.99 226.38,162.14 v1(226.77,162.14) ; RV25.2 191.25,111.33 v1(190.77,110.86) ; RM18.1 173.31,158.37 172.9,157.96 v1(172.9,157.91) ; v1(195.04,14.13) 194.35,13.43 R2.1 ; RV631.2 184.18,105.7 RV634.1 184.18,106.47 183.63,107.03 183.63,107.76 183.79,107.93 v1(184.15,107.93) RV635.1 ; CV1314.1 214.05,150.57 213.85,150.57 213.85,150.6 213.79,150.6 v1(213.14,151.25) 213.14,151.95 213.5,152.31 213.5,152.52 CV446.1 ; CM33.1 CM30.1 v1(125.93,155.2) ; RC62.2 213.61,13.24 RC65.2 214.18,13.4 215.16,14.38 RH517.1 215.08,14.65 v1(215.08,15.8) ; CV437.1 182.93,109.61 182.18,110.36 v1(182.1,110.36) ; v1(213.15,43.44) 213.73,44.03 RH5.1 ; 172.88,164.98 172.88,165.34 173.57,166.02 174,166.02 v1(174.25,166.28) ; RH584.2 199.84,13.23 v1(199.84,12.61) ; v1(95.45,19.95) 95.45,19.97 94.99,20.43 RE20.2 ; RV623.2 RV627.2 185.99,108.05 v1(185.9,107.97) ; CV447.1 CV445.1 224.29,154.17 224.8,153.66 v1(224.8,153.38) ; v1(190.52,124.14) 190.52,123.75 RV19.1 ; v1(170.3,150.83) RM96.1 RM20.1 ; RV202.1 RV204.1 218.12,150.24 217.93,150.04 217.5,150.04 217.49,150.03 216.19,150.03 215.83,150.39 RV200.2 ; v1(188.35,44.87) R181.1 ; RV198.1 v1(216.05,162.07)
  vias: v1(70.4,18.18) v1(70.4,16.91) v1(71.1,18.18) v1(71.1,17.54) v1(71.1,16.91) v1(71.74,18.18) v1(71.74,17.54) v1(71.74,16.91) v1(72.44,18.18) v1(72.44,17.54) v1(72.44,16.91) v1(123.33,11.65) v1(123.33,11.02) v1(123.96,11.65) v1(123.96,11.02) v1(124.6,11.65) v1(124.6,11.02) v1(125.23,11.65) v1(125.23,11.02) v1(160.91,160.43) v1(161.18,160.95) v1(163.65,35.34) v1(164.41,35.34) v1(167.04,168.62) v1(167.08,167.99) v1(177.19,62.02) v1(205.33,24.43) v1(205.57,24.94) v1(221.81,23.29) v1(222.44,23.29) v1(237.03,162.59) v1(237.66,163.23) v1(300.78,39.35) v1(301.45,39.34) v1(302.08,39.34) v1(302.72,39.34) v1(303.7,43.16) v1(303.7,42.53) v1(304.34,43.16) v1(304.34,42.53) v1(311.41,44.16) v1(311.41,43.53) v1(312.17,44.16) v1(312.17,43.53) v1(317.18,39.69) v1(317.76,39.67) v4(199.69,14.42) v4(318.58,40.68)
+3VS_CAM: length 0.6
  BOTTOM w0.102: v1(164.7,171.46) 164.41,171.16 v4(164.22,171.16)
  vias: v1(160.22,165.42) v1(160.62,165.85) v1(164.22,171.8)
+3VS_DP:
  vias: v2(239.62,168.01)
+3VS_SSD:
  vias: v1(235.72,6.64) v1(236.36,6.64) v1(236.99,6.64) v1(237.63,6.64) v1(251.56,8.24) v1(252.01,8.69) v1(253.63,6.64) v1(254.26,6.64) v1(254.45,6.06) v1(255.09,6.06) v1(260.69,18.84) v1(260.69,17.29) v1(261.1,17.76) v1(261.17,19.31) v1(261.54,18.14) v1(261.59,19.76) v1(273.16,9.1) v1(273.53,8.63) v1(277,21.43) v1(277,20.35) v1(277.58,21.43) v1(277.58,20.35) v1(278.16,20.35) v1(278.2,21.43) v1(279.28,5.24) v1(279.92,5.24) v1(280.55,5.24) v1(280.68,5.87) v1(280.81,6.51) v1(281.25,5.24) v1(281.38,5.87) v1(281.5,6.51) v1(319.48,49.63) v1(319.48,48.99) v1(320.11,49.63) v1(320.11,48.99) v1(320.75,49.63) v1(320.75,48.99) v1(321.38,49.63) v1(321.38,48.99) v1(322.02,49.63) v1(322.02,48.99) v1(322.65,49.63) v1(322.65,48.99) v1(325.83,5.18) v1(325.83,4.54) v1(326.46,5.18) v1(326.46,4.54) v1(327.1,5.18) v1(327.1,4.54) v1(327.8,5.18) v1(327.8,4.54) v1(333.07,29.12) v1(333.07,28.48) v1(333.07,27.85) v1(333.7,29.12) v1(333.7,28.48) v1(333.7,27.85) v1(334.34,29.12) v1(334.34,28.48) v1(334.34,27.85) v1(334.55,46.26) v1(334.55,45.63) v1(334.55,44.99) v1(334.55,44.36) v1(335.03,29.12) v1(335.03,28.48) v1(335.03,27.85) v1(335.18,46.26) v1(335.18,45.63) v1(335.18,44.99) v1(335.18,44.36) v1(335.82,46.26) v1(335.82,45.63) v1(335.82,44.99) v1(335.82,44.36) v2(277,18)
+3VS_TBT: length 18.1
  TOP w0.178: UT1.H9 179.68,166.73 v1(180.01,167.07)
  TOP w0.254: RT21.1 177.75,172.97 v1(177.55,173.16) ; UT1.R13 181.94,163.17 v1(181.94,163.15)
  TOP w0.508: v1(182.57,151.29) 181.94,150.65 179.08,150.65 v1(178.44,151.29) 178.44,152.18 177.49,153.13 175.33,153.13 174.06,154.4 v1(174.06,155.92)
  BOTTOM w0.356: v1(182.57,151.29) RT77.2
  BOTTOM w0.381: CT48.1 181.9,163.19 v1(181.94,163.15) ; v1(178.44,151.29) 178.19,151.54 RT76.2 178.18,152.69 RT20.1
  vias: v1(177.94,173.64) v4(176.86,173.81)
+3VS_TOUCH: length 126.8
  TOP w0.508: v1(215.4,9.89) 215.4,9.87 214.17,11.11 210.73,11.11 v4(208.56,8.93) 207.65,8.03 196.67,8.03 194.88,9.83 v1(194.84,9.83) ; v1(301.91,6.53) 301.91,4.9 302.21,4.6 RE100.1 RE101.1
  IN2 w0.508: v1(215.4,9.89) 215.4,10.18 216.61,11.39 225.28,11.39 226.77,9.91 231.66,9.91 232,10.26 233.03,10.26 233.66,10.88 240.25,10.88 241.3,9.84 246.42,9.84 246.81,10.23 252.76,10.23 253.41,10.88 258.44,10.88 258.64,11.08 265.87,11.08 266.49,10.46 271.53,10.46 272.14,11.08 273.79,11.08 276.46,8.41 286.2,8.41 286.84,7.78 290.78,7.78 291.73,6.83 292.49,6.83 293,6.32 293.63,6.32 294.08,6.76 298.84,6.76 299.35,6.26 301.63,6.26 v1(301.91,6.53)
  BOTTOM w0.305: v1(194.84,9.83) 194.82,9.83 194.3,9.3 192.92,9.3 191.82,10.4 JTP.11 191.82,13.09 R2.2
  BOTTOM w0.508: R2.2 192.16,13.88 192.4,14.12 C2.1
+5V_HDD:
  vias: v1(126.88,11.14) v1(127.52,11.14) v1(128.15,11.14) v1(128.79,11.14) v2(127.45,11.65)
+5V_PVDD: length 2.9
  BOTTOM w0.508: RA68.2 27.82,39.58 CA6.1 27.81,40.11 CA5.1 v1(27.38,41.24)
  vias: v2(30.11,40.74)
+5V_TOBII:
  vias: v4(153.56,161.31)
+5V_USB_PWR1:
  vias: v1(18.52,47.44) v1(18.52,46.81) v1(19.16,47.44) v1(19.16,46.81) v4(20.14,47.4)
+5V_USB_PWR2:
  vias: v1(266.65,22.57) v1(267.23,22.57) v1(267.81,22.57) v1(268.17,24.23) v1(326.49,11.77) v1(326.49,11.07) v1(326.49,10.48) v1(327.12,11.77) v1(327.12,11.07) v1(327.12,10.48) v2(268.17,23.07)
+5V_USBC_VBUS: length 402.4
  TOP w0.254: JUSBC2.B4 6.28,59.17 6.6,58.85 6.73,58.85 6.75,58.83 v1(6.76,58.83) 7,58.83 7.09,58.92 JUSBC2.A9 8.27,58.92 v1(8.36,58.83) ; JUSBC2.B9 6.54,61.68 v1(6.68,61.82) 6.79,61.82 7.18,61.42 JUSBC2.A4 8.37,61.42 v1(8.51,61.57)
  TOP w0.381: RU24.1 306.89,59.21 v1(306.21,59.21)
  TOP w0.508: v1(10.36,60.67) 9.91,60.67 9.57,61.02 CU18.1 9.03,61.37 8.83,61.57 v1(8.51,61.57) ; v1(236.72,35.72) 236.72,35.05 239.76,32.01 239.76,24.29 240.34,23.71 240.34,17.22 239.95,16.82 239.95,15.91 239.3,15.26 238.88,15.26 236.26,12.64 233.81,12.64 230.37,9.2 230.37,8.36 229.64,7.63 227.34,7.63 226.55,8.41 v1(226.55,8.48)
  IN1 w0.508: v1(306.21,59.21) 305.52,59.21 303.56,57.26 303.56,51.54 301.6,49.57 301.6,47.63 300.26,46.3 300.26,43.65 299.19,42.58 299.19,41.44 296.6,38.84 289.56,38.84 288.67,39.73 271.92,39.73 269.28,42.37 256.73,42.37 255.88,41.52 253.6,41.52 253.13,41.05 243.83,41.05 239.3,36.52 237.51,36.52 v1(236.72,35.72)
  IN3 w0.508: v1(226.55,8.48) 226.36,8.67 206.68,8.67 205.76,7.75 193.98,7.75 192.44,9.29 189.03,9.29 184.95,13.37 151.24,13.37 148.47,10.6 146.95,10.6 145.34,12.21 133.55,12.21 131.67,10.33 122.47,10.33 121.91,9.77 113.51,9.77 110.86,7.12 108.59,7.12 106.3,9.42 104.28,9.42 103.54,10.15 88.29,10.15 86.56,8.42 81.35,8.42 81.29,8.36 71.08,8.36 68.25,11.18 62.8,11.18 62.25,11.73 51.29,11.73 49.7,13.32 45.6,13.32 44.97,13.95 43.49,13.95 40.48,16.96 38.67,16.96 36.23,19.4 v1(34.06,19.4)
  IN4 w0.508: v1(34.06,19.4) 34.58,19.92 34.58,20.62 33.79,21.41 33.79,24.97 33.45,25.32 33.45,26.52 35.04,28.11 35.04,32.75 34.13,33.65 34.13,38.19 33.44,38.88 27.87,38.88 24.66,35.67 22.9,35.67 21.9,36.67 21.9,42.51 19.82,44.6 17.74,44.6 16.91,45.42 16.91,49.17 16.21,49.87 11.57,49.87 10.89,50.54 10.89,53.11 v1(11.06,53.28)
  vias: v1(11.06,54.55) v1(11.06,53.91) v1(11.7,54.55) v1(11.7,53.91) v1(11.7,53.28) v4(9.72,62.45)
+5VA: length 7.4
  TOP w0.127: v2(30.1,35.45) 29.99,35.45 29.17,36.28 RA8.1
  TOP w0.508: RA8.1 28.79,36.79 v1(28.47,37.11)
  BOTTOM w0.203: 29.55,35.46 30.42,34.59 UA1.45
  BOTTOM w0.508: 29.55,35.46 CA15.1 28.74,36.11 CA14.1 28.6,37.11 v1(28.47,37.11)
+5VALW: length 512.1
  TOP w0.254: C2520.1 182.28,77.86 181.87,78.27 U20.3
  TOP w0.305: PU300.7 248.61,23.28 v1(248.68,23.34) ; U19.3 178.25,77.85 v1(178.37,77.73) ; U16.3 v1(316.49,54.44)
  TOP w0.356: RE525.1 226.98,22.65 v1(226.98,23.03) ; RE521.1 227.15,29.05 226.95,29.25 v1(226.95,29.53) ; RE449.1 227.15,25.81 226.95,26.02 v1(226.95,26.29) ; RE529.1 226.54,32.2 226.32,32.42
  TOP w0.381: QE54.1 226.01,25.94 226.35,26.29 v1(226.95,26.29) ; RE517.1 223.69,25.53 v1(223.96,25.8)
  TOP w0.432: v1(226.47,32.42) 226.32,32.42 226.02,32.11 225.11,32.11 225.07,32.16 QE56.1 ; v1(223.96,25.8) 223.97,25.79 223.97,25.65 224.64,24.98 QE54.4 ; v1(226.95,29.53) 226.87,29.46 226.37,29.46 225.94,29.02 QE55.1 ; v1(223.44,26.47) 224.08,27.11 QE55.4
  TOP w0.508: v1(202.57,175.23) 202.54,175.19 RE154.1 201.3,175.19 v1(201.24,175.25) ; C2520.1 184.26,78.3 v1(183.94,78.62) ; PR8.1 273.73,28.26 v4(272.71,27.24) v1(270.71,25.24) ; RE156.1 198.13,172.03 197.72,172.43 197.72,173.51 198.26,174.05 198.26,174.07 ; C2521.1 178.02,77.73 v1(178.37,77.73) ; v1(152.98,162.53) 153.36,162.91 CE81.1 RE161.2 ; v1(316.49,54.44) 316.49,54.89 316.43,54.95 C2516.1 ; 203.21,69.37 203.21,72.04 203.65,72.49 203.65,75.69 203.15,76.19 200.92,76.19 200.41,76.7 200.41,79.98 198,82.39 198,86.65 202.83,91.47 208.29,91.47 v1(209.62,90.14) ; JWDB.1 205.49,9.99 204.86,9.37 202.3,9.37 200.8,10.88 200.8,12.25 v1(200.47,12.58) ; v1(204.99,175.23) RE158.1
  IN1 w0.508: v1(316.49,54.44) 316.49,48.41 316.99,47.91 324.68,47.91 326.68,49.91 332.56,49.91 333.66,48.8 335.67,48.8 336.43,48.04 336.43,23.34 328.56,15.46 319.93,15.46 v1(319.58,15.12) ; v1(208.99,154.41) 209,154.41 210.92,152.5 212.57,152.5 214.73,154.65 215.77,154.65 216.81,155.7 220.32,155.7 221.19,154.82 223.04,154.82 223.63,155.4 223.63,157.49 224.93,158.79 226.2,158.79 227.11,157.88 232.47,157.88 232.61,157.74 237.88,157.74 238.39,157.23 238.39,152.05 243.02,147.42 255.41,147.42 255.91,147.92 262.2,147.92 263.72,149.45 263.72,152.89 264.76,153.93 272.64,153.93 v1(274.07,152.5) ; v1(241.05,39.4) 239.48,37.83 235.23,37.83 232.99,35.59 230.07,35.59 227.8,33.32 227.8,32.93 227.29,32.42 v1(226.47,32.42)
  IN2 w0.457: 202.88,162.5 202.88,163.14 202.56,163.45 v1(202.17,163.45)
  IN2 w0.508: v1(92.85,40.1) 92.85,39.85 93.35,39.34 95.77,39.34 96.21,39.78 v1(96.21,40.1) ; v1(203.9,161.02) 203.34,161.02 202.88,161.47 202.88,162.5 ; v1(261.27,27.04) 261.27,26.15 260.68,25.56 257.06,25.56 253.75,22.26 249.76,22.26 v1(248.68,23.34) ; v1(144.8,162.59) 146.57,162.59 147.39,161.77 152.22,161.77 v1(152.98,162.53)
  IN2 w1.016: 203.48,79.42 203.49,79.43 203.49,83.13 202.76,83.85 202.76,92.01 203.18,92.42 203.18,95.73 201.93,96.99 201.93,109.63 199.73,111.82 199.73,146.78 205.56,152.61 206.57,152.61 207.73,153.77 ; 203.18,72.17 203.18,73.35 203.7,73.87 203.7,77.92
  IN3 w0.508: v1(101.86,55.4) 101.34,54.88 101.34,51.92 100.06,50.64 98.11,50.64 96.71,49.24 91.32,49.24 88.72,46.64 88.72,42.64 91.26,40.1 v1(92.85,40.1) ; v1(248.68,23.34) 248.68,23.24 248.19,22.75 245.48,22.75 245.46,22.73 240.79,22.73 239.56,23.95 236.19,23.95 235.35,23.11 234.43,23.11 233.56,23.97 231.02,23.97 226.95,28.05 v1(226.95,29.53)
  BOTTOM w0.203: UT4.H10 202.28,163.57 v1(202.17,163.45) ; U17.4 v1(64.69,16.05)
  BOTTOM w0.254: PC1312.1 202.89,78.53 202.94,78.48 v1(202.94,78.33) 202.94,77.92 203.19,77.67 PU1301.4 ; UZ21.4 127.6,97.51 127.42,97.33 127.06,97.33 126.63,97.76
  BOTTOM w0.406: v1(232.1,12.16) 231.91,11.97 231.2,11.97 229.49,10.27 226.75,10.27 226.13,9.64 226.13,9.04 225.55,8.46 223.88,8.46 223.47,8.06 JKB.1
  BOTTOM w0.508: v1(92.85,40.1) 92.85,40.04 92.27,39.47 PR204.1 ; v1(114.05,77.44) 121.1,84.49 125.1,84.49 127.83,87.22 127.83,94.01 126.63,95.22 C2519.1 ; RG47.1 209.72,90.05 v1(209.62,90.14) ; RM92.1 148.51,163.61 RM91.1 148.52,163.18 147.94,162.59 v1(144.8,162.59) ; v1(152.98,162.53) 152.74,162.77 RM93.1 RM94.1 ; v1(96.21,40.1) PR203.1 ; 241.07,40.38 242.4,41.71 254.81,41.71 256.83,43.73 256.83,51.24 257.77,52.18 RG513.1 260.52,52.18 RG515.1 ; v1(274.07,152.5) 274.07,152.78 PR8200.2
  vias: v1(20.56,40.9) v1(20.56,40.27) v1(21.26,40.9) v1(21.26,40.27) v1(24.5,49.45) v1(24.5,48.81) v1(24.5,48.18) v1(25.13,49.45) v1(25.13,48.81) v1(25.13,48.18) v1(39.32,44.74) v1(39.44,45.37) v1(39.95,44.74) v1(40.08,45.37) v1(40.36,44.18) v1(40.59,44.74) v1(40.78,45.37) v1(40.97,44.18) v1(41.22,44.74) v1(41.41,45.37) v1(41.6,44.18) v1(41.86,44.74) v1(42.05,45.37) v1(42.24,44.23) v1(42.55,44.8) v1(42.68,45.37) v1(42.87,44.23) v1(43.65,45.43) v1(44.26,45.43) v1(44.89,45.43) v1(45.53,45.43) v1(46.16,45.43) v1(47.84,50.09) v1(48.47,50.09) v1(49.11,50.09) v1(49.74,50.09) v1(50.44,50.09) v1(51.08,50.09) v1(60.38,42.91) v1(60.97,42.91) v1(61.55,42.91) v1(61.65,16.92) v1(61.63,16.3) v1(61.63,15.66) v1(61.63,15.03) v1(62.26,42.91) v1(62.26,16.3) v1(62.26,15.66) v1(62.26,15.03) v1(62.29,16.92) v1(62.85,42.91) v1(62.97,16.3) v1(62.97,15.66) v1(62.97,15.03) v1(63.43,42.91) v1(101.86,56.67) v1(101.86,56.08) v1(101.95,57.41) v1(102.37,57.86) v1(102.52,57.27) v1(102.5,56.67) v1(102.5,56.08) v1(102.5,55.4) v1(102.82,47.48) v1(103.02,58.41) v1(102.99,57.78) v1(103.44,58.91) v1(109.85,63.9) v1(109.85,63.23) v1(110.33,65.09) v1(110.33,64.46) v1(110.46,63.81) v1(110.46,63.14) v1(110.97,65.09) v1(110.97,64.46) v1(111.1,63.81) v1(111.1,63.14) v1(111.6,65.09) v1(111.6,64.46) v1(142.54,163.9) v1(143.02,164.23) v1(143.53,162.59) v1(143.8,163.89) v1(144.17,162.59) v1(144.31,164.19) v1(144.31,163.57) v1(149.36,175.93) v1(149.36,175.29) v1(149.91,177.25) v1(149.93,176.18) v1(150.66,177.84) v1(150.58,177.25) v1(150.63,176.18) v1(171.99,177.83) v1(171.99,177.25) v1(171.99,176.66) v1(172.27,176.14) v1(172.58,177.83) v1(172.58,177.25) v1(172.58,176.66) v1(172.88,176.14) v1(173.16,177.83) v1(173.16,177.25) v1(173.16,176.66) v1(197.11,173.44) v1(199.11,175.2) v1(199.27,174.47) v1(199.78,175.17) v1(199.88,174.42) v1(202.33,68.37) v1(202.61,174.19) v1(202.82,68.73) v1(203.9,159.7) v1(203.9,159.11) v1(205,174.11) v1(207.73,156.3) v1(207.72,155.67) v1(207.72,155.04) v1(208.35,156.31) v1(208.35,155.67) v1(208.35,155.05) v1(208.35,154.46) v1(208.66,153.89) v1(208.99,156.31) v1(208.99,155.67) v1(208.99,155.05) v1(222.42,165.35) v1(261.27,27.67) v1(261.9,27.67) v1(261.9,27.04) v1(319.58,14.48) v1(320.94,7.72) v1(321.57,7.72) v4(46.49,46.9) v4(64.52,7.65)
