# Allegro board LAD752PR10-0816.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
KSO1: length 79.6
  TOP w0.107: RE516.1 223.19,22.61 v1(222.78,22.21) ; UE5.40 288.51,19.41 285.46,22.47 285.46,24.75 285.13,25.08 v1(285.13,25.34)
  IN3 w0.091: v1(222.78,22.21) 223.31,22.21 225.96,19.56 227.44,19.56 228.78,18.21 239.85,18.21 240.47,17.59 246.27,17.59 246.47,17.8 250.09,17.8 251.64,19.34 255.65,19.34 259.04,22.74 262.7,22.74 266.59,26.62 276.06,26.62 276.6,26.07 279.67,26.07 280.4,25.34 v1(285.13,25.34)
KSO2: length 89
  TOP w0.107: v1(283.93,38.43) 284.51,37.86 284.51,25.12 285.23,24.4 285.23,22.17 288.38,19.01 UE5.41 ; v1(230.77,34.45) 231.28,34.45 231.71,34.01 231.71,29.3 231.38,28.96 RE520.1
  IN1 w0.097: v1(230.77,34.45) 231.15,34.83 238.22,34.83 244.01,40.62 253.31,40.62 253.77,41.09 256.05,41.09 256.91,41.94 269.1,41.94 272.15,38.89 283.46,38.89 283.92,38.43 v1(283.93,38.43)
KSO3: length 119.8
  TOP w0.107: RE524.1 232.14,23.8 232.14,28.74 232.41,29 232.41,30.12 232.61,30.32 232.61,32.89 v1(233.05,33.33) ; v1(292.73,10.89) 292.73,18.51 292.62,18.61 UE5.42 v4(289.7,18.61)
  IN1 w0.097: v1(233.05,33.33) 233.88,34.16 238.5,34.16 244.29,39.95 253.59,39.95 254.05,40.42 256.33,40.42 257.19,41.27 268.82,41.27 271.94,38.16 282.74,38.16 283.27,37.62 287,37.62 v1(287.66,36.96)
  BOTTOM w0.107: JEC.1 285.17,8.44 286.22,9.48 287.58,9.48 288.12,10.02 290.35,10.02 291.22,10.89 v1(292.73,10.89) 292.73,12.48 291.79,13.42 291.79,17.93 288.89,20.82 288.89,31.39 287.66,32.62 287.66,36.96 v1(287.66,36.96)
KSO4: length 84.3
  TOP w0.107: v1(230.81,33.57) 230.83,33.57 231.24,33.16 231.24,32.61 RE528.1 ; UE5.43 291.5,18.23 289.54,18.23 288.99,18.78 288.02,18.78 284.99,21.8 284.99,24.31 284.28,25.03 284.28,36.78 283.34,37.72 v1(283.34,38.45)
  IN1 w0.097: v1(283.34,38.45) 283.18,38.61 272.12,38.61 269.01,41.72 257,41.72 256.15,40.87 253.87,40.87 253.4,40.4 244.1,40.4 238.31,34.61 232.26,34.61 231.22,33.57 v1(230.81,33.57)
KSO5: length 246.9
  TOP w0.107: UE5.44 289.62,17.81 289.05,18.38 v2(287.89,18.38) 287.83,18.38 284.76,21.45 284.76,24.21 284.04,24.93 284.04,36.27 v1(283.54,36.77)
  IN1 w0.097: v1(283.54,36.77) 282.37,37.94 271.84,37.94 268.73,41.05 257.28,41.05 256.42,40.19 254.14,40.19 252.22,38.27 248.42,38.27 242.42,32.27 235.8,32.27 235.53,32.54 234.63,32.54 234.37,32.29 230.65,32.29 230.08,32.86 228.34,32.86 227.47,31.99 224.96,31.99 224.57,32.38 224.57,33.62 225.67,34.73 225.67,37.64 221.98,41.33 221.98,47.6 v1(222.26,47.87) ; v1(140.47,7.5) 140.47,9.15 144.98,13.66 v1(144.98,35.53)
  IN4 w0.097: v1(144.98,35.53) 144.98,37.51 147.03,39.56 177.95,39.56 178.72,40.32 181.02,40.32 184.17,43.46 184.17,51.5 183.48,52.19 183.48,57.03 187.29,60.84 193.19,60.84 194.51,62.17 195.93,62.17 197.2,60.9 205.15,60.9 206.83,59.21 208.73,59.21 210.52,57.43 210.52,55.39 212.18,53.72 212.18,52.58 214.82,49.95 220.18,49.95 v1(222.26,47.87)
  BOTTOM w0.107: JKB2.3 140.38,7.59 v1(140.47,7.5) 140.38,7.41 JKB2.4
LAN_ACTIVITY#: length 31.4
  TOP w0.107: JLAN.10 247.66,170.04 247.66,170.97 247.09,171.54 245.55,171.54 243.91,169.91 243.91,167.88 CL27.1 241.74,165.78 240.23,164.27 240.23,159.54 v2(239.53,158.85) 238.48,157.8 233.09,157.8 232.74,157.45 232.74,156.88 232.16,156.31 232.16,155.16 v1(232.67,154.65)
  BOTTOM w0.107: UL1.38 232.91,154.42 v1(232.67,154.65)
LAN_LED2#: length 7.5
  TOP w0.127: v2(257.5,164.43) 259.03,164.43 259.41,164.81 RL15.1
  TOP w0.508: RL15.1 259.62,164.89 260.07,165.34 260.07,166.17 259.56,166.67 CL29.1 260.18,167.44 JLAN.13
LAN_LED2#_R: length 42.9
  TOP w0.508: v1(260.61,164.5) 260.27,164.5 259.75,163.98 RL15.2 ; v1(236.78,149.98) 238.8,149.98 239.04,150.22 239.54,150.22 v2(242.11,147.65) 243.11,146.65 254.1,146.65 257.62,150.17 v1(257.62,150.62)
  IN1 w0.508: v1(257.62,150.62) 259.75,152.75 259.75,161.13 258.86,162.02 258.86,163.09 260.27,164.5 v1(260.61,164.5)
  BOTTOM w0.203: UL1.23 237.09,150.29 v1(236.78,149.98)
LAN_LINK#: length 6.6
  TOP w0.107: RL13.1 257.82,164.89 257.37,165.34 257.37,166.15 257.9,166.67 CL28.1 258.9,167.05 v2(258.9,167.86) 258.9,168.15 JLAN.11
LAN_LINK#_R: length 44.7
  TOP w0.107: v1(232.61,155.54) 232.61,155.61 RL4.2 233.09,156.6 233.09,157.3 233.36,157.57 238.4,157.57 240.55,155.42 240.55,150.91 v2(241.63,149.83) 244.23,147.23 253.61,147.23 259.08,152.69 QL3.2
  BOTTOM w0.107: v1(232.61,155.54) 232.61,155.31 233.1,154.82 UL1.39
LAN_MDIN0: length 15.8
  IN4 w0.089: v1(240.05,154.76) 240.05,154.83 240.14,154.92 240.62,154.92 241.12,155.42 241.12,156.76 242.46,158.09 242.46,163.65 242.66,163.86 244.02,163.86 v1(244.13,163.74)
  BOTTOM w0.089: v1(240.05,154.76) 239.91,154.89 239.32,154.89 239.24,154.82 UL1.12 ; TL1.11 243.44,163.4 243.56,163.53 243.56,163.77 243.69,163.9 243.98,163.9 v1(244.13,163.74)
LAN_MDIN1: length 12
  IN1 w0.089: v1(244.17,158.61) 244,158.78 242.62,158.78 240.73,156.89 240.73,153.96 240.48,153.7 240.17,153.7 240.07,153.61 v1(240.07,153.55)
  BOTTOM w0.089: TL1.7 243.38,158.32 243.47,158.41 243.47,158.66 243.59,158.78 244.02,158.78 244.17,158.63 v1(244.17,158.61) ; UL1.15 239.24,153.62 239.32,153.7 239.98,153.7 240.07,153.61 v1(240.07,153.55)
LAN_MDIN2: length 11.2
  IN4 w0.089: v1(240.05,152.34) 240.21,152.5 241.7,152.5 243.03,153.83 243.03,155.94 243.38,156.3 244.08,156.3 v1(244.25,156.12)
  BOTTOM w0.089: v1(244.25,156.12) 244.1,156.28 243.69,156.28 243.56,156.15 243.56,155.91 243.44,155.78 TL1.5 ; v1(240.05,152.34) 240.05,152.41 239.96,152.5 239.21,152.5 239.14,152.42 UL1.18
LAN_MDIN3: length 11.1
  IN4 w0.089: v1(244.23,151.04) 244.23,151.1 244.09,151.24 242.83,151.24 240.73,149.14 239.41,149.14 v1(239.29,149.02)
  BOTTOM w0.089: v1(244.23,151.04) 244.06,151.21 243.83,151.21 243.32,150.7 TL1.1 ; UL1.21 237.89,150.43 237.98,150.34 238.58,150.34 238.69,150.22 238.69,149.64 238.99,149.34 238.99,149.32 v1(239.29,149.02)
LAN_MDIP0: length 15.8
  IN4 w0.089: v1(244.13,164.33) 243.92,164.12 242.55,164.12 242.2,163.76 242.2,158.2 240.86,156.86 240.86,155.53 240.51,155.18 240.21,155.18 v1(240.05,155.34)
  BOTTOM w0.089: TL1.12 243.44,164.67 243.56,164.54 243.56,164.3 243.69,164.17 243.98,164.17 v1(244.13,164.33) ; UL1.11 239.24,155.22 239.3,155.16 239.87,155.16 v1(240.05,155.34)
LAN_MDIP1: length 12.1
  IN1 w0.089: v1(240.07,154.13) 240.07,154.05 240.16,153.96 240.37,153.96 240.47,154.06 240.47,156.99 242.52,159.04 244.01,159.04 v1(244.17,159.19)
  BOTTOM w0.089: UL1.14 239.08,154.02 239.13,153.97 239.98,153.97 240.07,154.06 v1(240.07,154.13) ; TL1.8 243.29,159.59 243.4,159.48 243.4,159.28 243.64,159.05 244.08,159.05 244.17,159.14 v1(244.17,159.19)
LAN_MDIP2: length 11.2
  IN4 w0.089: v1(244.25,156.71) 244.11,156.56 243.28,156.56 242.77,156.05 242.77,153.94 241.59,152.76 240.21,152.76 v1(240.05,152.93)
  BOTTOM w0.089: v1(244.25,156.71) 244.1,156.55 243.69,156.55 243.56,156.68 243.56,156.92 243.44,157.05 TL1.6 ; v1(240.05,152.93) 240.05,152.85 239.96,152.76 239.2,152.76 239.14,152.82 UL1.17
LAN_MDIP3: length 11.1
  IN4 w0.089: v1(244.23,151.63) 244.1,151.5 242.73,151.5 240.63,149.4 239.43,149.4 239.29,149.54 v1(239.29,149.61)
  BOTTOM w0.089: v1(239.29,149.61) 239.11,149.61 238.96,149.75 238.96,150.71 239.14,150.89 239.14,151.52 239.03,151.62 UL1.20 ; v1(244.23,151.63) 244.23,151.61 244.1,151.48 243.79,151.48 243.3,151.97 TL1.2
LCD_TEST: length 297.9
  TOP w0.107: v1(166.38,179.39) 166.62,179.63 JEDP.31 ; v1(295.92,17.43) 295.35,16.86 295.35,16.03 295.81,15.57 295.81,9.17 295.94,9.04 UE5.72
  IN2 w0.091: v1(296.22,36.05) 296.22,36.06 296.22,37.77 291.52,42.46 285.65,42.46 284.95,43.16 281.83,43.16 277.95,47.05 277.95,51.78 276.19,53.54 276.19,61.44 272.72,64.91 267.73,64.91 267.58,64.76 248.9,64.76 248.72,64.95 225.09,64.95 222.78,62.64 207.87,62.64 207.59,62.92 202.2,62.92 200.96,64.15 198.81,64.15 196.34,66.63 195.51,66.63 191.93,70.21 191.93,70.84 189.64,73.13 189.64,92.76 187.23,95.17 187.23,103.23 188.56,104.56 188.56,110.13 193.2,114.77 193.2,128.54 192.65,129.08 192.65,144.07 186.73,149.99 171.03,149.99 170.76,150.25 170.76,150.97 170.25,151.48 169.63,151.48 165.16,155.95 165.16,161.26 164.74,161.67 164.74,165.86 163.31,167.29 163.31,173.57 164.1,174.35 165.54,174.35 166.09,174.9 166.09,175.02 166.68,175.62 166.68,179.08 v1(166.38,179.39)
  BOTTOM w0.107: v1(296.22,36.05) 296.76,35.51 296.76,30.65 295.16,29.05 295.16,23.29 294.51,22.65 294.51,18.84 v1(295.92,17.43)
LDO2-CAP: length 5.6
  BOTTOM w0.203: UA1.22 32.02,25.41 32.55,24.88 CA28.1
  BOTTOM w0.254: CA28.1 32.71,24.69 CA29.1 v2(32.71,22.54) 32.03,22.54 RA12.2
LG_3V: length 16.2
  IN3 w1.016: 56.4,41.88 56.4,37.88 49.73,31.21 47.74,31.21
  BOTTOM w0.107: v1(55.57,43.41) 55.76,43.41 v2(56.21,42.96)
  vias: v1(46.17,31.46) v1(46.17,30.87) v1(55.13,43.85)
LG_5V: length 8
  IN3 w1.016: 48.11,36.96 48.11,39 51.32,42.2 52.15,42.2
  BOTTOM w0.107: v1(52.59,43.15) 52.54,43.11 v2(52.54,42.61)
  vias: v1(47.95,36.04) v1(48.4,35.59) v1(52.59,43.79)
LG_+1VALWP: length 3.4
  IN4 w1.016: 251.02,23.21 252.55,23.21 253.56,22.19 253.56,21.75
  vias: v1(250.07,23.65) v1(250.07,23.07) v1(254.58,22.07) v1(254.58,21.43) v2(250.39,22.38)
LID_SW#: length 37.4
  TOP w0.107: v4(314.28,23.67) v1(313.64,23.02)
  TOP w0.203: UE5.115 308.33,17.01 308.59,16.75 309.01,16.75 RE70.2 CE43.1
  TOP w0.254: DE1.1 313.2,22.58 v1(313.64,23.02) ; v1(308.43,17.73) CE43.1 ; v1(325.7,25.94) 326.05,25.94 326.35,25.64 326.35,19.61 326.1,19.36 JIO.20
  IN1 w0.254: v1(308.43,17.73) 309.59,17.73 309.98,17.34 312.02,17.34 312.81,18.13 312.81,22.19 v1(313.64,23.02) 314.59,23.02 318.26,26.69 323.3,26.69 324.05,25.94 v1(325.7,25.94)
LINE1_JD: length 38
  TOP w0.107: RA36.2 38.89,30.07 39.5,30.07 v1(39.56,30.01) 39.56,30.63 v2(39.57,30.64)
  IN2 w0.254: v1(39.56,30.01) 39.56,30.02 39.56,31.1 39.23,31.44 38.41,31.44 38.05,31.81 38.05,34.73 37.02,35.76 35.75,35.76 35.19,36.31 27.71,36.31 27.42,36.02 26.47,36.02 22.87,32.42 22.87,30.89 21.03,29.05 19.5,29.05 17.6,27.15 15.76,27.15 15.11,26.5 JACK2.5
LINE1_L:
  vias: v2(23.88,30.07)
LINE1_R:
  vias: v2(27.54,29.92)
LINE1_VREFO_L: length 11.5
  TOP w0.107: v2(26.23,25.5) 25.92,25.81 v1(25.92,26)
  TOP w0.254: RA41.1 25.66,26.57 25.92,26.32 v1(25.92,26)
  IN4 w0.203: v1(27.78,32.38) 25.75,32.38 25.18,31.8 25.18,27.19 25.92,26.45 v1(25.92,26)
  BOTTOM w0.203: UA1.40 27.85,32.31 v1(27.78,32.38)
LINE1_VREFO_R: length 11.9
  TOP w0.254: RA40.1 25.29,25.19 v1(25.29,26.02)
  IN4 w0.254: v1(25.29,26.02) 25.29,26.44 24.67,27.06 24.67,31.72 v1(24.58,31.81)
  BOTTOM w0.107: v2(24.2,32.35) 24.2,32.19 v1(24.58,31.81)
  BOTTOM w0.203: UA1.39 28.22,31.91 28.21,31.9 24.67,31.9 v1(24.58,31.81)
LINE-IN-L: length 6.5
  TOP w0.254: RA38.1 23.62,19.94 v2(25.01,18.55) 25.35,18.21 v1(25.35,17.75)
  BOTTOM w0.254: v1(25.35,17.75) 25.35,17.55 RA35.2 25.99,16.8 24.79,16.8 LA9.2
LINE-IN-R: length 4.5
  TOP w0.107: v2(18.37,21.01) 18.72,20.67 19.25,20.67 RA37.2
  TOP w0.203: v1(18.39,21.92) 18.88,21.43 RA39.1 19.34,20.76 RA37.2
  BOTTOM w0.254: v1(18.39,21.92) 18.39,22.11 17.46,23.05 LA10.2
LOGO_LED_B_DRV#: length 20.1
  TOP w0.254: UE3.9 215.19,158.33 214.88,158.64 v2(214.88,158.95) 214.88,159.35 v1(215.21,159.68)
  TOP w0.508: v1(227.8,164.59) 227.8,164.69 228.92,165.8 JLOGO.8
  IN1 w0.508: v1(227.8,164.59) 226.8,164.59 225.79,163.58 225.53,163.58 223.75,161.8 223.75,161.2 221.82,159.28 219.62,159.28 219.34,159 215.73,159 215.21,159.51 v1(215.21,159.68)
LOGO_LED_G_DRV#: length 22.1
  TOP w0.254: v1(215.88,159.7) 216.56,159.7 216.81,159.45 UE3.8
  TOP w0.457: v1(226.96,168.05) 227.92,167.09 JLOGO.7
  IN2 w0.508: v1(215.88,159.7) 216.89,158.69 221.8,158.69 223.91,160.8 223.91,162.38 226.35,164.81 226.35,167.44 v1(226.96,168.05)
  BOTTOM w0.109: v2(226.36,168.18) 226.49,168.05 v1(226.96,168.05)
LOGO_LED_R_DRV#: length 16.7
  TOP w0.254: v1(217.14,160.57) 217.14,160.16 217.81,159.49 UE3.6
  TOP w0.457: v1(224.85,164.22) 225.89,164.22 v2(226.4,164.73) 226.92,165.25 JLOGO.6
  IN2 w0.508: v1(224.85,164.22) 223.21,162.57 223.21,161 221.54,159.33 217.76,159.33 217.14,159.95 v1(217.14,160.57)
LPC_AD0: length 106.3
  TOP w0.107: UE5.10 301.94,22.84 302.19,22.59 302.19,21.32 300.3,19.43 v1(300.3,18.19)
  IN4 w0.097: v1(212.03,29.7) 212.49,30.15 214.27,30.15 215.75,28.67 219.19,28.67 220.46,27.4 220.46,26.15 221.98,24.63 223.07,24.63 224.57,23.13 224.57,21.91 228.19,18.3 238.73,18.3 239.52,17.51 241.12,17.51 244.17,14.45 246.64,14.45 247.21,13.88 250.87,13.88 251.1,13.66 263.69,13.66 265.27,15.25 265.27,15.87 267.96,18.55 299.94,18.55 v1(300.3,18.19)
  BOTTOM w0.089: UH1.AT22 212.22,29.5 v1(212.03,29.7)
LPC_AD1: length 106.4
  TOP w0.107: v1(300.94,18.19) 300.72,18.4 300.72,19.52 302.42,21.22 302.42,22.26 302.74,22.57 UE5.8
  IN4 w0.097: v1(212.81,29.75) 213.32,29.24 214.92,29.24 215.88,28.28 219.27,28.28 220.24,27.31 220.24,25.89 221.72,24.41 222.98,24.41 224.35,23.04 224.35,21.82 228.09,18.07 238.63,18.07 239.44,17.27 241.05,17.27 244.18,14.13 246.64,14.13 247.12,13.66 250.78,13.66 251,13.44 263.78,13.44 265.5,15.15 265.5,15.78 268.05,18.33 299.59,18.33 300.17,17.75 300.49,17.75 v1(300.94,18.19)
  BOTTOM w0.089: UH1.AV22 212.81,29.44 v1(212.81,29.75)
LPC_AD2: length 107.5
  TOP w0.107: v1(301.53,18.19) 301.53,19.98 302.66,21.1 302.66,22.16 303.14,22.64 UE5.7
  IN4 w0.089: v1(211.79,30.83) 212.11,30.51 215.59,30.51 215.99,30.11
  IN4 w0.097: 215.99,30.11 218.17,30.11 221.48,26.8 221.48,26.4 222.37,25.51 222.85,25.51 224.8,23.56 224.8,22 227.42,19.38 232.79,19.38 233.2,18.97 239.98,18.97 244.27,14.68 246.73,14.68 247.3,14.11 250.96,14.11 251.19,13.88 263.59,13.88 265.05,15.34 265.05,15.96 267.86,18.78 300.95,18.78 v1(301.53,18.19)
  BOTTOM w0.089: UH1.AT19 212.21,30.37 211.79,30.79 v1(211.79,30.83)
LPC_AD3: length 105.2
  TOP w0.107: v1(302.35,18.76) 302.35,20.13 303.12,20.9 303.12,21.84 303.94,22.66 UE5.5
  IN4 w0.097: v1(302.35,18.76) 302.1,19 281.53,19 280.94,19.59 268.36,19.59 264.83,16.06 264.83,15.43 263.5,14.11 251.28,14.11 251,14.39 251,14.85 250.79,15.07 244.72,15.07 244.43,15.35 244.43,16.19 243.47,17.15 242.11,17.15 240.07,19.19 233.29,19.19 231.95,20.54 226.58,20.54 225.02,22.09 225.02,23.65 222.94,25.73 222.46,25.73 221.7,26.49 221.7,26.89 218.34,30.25 v1(218.34,31.18)
  BOTTOM w0.089: UH1.BD16 215.97,32.1 216.27,31.79 217.83,31.79 v2(217.94,31.69) 218.34,31.29 v1(218.34,31.18)
LPC_FRAME#: length 103.1
  TOP w0.107: UE5.4 304.34,22.73 303.36,21.75 303.36,20.77 302.97,20.38 v1(302.97,18.76)
  IN4 w0.097: v1(218.92,31.18) 218.91,31.17 218.91,30 221.93,26.98 221.93,26.58 222.56,25.95 223.03,25.95 225.24,23.74 225.24,23.21 227.69,20.76 232.04,20.76 233.38,19.41 240.16,19.41 242.2,17.37 243.56,17.37 245.12,15.81 246.04,15.81 246.56,15.29 262.15,15.29 262.58,15.72 263.18,15.72 263.38,15.91 263.38,16.39 266.8,19.81 281.04,19.81 281.62,19.22 302.51,19.22 v1(302.97,18.76)
  BOTTOM w0.089: UH1.BE16 216.51,31.97 218.2,31.97 218.91,31.26 218.91,31.18 v1(218.92,31.18)
LX_3V: length 24.7
  IN4 w1.016: 50.24,26.26 51.93,27.95 53.67,27.95 54.68,28.97 54.68,30.45 54.17,30.96 54.17,34.83 59.44,40.1 59.44,42.64 57.28,44.8
  vias: v1(44.71,25.94) v1(44.78,24.8) v1(44.97,25.37) v1(45.41,25.94) v1(45.47,24.8) v1(45.67,25.37) v1(46.05,25.94) v1(46.11,24.8) v1(46.3,25.37) v1(46.74,25.94) v1(46.74,24.8) v1(47,25.37) v1(47.38,25.94) v1(47.38,24.8) v1(47.63,25.37) v1(48.01,25.94) v1(48.01,24.8) v1(48.27,25.37) v1(48.65,25.94) v1(48.71,24.8) v1(48.9,25.37) v1(49.28,25.94) v1(49.35,24.8) v1(49.54,25.37) v1(56.26,45.76) v1(56.9,45.75) v2(51.44,27.59)
LX_5V: length 9.4
  IN4 w1.016: 43.92,38.36 50.55,45
  vias: v1(40.2,37.05) v1(40.27,35.91) v1(40.46,36.48) v1(40.52,37.56) v1(40.84,37.05) v1(40.86,35.91) v1(41.09,36.48) v1(41.22,37.56) v1(41.54,37.05) v1(41.5,35.91) v1(41.73,36.48) v1(41.86,37.56) v1(42.13,35.91) v1(42.17,37.05) v1(42.36,36.48) v1(42.49,37.56) v1(42.81,37.05) v1(42.83,35.91) v1(43.06,36.48) v1(43.13,37.56) v1(43.44,37.05) v1(43.7,36.48) v1(50.78,45.78) v1(51.37,45.77) v2(40.78,35.02)
LX_+1.8VGS: length 1.4
  BOTTOM w0.107: v2(229.75,34.39) 229.5,34.64 PR809.1
LX_+VGA_PCIE: length 13.6
  TOP w0.254: v1(198.2,73.45) 198.21,73.44 199.53,73.44 199.97,73.88 199.97,75.22 199.72,75.47 199.72,79.72 199.4,80.04 v2(197.24,80.04) v1(196.67,79.47) 197.37,78.77 PR803.1
  BOTTOM w0.254: v1(198.2,73.45) 198.05,73.45 197.77,73.73 PU800.6
LX_CHG: length 4.6
  IN1 w1.016: 61.67,23.46 62.7,23.46 63.27,22.89 65.03,22.89 65.73,22.19
  vias: v1(60.97,23.46) v1(61.41,23.84) v1(65.92,20.8) v1(65.9,20.16) v1(66.56,20.8) v1(66.49,20.16) v1(67.19,20.8) v1(67.83,20.8) v1(68.27,20.29) v1(68.53,20.86) v1(68.72,23.65) v1(68.72,23.02) v1(68.72,22.38) v1(68.72,21.75) v1(68.91,20.29) v1(69.03,21.18) v1(69.41,20.61) v2(60.59,23.08)
LX_VCCIO: length 7.6
  IN4 w0.254: v1(120.59,112.37) v1(120.59,119.16)
  BOTTOM w0.254: PU509.6 120.66,119.09 v1(120.59,119.16)
  vias: v2(123.01,111.16)
M_CLK_DDR0: length 51.4
  IN4 w0.089: v1(151.19,87.16) 151.19,86.97 151.06,86.84 150.69,86.84 150.44,86.58 150.44,83.93 150.44,83.92 150.44,83.87 150.44,83.87 150.44,83.85
  IN4 w0.099: 150.44,83.85 150.44,83.61 150.71,83.34 151.03,83.34 151.13,83.24 151.13,82.88 151.04,82.79 150.63,82.79 150.39,82.55 150.39,82.12 150.61,81.9 150.98,81.9 151.07,81.81 151.07,81.49 150.97,81.39 150.62,81.39 150.41,81.18 150.41,81.08 150.41,81.08 150.41,81.07 150.41,81.07 150.41,80.7 150.63,80.48 151.06,80.48 151.22,80.33 151.22,71.7 146.38,66.86 146.38,60.32 146.18,60.12 146.18,59.76 146.08,59.66 145.72,59.66 145.5,59.43 145.5,58.92 145.71,58.71 146.14,58.71 146.24,58.61 146.24,57.34 146.14,57.25 145.86,57.25 v1(145.62,57.49)
  BOTTOM w0.076: CPU1.AG1 153.81,93.71 153.81,93.89 153.88,93.96 154.18,93.96 154.28,93.87 154.28,93.38 154.21,93.32 154.21,92.69 154.02,92.5 154.02,88.04 152.64,86.66 151.66,86.66 151.19,87.13 v1(151.19,87.16)
  BOTTOM w0.107: JDIMM1.137 145.69,59.07 145.8,58.96 145.8,58.56 146.41,57.96 146.41,57.3 146.2,57.09 145.96,57.09 145.62,57.43 v1(145.62,57.49)
M_CLK_DDR1: length 53.8
  IN4 w0.089: 152.11,83.85 152.11,83.87 152.1,83.88 152.1,84.32 151.75,84.67 151.75,88 151.44,88.31 151.44,89.34 151.79,89.68 151.79,91.33 151.56,91.56 151.28,91.56 v1(151.04,91.8)
  IN4 w0.099: 152.11,83.85 152.11,71.22 147.29,66.39 147.29,59.47 147.14,59.32 147.14,56.51 146.92,56.29 146.48,56.29 146.38,56.19 146.38,55.81 146.48,55.71 147.68,55.71 147.96,55.43 147.96,54.92 147.88,54.84 147.88,54.83 147.75,54.7 147.24,54.7 147.14,54.6 147.14,54.24 147.24,54.14 147.71,54.14 147.96,53.88 147.96,53.44 147.71,53.18 146.74,53.18 146.24,53.68 v1(145.62,53.68)
  BOTTOM w0.076: v1(151.04,91.8) 151.27,91.57 151.48,91.57 151.66,91.75 151.66,92.59 150.96,93.28 150.96,93.83 151.12,93.99 151.17,93.99 151.42,94.23 CPU1.AK2
  BOTTOM w0.107: v1(145.62,53.68) 145.84,53.9 146.15,53.9 146.27,53.78 146.27,53.34 146.06,53.13 146.06,52.79 145.94,52.68 JDIMM1.138
M_CLK_DDR2: length 65.3
  IN1 w0.089: 151.78,85 151.78,85 151.76,84.98 151.76,84.93 151.57,84.74 151.57,83.88 151.56,83.87 151.56,83.85
  IN1 w0.091: v1(149.75,98.48) 150.12,98.11 150.12,97.58 150.77,96.93 151.18,96.93 151.48,96.62 151.64,96.62 152.18,96.09 152.18,95.56 151.86,95.25 151.65,95.25 151.02,94.62 151.02,93.3 151.61,92.72 151.61,88.31 151.78,88.14 151.78,85
  IN1 w0.099: 151.56,83.85 151.56,77.74 146.16,72.34 146.16,52.66 145.02,51.52 145.02,44.3 145.35,43.96 145.45,43.96 v1(145.62,43.8)
  BOTTOM w0.076: v1(149.75,98.48) 150.07,98.8 CPU1.AM9
  BOTTOM w0.107: JDIMM2.137 145.69,46.29 145.8,46.18 145.8,45.9 145.66,45.75 145.28,45.75 144.81,45.28 144.81,44.23 145.05,43.98 145.44,43.98 v1(145.62,43.8)
M_CLK_DDR3: length 66.9
  IN1 w0.089: 152.28,83.85 152.28,83.92 152.41,84.04 152.41,86.71 152.83,87.13 152.83,89.94 152.83,89.94 152.83,93.08 152.74,93.17 152.74,93.17 152.55,93.36 152.55,96.49 151.77,97.26 151.4,97.26 151.08,97.58 151.08,97.86 150.96,97.98 150.82,97.98 v1(150.66,97.82)
  IN1 w0.099: 152.28,83.85 152.28,77.47 146.86,72.05 146.86,52.37 146.03,51.53 146.03,50.37 146.02,50.37 146.02,42.21 146.36,41.87 146.99,41.87 147.09,41.77 147.09,41.3 146.97,41.18 145.7,41.18 v1(145.62,41.26)
  BOTTOM w0.076: CPU1.AM7 v1(150.66,97.82)
  BOTTOM w0.107: v1(145.62,41.26) 145.18,40.82 145.18,40.41 145.42,40.16 145.92,40.16 146,40.08 146,39.91 145.94,39.86 JDIMM2.138
M_CLK_DDR#0: length 51.3
  IN4 w0.089: v1(151.19,86.5) 151.03,86.66 150.77,86.66 150.62,86.51 150.62,83.93 150.63,83.91 150.63,83.85
  IN4 w0.099: 150.63,83.85 150.63,83.69 150.79,83.53 151.12,83.53 151.33,83.32 151.33,82.8 151.12,82.59 150.71,82.59 150.59,82.47 150.59,82.2 150.69,82.1 151.06,82.1 151.27,81.89 151.27,81.41 151.05,81.19 150.7,81.19 150.61,81.1 150.61,80.78 150.71,80.68 151.14,80.68 151.41,80.41 151.41,71.62 146.57,66.78 146.57,60.24 146.38,60.04 146.38,59.68 146.16,59.46 145.8,59.46 145.69,59.35 145.69,59.01 145.79,58.91 146.22,58.91 146.44,58.69 146.44,57.26 146.22,57.05 145.82,57.05 v1(145.62,56.85)
  BOTTOM w0.076: v1(151.19,86.5) 152.71,86.5 154.18,87.98 154.18,92.43 154.38,92.62 154.38,93.25 154.44,93.31 154.44,93.93 154.2,94.17 154,94.17 CPU1.AG2
  BOTTOM w0.107: JDIMM1.139 146.19,59.1 146.04,58.94 146.04,58.66 146.65,58.05 146.65,57.2 146.3,56.85 v1(145.62,56.85)
M_CLK_DDR#1: length 53.8
  IN4 w0.089: v1(151.04,91.16) 151.26,91.38 151.49,91.38 151.61,91.26 151.61,89.76 151.27,89.41 151.27,88.24 151.57,87.93 151.57,84.6 151.93,84.25 151.93,83.88 151.92,83.87 151.92,83.85
  IN4 w0.099: v1(145.62,54.31) 146.06,53.87 146.32,53.87 146.82,53.37 147.63,53.37 147.77,53.52 147.77,53.8 147.63,53.94 147.16,53.94 146.95,54.15 146.95,54.69 147.16,54.9 147.67,54.9 147.69,54.91 147.69,54.92 147.77,55 147.77,55.35 147.6,55.52 146.4,55.52 146.18,55.73 146.18,56.27 146.4,56.49 146.84,56.49 146.94,56.59 146.94,59.4 147.1,59.55 147.1,66.48 151.92,71.3 151.92,83.85
  BOTTOM w0.076: v1(151.04,91.16) 151.29,91.41 151.55,91.41 151.83,91.69 151.83,92.65 151.13,93.35 151.13,93.76 151.19,93.82 151.29,93.82 151.42,93.69 CPU1.AK1
  BOTTOM w0.107: v1(145.62,54.31) 145.8,54.13 146.25,54.13 146.5,53.88 146.5,53.24 146.3,53.04 146.3,52.83 146.44,52.68 JDIMM1.140
M_CLK_DDR#2: length 65.3
  IN1 w0.089: 151.96,84.93 151.94,84.91 151.94,84.86 151.75,84.67 151.75,83.88 151.76,83.87 151.76,83.85
  IN1 w0.091: 151.96,84.93 151.96,88.21 151.79,88.39 151.79,92.79 151.2,93.38 151.2,94.55 151.72,95.07 151.94,95.07 152.36,95.48 152.36,96.16 151.72,96.8 151.56,96.8 151.25,97.11 150.84,97.11 150.3,97.65 150.3,98.44 149.75,98.99 v1(149.75,99.11)
  IN1 w0.099: v1(145.62,44.43) 145.45,44.27 145.32,44.27 145.21,44.38 145.21,51.44 146.35,52.58 146.35,72.26 151.76,77.66 151.76,83.85
  BOTTOM w0.076: CPU1.AN9 149.39,98.8 149.4,98.8 149.43,98.8 v1(149.75,99.11)
  BOTTOM w0.107: v1(145.62,44.43) 145.4,44.22 145.15,44.22 145.04,44.32 145.04,45.18 145.38,45.52 145.76,45.52 146.04,45.8 146.04,46.11 146.2,46.26 JDIMM2.139
M_CLK_DDR#3: length 66.8
  IN1 w0.089: 152.48,83.85 152.48,83.86 152.59,83.97 152.59,86.63 152.6,86.64 152.6,86.65 153.01,87.05 153.01,93.15 152.72,93.44 152.72,96.56 151.85,97.44 151.47,97.44 151.26,97.65 151.26,97.96 151.06,98.16 150.79,98.16 150.66,98.29 v1(150.66,98.47)
  IN1 w0.099: 152.48,83.85 152.48,77.39 147.06,71.97 147.06,52.29 146.22,51.45 146.22,50.29 146.22,50.29 146.22,42.29 146.44,42.07 147.07,42.07 147.29,41.86 147.29,41.22 147.05,40.98 145.98,40.98 v1(145.62,40.62)
  BOTTOM w0.076: CPU1.AM8 v1(150.66,98.47)
  BOTTOM w0.107: v1(145.62,40.62) 145.82,40.42 146,40.42 146.25,40.16 146.25,40.04 146.44,39.84 JDIMM2.140
M_ODT0: length 52.7
  IN4 w0.089: 158.08,83.85 158.08,84.15 155.71,86.52 155.12,86.52 154.44,87.2 154.44,88.42 154.61,88.59 v1(154.82,88.59)
  IN4 w0.152: v1(152.85,55.45) 153.32,55.92 153.32,59.45 153.85,59.98 153.85,64.14 158.08,68.37 158.08,83.85
  BOTTOM w0.076: CPU1.AD3 156.17,94.61 156.17,93.37 156.37,93.17 156.37,90.14 v2(155.47,89.24) v1(154.82,88.59)
  BOTTOM w0.175: v1(152.85,55.45) 152.74,55.34 151.59,55.34 151.41,55.52 151.41,55.86 151.59,56.04 152.22,56.04 152.34,56.16 152.34,56.55 152.22,56.67 151.59,56.67 151.41,56.85 151.41,57.24 151.59,57.41 151.94,57.41 152.19,57.67 JDIMM1.155
M_ODT1: length 51.6
  IN4 w0.089: v1(154.82,92.48) 154.82,92.4 154.03,91.61 154.03,86.74 156.61,84.16 156.61,83.85
  IN4 w0.152: v1(152.88,56.97) 152.32,56.42 152.05,56.42 151.8,56.67 151.8,57.02 152.4,57.62 152.4,61.72 152.86,62.19 152.86,64.45 156.61,68.19 156.61,68.8 156.76,68.96 157.01,68.96 157.16,69.11 157.16,69.41 157.01,69.57 156.76,69.57 156.61,69.72 156.61,70.02 156.76,70.18 157.01,70.18 157.16,70.33 157.16,70.63 157.01,70.79 156.76,70.79 156.61,70.94 156.61,83.85
  BOTTOM w0.076: CPU1.AE4 155.61,95.54 155.27,95.19 155.27,92.98 154.82,92.54 v1(154.82,92.48)
  BOTTOM w0.175: v1(152.88,56.97) 153.25,56.97 153.42,56.8 153.42,56.15 153.6,55.98 153.89,55.98 154.06,56.15 154.06,58.52 153.69,58.88 JDIMM1.161
M_ODT2: length 66.1
  IN1 w0.089: 158.3,83.85 158.3,86.28 156.35,88.23 156.35,93.95 155.46,94.84 155.46,97.63 v1(155.24,97.85)
  IN1 w0.152: 158.3,83.85 158.3,73.01 153.92,68.63 153.92,67.58 153.74,67.41 153.01,67.41 152.85,67.25 152.85,66.94 153.01,66.79 153.76,66.79 153.92,66.63 153.92,66.32 153.76,66.17 153.01,66.17 152.85,66.01 152.85,65.7 153.01,65.55 153.76,65.55 153.92,65.39 153.92,65.1 153.75,64.93 153.01,64.93 152.85,64.77 152.85,64.46 153.01,64.31 153.76,64.31 153.92,64.15 153.92,63.84 153.76,63.69 153.01,63.69 152.85,63.53 152.85,63.22 153.01,63.07 153.7,63.07 153.92,62.85 153.92,60.91 154.96,59.87 154.96,52.09 153.69,50.82 153.69,49.08 152.87,48.27 152.87,45.59 v1(152.85,45.57)
  BOTTOM w0.076: v1(155.24,97.85) CPU1.AF7
  BOTTOM w0.175: JDIMM2.155 152.2,46.23 v1(152.85,45.57)
M_ODT3: length 67.2
  IN1 w0.089: 159.22,83.85 159.22,86.63 156.94,88.91 156.94,94.62 156.47,95.09 156.47,97.37 v1(156.12,97.72)
  IN1 w0.152: v1(152.85,42.65) 153.79,43.59 153.79,47.32 155.12,48.65 155.12,50.96 155.88,51.71 155.88,60.25 154.84,61.29 154.84,62.81 154.99,62.96 155.56,62.96 155.71,63.12 155.71,63.42 155.56,63.57 154.99,63.57 154.84,63.73 154.84,64.07 154.99,64.22 155.59,64.22 155.75,64.38 155.75,69.16 159.22,72.63 159.22,83.85
  BOTTOM w0.076: v1(156.12,97.72) CPU1.AE8
  BOTTOM w0.175: v1(152.85,42.65) 153.87,43.67 153.87,46.07 153.69,46.24 JDIMM2.161
MDP_AUX#_SDA: length 125
  TOP w0.107: v1(213.33,100.42) 213.14,100.61 213.14,100.91 213.27,101.04 214.08,101.04 214.63,100.49 215.13,100.49 215.36,100.72 215.36,101.01 RG400.1
  IN1 w0.097: v1(213.33,100.42) 213.03,100.71 213.03,103.27 199.73,116.57 199.73,124.61 199.27,125.08 199.27,142.96 203.43,147.12 210.29,147.12 210.59,147.41 215.87,147.41 217.12,148.67 222.44,148.67 225.86,152.08 225.86,155.44 225.62,155.68 225.37,155.68 v1(225.17,155.89)
  IN3 w0.099: v1(225.17,155.89) 225.37,155.69 227.88,155.69 230.02,157.83 230.02,158.64 229.81,158.85 v1(228.94,158.85)
  IN4 w0.097: v1(213.33,100.42) 213.11,100.2 213.11,98.88 213.91,98.09 213.91,90.12 215.31,88.72 215.31,86.98 217.13,85.16 218.21,85.16 219.22,86.17 224.32,86.17 225.24,85.25 225.72,85.25 v1(226.02,85.55)
  BOTTOM w0.107: v1(225.17,155.89) 225.34,155.71 225.57,155.71 RV618.2 ; UG1.AT33 226.62,85.93 226.24,85.55 v1(226.02,85.55) ; UV3.6 228.45,158.84 228.62,159.01 228.77,159.01 v1(228.94,158.85)
MDP_AUX_SCL: length 125.1
  TOP w0.107: RG401.1 215.15,101.06 215.15,100.81 215.04,100.7 214.72,100.7 214.17,101.25 213.18,101.25 212.92,101 212.92,100.61 v1(212.73,100.42)
  IN1 w0.097: v1(212.73,100.42) 212.86,100.54 212.86,103.2 199.56,116.5 199.56,124.54 199.1,125.01 199.1,143.04 203.35,147.29 210.22,147.29 210.51,147.59 215.79,147.59 217.05,148.84 222.37,148.84 225.69,152.15 225.69,155.37 225.55,155.51 225.37,155.51 v1(225.17,155.3)
  IN3 w0.099: v1(231.29,158.83) 230.4,158.83 230.21,158.64 230.21,157.75 227.96,155.5 225.37,155.5 v1(225.17,155.3)
  IN4 w0.097: v1(226.01,84.75) 225.68,85.08 225.17,85.08 224.25,86 219.29,86 218.28,84.99 217.05,84.99 215.14,86.91 215.14,88.65 213.73,90.05 213.73,98.02 212.94,98.81 212.94,100.21 v1(212.73,100.42)
  BOTTOM w0.107: v1(226.01,84.75) 226.46,85.2 UG1.AU33 ; RV619.2 225.57,155.5 225.36,155.5 v1(225.17,155.3) ; UV3.3 230.4,158.22 231.01,158.83 v1(231.29,158.83)
MDP_HPD: length 4.2
  BOTTOM w0.107: JDP.2 232.37,169.66 232.1,169.39 v2(232.1,168.62) 232.1,168.56 232.21,168.46 CX1.1 RX2.2
MDP_LANE_N0_C: length 8.4
  BOTTOM w0.107: JDP.5 232.88,173.09 232.44,173.09 231.26,171.91 231.26,170.14 229.88,168.76 229.86,168.76 229.48,168.37 229.48,168.35 229.33,168.2 CV27.2
MDP_LANE_N1_C: length 11.1
  TOP w0.107: JDP.11 235.14,173.26 235.14,171.93 236.49,170.59 238.74,170.59 v3(238.99,170.33) 240,169.32 240.51,169.32 240.53,169.34 241.07,169.34 241.09,169.32 241.75,169.32 242.13,168.94 242.13,168.32 CV30.2
MDP_LANE_N2_C: length 9.1
  BOTTOM w0.107: CV33.2 240.76,167.68 240.87,167.79 241.33,167.79 241.43,167.9 v3(241.43,168.15) 241.43,168.39 241.29,168.53 241.26,168.56 241.01,168.56 240.86,168.71 240.86,168.95 240.65,169.17 239.86,169.17 238.55,170.48 238.55,171.98 237.64,172.89 237.28,172.89 237.18,172.78 JDP.17
MDP_LANE_N3_C: length 3.7
  BOTTOM w0.107: JDP.12 235.37,169.61 235.17,169.41 235.17,167.6 CV31.2
MDP_LANE_P0_C: length 8.4
  BOTTOM w0.107: JDP.3 232.97,172.77 232.87,172.88 232.53,172.88 231.48,171.82 231.48,170.05 230.44,169.01 230.44,168.81 230.26,168.62 230.06,168.62 v3(229.83,168.4) 229.54,168.11 229.54,167.91 229.65,167.8 230.2,167.8 230.28,167.71 CV26.2
MDP_LANE_P1_C: length 11.2
  TOP w0.107: JDP.9 234.93,173.34 234.93,171.84 236.4,170.37 238.62,170.37 239.02,169.98 239.04,169.98 239.91,169.11 240.6,169.11 240.61,169.11 240.76,169.11 240.76,169.11 v3(240.8,169.11) 241.66,169.11 241.92,168.85 241.92,168.53 CV28.2
MDP_LANE_P2_C: length 9.2
  BOTTOM w0.107: JDP.15 237.26,173.1 237.73,173.1 238.77,172.07 238.77,170.57 239.95,169.39 240.74,169.39 241.66,168.46 241.66,167.75 241.65,167.73 CV32.2
MDP_LANE_P3_C: length 3.7
  BOTTOM w0.107: JDP.10 234.77,169.57 234.96,169.39 234.96,167.67 CV29.2
ME_EN: length 120.6
  TOP w0.089: v1(214.46,36.11) 214.46,35.92 v2(214.18,35.64)
  TOP w0.097: RH16.1 214.38,36.19 v1(214.46,36.11)
  TOP w0.107: v1(300.12,15.67) 300.12,15.32 300.63,14.82 301.39,14.82 302.08,14.13 302.08,13.24 304.7,10.61 UE5.99
  IN4 w0.097: v1(214.46,36.11) 214,35.66 212.63,35.66 211.4,34.43 211.4,29.8 213.09,28.12 215.7,28.12 216.35,27.46 217.36,27.46 218.32,26.51 219.3,26.51 221.62,24.19 222.89,24.19 224.13,22.95 224.13,21.72 228,17.85 238.54,17.85 239.35,17.04 240.95,17.04 244.09,13.91 246.55,13.91 247.02,13.44 250.69,13.44 250.91,13.21 263.87,13.21 265.72,15.06 265.72,15.69 267.32,17.28 280.45,17.28 281.27,18.11 299.49,18.11 300.43,17.17 300.43,15.97 v1(300.12,15.67)
ME_SUS_PWR_ACK: length 101.3
  TOP w0.089: v1(217.98,29.73) 217.99,29.73 218.33,29.73 218.7,29.36 219.08,29.36 v2(219.08,29.37) 219.09,29.36 219.18,29.36
  TOP w0.107: UE5.71 295.54,9.26 295.58,9.3 295.58,14.46 v1(295.35,14.69) ; 219.29,29.36 219.18,29.36
  TOP w0.127: RH506.1 219.29,29.36
  IN2 w0.091: v1(295.35,14.69) 295.16,14.87 292.23,14.87 291.53,15.56 278.3,15.56 274.35,19.51 272.45,19.51 270.88,21.09 269.91,21.09 268.47,19.65 266.01,19.65 263.74,17.38 262.6,17.38 261.82,16.6 256.16,16.6 255.51,17.24 231.65,17.24 231.25,17.64 228.92,17.64 227.14,19.43 227.14,21.22 226.67,21.69 226.01,21.69 224.6,23.09 224.6,26.19 221.86,28.92 219.01,28.92 218.21,29.73 217.99,29.73 v1(217.98,29.73)
  BOTTOM w0.089: v1(217.98,29.73) 217.29,30.42 216.06,30.42 UH1.BD19
MEM_VDD_CTL: length 6.4
  TOP w0.254: PR8213.1 281.82,148.52 281.36,148.06 279.92,148.06 v2(279.22,148.76) PR8216.1 PR8215.2
MIC1-VREFO_L: length 23
  TOP w0.254: RA28.1 27.25,22 25.66,20.42 v1(25.66,20.16)
  IN4 w0.254: v1(25.66,20.16) 25.66,20.1 25.15,19.59 24.71,19.59 23.96,20.34 23.96,24.61 23,25.57 23,28.47 23.96,29.43 v1(23.96,31.78)
  BOTTOM w0.203: v1(23.96,31.78) 24.44,31.3 25.65,31.3 25.92,31.57 28.04,31.57 28.1,31.51 UA1.38
  BOTTOM w0.254: RA26.1 25.69,19.65 25.66,19.68 v1(25.66,20.16)
MIC_CLK: length 271.8
  TOP w0.107: v1(164.39,173) 164.2,172.82 164.04,172.82 163.84,173.02 163.84,175.52 162.49,176.87 162.49,178.89 162.48,178.89 162.48,179.12 162.49,179.12 162.49,179.44 162.62,179.58 JEDP.23 ; RV13.1 163.11,163.74 162.24,162.86 161.46,162.86 161.2,163.11 161.2,163.64 161.74,164.18 161.74,165.32 160.64,166.43 160.64,168.02 160.21,168.44 v1(160.21,171.23)
  IN1 w0.097: v1(36.58,36.35) 36.79,36.56 36.79,45.26 39.7,48.17 44.52,48.17 45.05,48.69 53.4,48.69 53.69,48.39 60.25,48.39 60.59,48.05 65.43,48.05 65.66,48.29 68.67,48.29 69.3,47.66 88.59,47.66 90.75,49.81 90.75,52.04 92.47,53.75 93.76,53.75 101.77,61.76 101.77,66.04 113.64,77.91 113.64,160.33 114.2,160.9 126.86,160.9 129.01,158.75 137.46,158.75 138.47,159.77 142.6,159.77 145.44,162.61 145.44,167.18 148.88,170.62 159.6,170.62 v1(160.21,171.23) 160.39,171.05 161.63,171.05 163.49,172.91 164.3,172.91 v1(164.39,173)
  BOTTOM w0.107: LA6.1 35.82,37.05 CA34.1 36.76,36.53 v1(36.58,36.35)
MIC_DATA: length 259.1
  TOP w0.107: v1(164.39,172.42) 164.22,172.58 163.95,172.58 163.61,172.92 163.61,175.42 162.25,176.78 162.25,178.8 162.25,178.8 162.25,179.45 162.12,179.58 JEDP.22
  IN1 w0.097: v1(37.22,36.35) 37.01,36.56 37.01,45.17 39.79,47.94 44.62,47.94 45.14,48.46 53.3,48.46 53.6,48.17 60.15,48.17 60.5,47.83 65.52,47.83 65.76,48.06 68.58,48.06 69.21,47.43 88.69,47.43 90.97,49.72 90.97,51.94 92.56,53.53 93.86,53.53 101.99,61.66 101.99,65.95 113.86,77.82 113.86,160.24 114.29,160.67 126.77,160.67 128.91,158.53 137.55,158.53 138.57,159.54 142.69,159.54 145.66,162.51 145.66,167.08 148.97,170.39 159.69,170.39 160.13,170.82 161.72,170.82 163.58,172.69 164.12,172.69 v1(164.39,172.42)
  BOTTOM w0.107: RA19.1 35.82,35.64 35.82,35 35.97,34.84 36.48,34.84 36.76,35.13 CA35.1 37.22,36.18 v1(37.22,36.35)
MUX_EDP_A0N: length 99.8
  TOP w0.089: CV2.2 147.53,166.51 147.53,166.26 v1(147.71,166.08)
  IN1 w0.089: v1(192.25,131.08) 192.25,131.24 191.94,131.55 191.94,131.63 191.63,131.94 191.63,147 189.8,148.83 189.8,149.96 186.19,153.58 176.21,153.58 175.89,153.26 171.39,153.26 166.75,157.89 166.58,157.89 163.05,161.42 163.05,165.22 158.61,169.66 149.89,169.66 147.46,167.23 147.46,166.2 147.58,166.08 147.71,166.08 v1(147.71,166.08)
  BOTTOM w0.089: UV21.45 190.64,114.14 190.75,114.03 191.14,114.03 191.65,114.55 192.31,114.55 195.83,118.06 195.83,128.89 193.23,131.48 192,131.48 191.9,131.38 191.9,131.25 192.07,131.08 v1(192.25,131.08)
MUX_EDP_A0P: length 99.8
  TOP w0.089: v1(147.07,166.08) 147.11,166.08 147.27,166.24 147.27,166.49 CV1.2
  IN1 w0.089: v1(192.25,131.88) 192.05,131.88 191.89,132.04 191.89,147.11 190.06,148.94 190.06,150.07 186.29,153.83 176.1,153.83 175.78,153.52 171.5,153.52 166.86,158.15 166.69,158.15 163.31,161.53 163.31,165.33 158.72,169.92 149.78,169.92 147.18,167.31 147.18,166.19 v1(147.07,166.08)
  BOTTOM w0.089: v1(192.25,131.88) 192.38,131.75 193.34,131.75 196.1,129 196.1,117.95 192.42,114.28 191.76,114.28 191.25,113.76 190.78,113.76 190.76,113.74 UV21.46
MUX_EDP_A1N: length 94.6
  TOP w0.089: v1(148.98,166.08) 148.8,166.26 148.8,166.76 CV4.2
  IN1 w0.089: v1(148.98,166.08) 148.89,166.08 148.78,166.2 148.78,166.41 150.9,168.53 157.47,168.53 158.84,167.16 160.08,167.16 162.32,164.92 162.32,161.12 166.1,157.34 166.1,156.68 167.32,155.46 167.45,155.46 170.42,152.49 185.11,152.49 190.9,146.7 190.9,130.66 192.25,129.31 v1(192.25,129.1)
  BOTTOM w0.089: UV21.42 190.59,115.34 190.72,115.21 191.96,115.21 195.07,118.32 195.07,127.89 193.46,129.5 192.05,129.5 191.96,129.41 191.96,129.21 192.07,129.1 v1(192.25,129.1)
MUX_EDP_A1P: length 94.6
  TOP w0.089: v1(148.4,166.08) 148.54,166.22 148.54,166.87 CV3.2
  IN1 w0.089: v1(148.4,166.08) 148.52,166.21 148.52,166.52 150.79,168.79 157.58,168.79 158.95,167.42 160.19,167.42 162.58,165.03 162.58,161.23 166.36,157.45 166.36,156.78 167.43,155.72 167.56,155.72 170.53,152.75 185.22,152.75 191.16,146.81 191.16,130.77 192.07,129.86 192.2,129.86 v1(192.25,129.92)
  BOTTOM w0.089: UV21.43 192.07,114.94 195.33,118.21 195.33,128 193.57,129.76 192.4,129.76 v1(192.25,129.92)
MUX_EDP_A2N: length 93.7
  TOP w0.089: CV6.2 150.12,166.81 150.12,165.58 149.53,164.99 149.53,164.14 v1(149.74,163.93)
  IN1 w0.089: v1(149.74,163.93) 149.72,163.93 149.42,164.23 149.42,164.68 149.93,165.2 149.93,166.16 151.45,167.67 154.9,167.67 156.48,166.08 158.25,166.08 160.98,163.36 160.98,163.02 161.59,162.4 161.59,160.82 165.29,157.12 165.29,156.28 169.84,151.73 184.84,151.73 190.17,146.4 190.17,129.22 191.87,127.52 192.11,127.52 192.25,127.39 192.25,127.09 v1(192.25,127.09)
  BOTTOM w0.089: v1(192.25,127.09) 192.22,127.12 191.98,127.12 191.89,127.21 191.89,127.4 191.98,127.49 192.53,127.49 194.3,125.71 194.3,118.64 192.16,116.49 190.8,116.49 190.76,116.54 UV21.39
MUX_EDP_A2P: length 93.6
  TOP w0.089: CV8.2 149.85,166.83 149.85,165.68 149.26,165.1 149.26,164.03 v1(149.16,163.93)
  IN1 w0.089: v1(192.25,127.93) 192.11,127.78 191.98,127.78 190.43,129.33 190.43,146.5 184.95,151.99 169.95,151.99 165.55,156.38 165.55,157.22 161.85,160.93 161.85,162.51 161.24,163.12 161.24,163.46 158.36,166.34 156.59,166.34 155,167.93 151.34,167.93 149.67,166.26 149.67,165.3 149.16,164.79 v1(149.16,163.93)
  BOTTOM w0.089: UV21.40 190.76,116.14 190.84,116.22 192.27,116.22 194.57,118.52 194.57,125.83 192.64,127.76 192.42,127.76 v1(192.25,127.93)
MUX_EDP_A3N: length 86.6
  TOP w0.089: CV11.2 150.96,165.36 150.96,164.72 v1(151.12,164.56)
  IN1 w0.089: v1(192.26,125.12) 192.26,125.38 192.08,125.56 191.92,125.56 189.44,128.03 189.44,146.09 185.45,150.08 170.12,150.08 168.66,151.54 168.66,151.75 161.68,158.73 160.92,158.73 159.92,159.73 159.92,163.38 158.44,164.87 154.91,164.87 152.96,166.82 151.8,166.82 150.86,165.88 150.86,164.79 151.09,164.56 v1(151.12,164.56)
  BOTTOM w0.089: UV21.36 190.72,117.74 190.81,117.65 192.05,117.65 193.3,118.9 193.3,124.85 192.63,125.52 192.05,125.52 191.96,125.43 191.96,125.32 192.16,125.12 v1(192.26,125.12)
MUX_EDP_A3P: length 86.7
  TOP w0.089: CV7.2 150.69,165.47 150.69,164.72 v1(150.54,164.56)
  IN1 w0.089: v1(150.54,164.56) 150.61,164.63 150.61,165.99 151.69,167.08 153.07,167.08 155.02,165.12 158.54,165.12 160.18,163.49 160.18,159.84 161.03,158.99 161.79,158.99 168.92,151.86 168.92,151.65 170.23,150.34 185.56,150.34 189.7,146.2 189.7,128.14 192.02,125.82 192.16,125.82 v1(192.26,125.92)
  BOTTOM w0.089: v1(192.26,125.92) 192.39,125.79 192.74,125.79 193.57,124.96 193.57,118.79 192.16,117.38 190.7,117.38 190.66,117.34 UV21.37
MUX_EDP_AUXN: length 86.1
  TOP w0.089: CV13.2 152.07,166.91 152.07,166.29 151.92,166.14 151.92,165.22 151.84,165.15 151.84,163.73 v3(151.46,163.35) 150.65,162.54 150.21,162.54 v1(150.08,162.41)
  IN1 w0.089: v1(191.02,119.92) 191.13,119.92 191.22,120.01 191.22,120.25 188.02,123.45 188.02,145.4 185.44,147.98 181.43,147.98 180.98,148.44 164.16,148.44 161.32,151.28 157.37,151.28 155.45,153.21 155.45,158.23 150.88,162.8 150.08,162.8 149.95,162.66 149.95,162.54 150.07,162.41 v1(150.08,162.41)
  BOTTOM w0.089: RV19.2 190.94,122.42 190.94,120.01 v1(191.02,119.92) 191.27,119.92 191.37,119.83 191.37,119.7 191.13,119.46 190.87,119.46 190.59,119.74 UV21.31
MUX_EDP_AUXP: length 86.6
  TOP w0.089: CV12.2 151.71,167 151.8,166.91 151.8,166.4 151.65,166.25 151.65,165.34 151.57,165.26 151.57,163.84 150.58,162.85 150.17,162.85 150.05,162.97 150.05,163.11 150.14,163.2 v1(150.15,163.2)
  IN1 w0.089: v1(191.8,119.8) 191.48,120.12 191.48,120.36 188.28,123.56 188.28,145.51 185.55,148.24 181.54,148.24 181.08,148.7 164.27,148.7 161.43,151.54 157.48,151.54 155.71,153.31 155.71,158.33 150.99,163.05 150.29,163.05 v1(150.15,163.2)
  BOTTOM w0.089: UV21.32 190.61,119.34 190.76,119.19 191.24,119.19 191.74,119.69 191.74,119.73 191.8,119.79 v1(191.8,119.8) 191.21,120.39 191.21,122.14 191.68,122.61 RV20.1
N17_ID0: length 27.6
  BOTTOM w0.089: UH1.AL43 209.63,18.52 209.41,18.29 209.41,16.95 209.69,16.67 210.82,16.67 211.99,15.5 212.27,15.22 212.27,15.16
  BOTTOM w0.107: RH27.1 RH28.1 196.82,14.13 197.2,13.75 197.67,13.75 197.78,13.64 197.78,11.89 199.37,10.29 203.74,10.29 204.21,10.77 v2(205.22,10.77) 208.85,10.77 210.51,12.43 211.61,12.43 212.38,13.2 212.38,15.05 212.27,15.16
N17_ID1: length 23.5
  BOTTOM w0.089: UH1.AJ43 208.47,18.71 208.73,18.45 208.73,17.75 208.97,17.52 208.97,16.89 209.65,16.21 210.71,16.21 211.76,15.16
  BOTTOM w0.107: RH26.1 RH25.1 199.21,13.71 199.41,13.51 199.41,12.19 200.54,11.05 v2(200.92,11.05) 203.5,11.05 204.11,11.66 205.94,11.66 206.82,12.54 209.61,12.54 210.14,13.08 211.32,13.08 211.76,13.52 211.76,15.16
NC_B4: length 4.6
  TOP w0.089: 177.52,170.19 177.52,170.19 177.52,169.64 177.3,169.42 UT1.B4
  TOP w0.107: v1(177.58,171.47) 177.58,171.38 177.36,171.16 177.36,170.34 177.52,170.19
  BOTTOM w0.107: RT86.2 v2(177.36,170.96) 177.36,171.25 v1(177.58,171.47) 177.72,171.61 RT45.1
NC_B5: length 3.1
  TOP w0.089: UT1.B5 177.76,169.43 177.99,169.67 178,170.14
  TOP w0.127: RT46.1 178.95,171.8 178.44,171.29 v2(178.44,171.04) 178.44,170.59 178,170.14
NC_G2: length 4.4
  TOP w0.089: UT1.G2 176.16,166.86 175.74,166.86 175.62,166.74 175.62,166 175.47,165.85
  TOP w0.107: 175.47,165.85 174.94,165.32 v2(174.94,164.68) 174.16,163.89 RT47.1
NRB_BIT: length 4.7
  TOP w0.107: v1(217.53,25.76) 218.49,24.8 219.68,24.8 RH524.2
  BOTTOM w0.089: UH1.BD28 216.11,25.94 216.18,25.87 216.65,25.87 216.74,25.79 216.74,25.79 216.75,25.78 217.51,25.78 v1(217.53,25.76)
NUM: length 42.3
  TOP w0.107: v1(248.42,14.55) 247.91,14.04 245.66,14.04 v2(245.21,14.5) 245.11,14.6 238.84,14.6 236.44,12.21 233.99,12.21 230.81,9.02 230.81,8.18 229.08,6.46 223.81,6.46 223.76,6.51 v1(222.97,6.51)
  IN2 w0.091: v1(248.42,14.55) 248.42,14.76 248.67,15.02 253.26,15.02 v1(253.7,14.57)
  BOTTOM w0.107: RE636.1 257.7,14.76 256.98,14.03 256.26,14.03 255.09,15.21 254.34,15.21 v1(253.7,14.57) ; v1(222.97,6.51) JKB.2
NUM_LED: length 63.9
  TOP w0.107: v1(268.68,13.25) 269.12,12.81 271.53,12.81 272.92,14.19 v2(273.57,14.19) 273.79,14.19 v1(276.17,11.81) ; v1(293,9.78) 293.93,10.71 293.93,12.41 293.17,13.17 293.17,14.13 293.76,14.72 293.76,16.29 294.24,16.77 294.24,17.64 293.76,18.12 293.76,20.48 293.22,21.01 UE5.36
  IN1 w0.097: v1(293,9.78) 288.74,9.78 286.96,11.57 277.21,11.57 276.96,11.81 v1(276.17,11.81)
  IN4 w0.097: v1(251.41,14.55) 251.91,15.06 263.19,15.06 263.79,15.65 v1(263.79,15.94)
  BOTTOM w0.107: RE637.1 252.04,16.22 251.41,15.59 v1(251.41,14.55) ; v1(268.68,13.25) 268.67,13.25 268.26,12.84 267.99,12.84 267.73,12.58 266.99,12.58 264.58,14.99 263.99,14.99 263.79,15.19 v1(263.79,15.94)
ON/OFF#: length 253.3
  TOP w0.107: v2(311.9,7.3) v1(311.9,6.79) SW1.2 ; UE5.114 308.14,16.61 v1(308.45,16.31) 308.66,16.1 309,16.1 309.11,15.99 CE27.1 309.11,15.81 309.98,14.93 RE63.1 ; v1(212.11,167.28) 212.32,167.07 JPWR.5
  IN3 w0.091: v1(308.45,16.31) 309.57,17.42 311.72,17.42 312.7,18.4 312.7,21.28 309.45,24.54 309.45,28.19 303.95,33.69 303.95,39.64 303.07,40.52 300.43,40.52 298.84,42.1 298.84,48.7 298.19,49.34 298.19,59.52 296.02,61.69 296.02,71.19 290.28,76.92 290.28,85.64 288.38,87.55 288.38,91.72 284.2,95.9 284.2,136.56 282.55,138.21 275.14,138.21 264.08,149.27 255.84,149.27 254.82,148.25 243.73,148.25 241.28,150.7 241.28,158.83 242.03,159.57 242.03,163.81 241.65,164.19 241.65,166.49 237.57,170.57 232.83,170.57 230.15,167.9 228.17,167.9 226.92,166.64 223.14,166.64 222.79,166.99 212.4,166.99 v1(212.11,167.28)
  BOTTOM w0.107: v1(308.45,16.31) 308.45,16.26 309.17,15.54 309.17,10.83 309.63,10.36 309.63,9.05 v1(311.9,6.79)
OUT_A:
  vias: v1(36.9,5.24) v1(37.35,4.86) v2(37.4,5.47)
OUT_B: length 1.6
  BOTTOM w0.107: v1(36.33,2.32) v2(36.33,1.75)
  BOTTOM w0.508: v1(36.33,2.32) 36.48,2.47 36.48,2.51 36.71,2.73 LA51.1
OUT_D: length 1.1
  TOP w0.107: v1(27,7.23) 27,8.16 v2(26.87,8.29)
  vias: v1(27,6.64) v1(31.63,3.78) v1(31.63,3.18)
P1: length 19.7
  TOP w0.254: PR701.2 63.43,30.75 64.26,31.58 PQ700.3 65.08,31.58 65.48,31.97 65.48,33.56 66.62,34.7 ; PQ708.1 66.32,35.1 65.16,33.94 62.3,33.94 61.22,32.86 v4(61.22,32.73) 61.22,31.59 60.97,31.34 60.97,30.89 58.75,28.67 PC701.1 58.05,28.16 58.29,27.92 PR706.1
  vias: v1(68.06,36.06) v1(68.07,34.83) v1(68.08,37.33) v1(68.28,38.46) v1(68.56,37.93) v1(68.64,36.71) v1(68.67,36.06) v1(68.65,35.44) v1(68.67,34.83) v1(68.7,37.32) v1(68.87,38.45)
P2:
  vias: v1(60.84,41.5) v1(60.84,40.86) v1(61.03,40.23) v1(61.48,41.5) v1(61.48,40.86) v1(61.67,40.23) v1(62.11,41.5) v1(62.11,40.86) v1(62.3,40.23) v1(62.75,41.5) v1(62.75,40.86) v1(62.94,40.23) v1(63.38,40.86) v1(63.57,40.23) v4(59.71,40.85)
PA_USB2_RBIAS: length 2.4
  TOP w0.102: v1(184.55,166.41) UT1.H19
  BOTTOM w0.107: v2(185.05,165.51) 185.05,165.89 184.55,166.39 v1(184.55,166.41)
  BOTTOM w0.127: RT43.1 185.04,166.4 185.03,166.41 v1(184.55,166.41)
PANELL_LED_B_DRV#: length 180.6
  TOP w0.107: v1(233.02,164.5) 232.96,164.56 232.94,164.56 231.92,165.58 JLOGO.11
  IN3 w0.091: v1(296.59,42.55) 296.59,43.91 297.32,44.64 297.32,58.99 294.99,61.33 294.99,70.98 288.54,77.43 288.54,82.87 284.96,86.45 284.96,91.53 282.57,93.93 282.57,111.63 282.24,111.96 282.24,112.58 282.96,113.3 282.96,117.16 282.48,117.63 282.48,121.19 283.14,121.84 283.14,135.15 281.83,136.46 275.56,136.46 264.49,147.53 256.6,147.53 255.58,146.51 243,146.51 241.59,147.92 236.5,147.92 235.07,149.35 235.07,155.01 234.4,155.68 234.4,157.63 233.39,158.64 233.39,160.31 236.44,163.36 236.44,164.2 235.22,165.42 233.94,165.42 v1(233.02,164.5)
  BOTTOM w0.107: UE8.14 v1(296.59,42.55)
PANELL_LED_G_DRV#: length 180
  TOP w0.107: v1(231.97,164.95) 231.4,164.95 230.92,165.42 JLOGO.10 ; v2(298.15,42.36) 297.9,42.36 v1(297.43,42.83)
  IN3 w0.091: v1(231.97,164.95) 233.11,166.08 236.83,166.08 239.78,163.13 239.78,162.52 240.43,161.86 240.43,161.03 240.01,160.61 240.01,160.59 239.99,160.57 239.99,158.58 239.61,158.19 239.61,157.3 238.82,156.52 238.82,151.61 243.27,147.16 255.31,147.16 256.33,148.18 264.77,148.18 275.83,137.11 282.1,137.11 283.8,135.42 283.8,111.42 283.89,111.32 283.89,94.55 287.29,91.16 287.29,87.1 289.19,85.19 289.19,77.71 295.64,71.26 295.64,61.6 297.98,59.27 297.98,43.38 v1(297.43,42.83)
  BOTTOM w0.107: v1(297.43,42.83) 297.42,42.83 296.2,44.05 UE8.11
PANELL_LED_R_DRV#: length 179.5
  TOP w0.107: JLOGO.9 229.92,165.56 231.11,164.37 v1(232.09,164.37)
  IN3 w0.091: v1(297.4,43.43) 297.76,43.79 297.76,59.17 295.42,61.51 295.42,71.17 288.97,77.62 288.97,85.1 287.07,87 287.07,91.07 283.68,94.46 283.68,111.23 283.58,111.33 283.58,135.33 282.01,136.89 275.74,136.89 264.67,147.96 256.42,147.96 255.4,146.94 243.18,146.94 238.6,151.52 238.6,157.5 239.77,158.67 239.77,160.67 239.79,160.69 239.79,160.7 240.21,161.12 240.21,161.77 239.56,162.42 239.56,163.04 236.74,165.86 233.2,165.86 232.55,165.21 232.55,164.83 v1(232.09,164.37)
  BOTTOM w0.107: v1(297.4,43.43) 296.28,44.55 UE8.10
PANELR_LED_B_DRV#: length 184.2
  TOP w0.107: v2(233.74,163.29) 233.74,163.79 v1(234.39,164.44) 234.42,164.44 234.92,164.94 JLOGO.14
  IN3 w0.091: v1(296.6,40.32) 295.82,41.1 295.82,44.38 296.76,45.33 296.76,58.76 293.41,62.11 293.41,71.94 288.1,77.25 288.1,82.69 284.53,86.26 284.53,91.35 283.13,92.74 281.38,92.74 280.93,93.19 280.93,111.67 281.19,111.92 281.19,113.95 280.96,114.18 280.96,120.28 282.7,122.03 282.7,134.97 281.65,136.02 274.24,136.02 265.28,144.98 255.93,144.98 254.84,146.07 242.82,146.07 241.41,147.48 236.32,147.48 234.46,149.34 234.46,151.24 233.96,151.74 233.96,157.45 232.95,158.46 232.95,160.58 236.01,163.63 236.01,164.02 235.59,164.44 v1(234.39,164.44)
  BOTTOM w0.107: v1(296.6,40.32) 295.93,39.64 293.86,39.64 293.21,40.29 UE8.17
PANELR_LED_G_DRV#: length 179.8
  TOP w0.107: JLOGO.13 233.92,165.53 v1(234.42,165.02) ; v1(296.59,40.9) 296.2,40.51 296.2,39.96 v2(296.21,39.95)
  IN3 w0.091: v1(296.59,40.9) 296.19,41.3 296.19,44.09 297.1,45.01 297.1,58.73 293.63,62.2 293.63,72.03 288.32,77.34 288.32,82.78 284.75,86.36 284.75,91.44 281.76,94.43 281.76,120.77 282.92,121.93 282.92,135.06 281.74,136.24 274.42,136.24 265.46,145.2 256.02,145.2 254.93,146.29 242.91,146.29 241.5,147.7 236.41,147.7 234.67,149.44 234.67,151.33 234.18,151.83 234.18,157.54 233.17,158.55 233.17,160.4 236.23,163.45 236.23,164.11 235.31,165.02 v1(234.42,165.02)
  BOTTOM w0.107: v1(296.59,40.9) 295.49,40.9 294.84,41.55 UE8.16
PANELR_LED_R_DRV#: length 178.3
  TOP w0.107: v2(296.26,41.54) 296.59,41.87 v1(296.59,41.97) ; v1(232.99,165.09) 232.92,165.16 JLOGO.12
  IN3 w0.091: v1(232.99,165.09) 233.55,165.64 236.65,165.64 239.34,162.95 239.34,162.27 239.98,161.64 239.98,161.2 239.57,160.79 239.57,160.78 239.55,160.76 239.55,158.76 238.39,157.59 238.39,151.43 243.09,146.72 255.49,146.72 256.51,147.75 264.58,147.75 275.65,136.68 281.92,136.68 283.36,135.24 283.36,121.75 282.67,121.06 282.67,117.76 283.18,117.25 283.18,113.21 282.46,112.49 282.46,112.05 282.78,111.72 282.78,94.02 284.02,92.78 285.05,92.78 286.85,90.98 286.85,86.91 288.76,85.01 288.76,77.52 295.21,71.07 295.21,61.42 297.54,59.08 297.54,44.52 296.99,43.97 296.99,42.32 296.64,41.97 v1(296.59,41.97)
  BOTTOM w0.107: v1(296.59,41.97) 296.51,42.05 UE8.15
PB_USB2_RBIAS: length 3.5
  TOP w0.102: UT1.F19 183.92,167.69 v1(183.92,167.71)
  BOTTOM w0.127: RT44.1 185.3,168.43 v2(185.08,168.66) 184.92,168.82 184.35,168.82 184.03,168.5 184.03,167.82 v1(183.92,167.71)
PBTN_OUT#: length 127.9
  TOP w0.089: v1(211.93,34.19) 211.84,34.11 210.72,34.11 210.46,34.37 ; CH174.1 209.15,35.43 RH2.2
  TOP w0.102: 210.46,34.37 210.27,34.56 CH174.1
  TOP w0.107: UE5.106 305.69,13.41 303.68,13.41 v1(302.9,14.19)
  IN3 w0.091: v1(225.54,30.95) 226.05,30.44 226.05,25.15 228.35,22.84 229.48,22.84 229.93,22.4 232.39,22.4 233.96,20.83 235.06,20.83 236.43,22.21 239.67,22.21 240.35,21.53 242.39,21.53 243.14,20.78 245.2,20.78 245.98,20 249.25,20 250.68,21.43 250.68,21.73 253.04,24.08 257.34,24.08 258.87,25.61 262.53,25.61 265.79,28.86 270.24,28.86 270.52,29.14 274.7,29.14 275.4,29.83 281,29.83 283.34,27.49 290.5,27.49 293.69,24.3 301.11,24.3 303.39,22.03 303.39,14.68 v1(302.9,14.19)
  IN4 w0.097: v1(225.54,30.95) 224.85,30.95 224.21,30.31 220.05,30.31 219.46,30.89 219.46,31.14 219.06,31.55 213.73,31.55 211.93,33.35 v1(211.93,34.19)
  BOTTOM w0.089: v1(211.93,34.19) 212.04,34.08 UH1.AT13
PC0: length 14.3
  TOP w0.107: v1(195,108.36) 194.57,108.36 193.68,109.25 RV624.1 RV625.1
  IN3 w0.091: v1(195,108.36) 190.63,112.73 190.63,116.53 v1(191.04,116.94)
  BOTTOM w0.107: v1(191.04,116.94) UV21.38
PC1: length 5.8
  BOTTOM w0.107: RV626.1 186.49,107.71 186.49,108.99 RV627.1 186.49,109.99 187.08,109.99 187.79,110.7 UV21.55
PC_BEEP: length 8.9
  TOP w0.254: RA15.1 v2(36.46,20.97) 36.69,20.97 38.3,22.57 38.3,23.4 RA9.1 36.93,25.43 DA1.1
