# Allegro board LAD752PR10-0816.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
I2S_DATA_OUT_R: length 4.2
  TOP w0.107: v1(36.56,31.43) 36.16,31.82 v2(36.16,31.97) 36.16,32.03 36.72,32.59 CA40.1 38.11,32.59 38.12,32.59 RA33.1
  BOTTOM w0.107: UA1.5 36.48,31.51 v1(36.56,31.43)
I2S_LRCK: length 333.4
  TOP w0.107: UA4.11 37.97,11.21 38.34,11.59 38.74,11.59 38.93,11.78 38.93,11.79 39.06,11.91 v1(39.06,13.18) ; JIO.16 324.75,17.36 324.62,17.48 v1(324.62,18.27)
  IN2 w0.091: v1(324.62,18.27) 324.62,17.54 319.98,12.89 309.94,12.89 309.04,11.99 303.33,11.99 302.48,12.85 296.63,12.85 296.41,13.06 291.6,13.06 290.41,14.25 277.73,14.25 273.78,18.2 271.9,18.2 271.8,18.3 269.04,18.3 268.45,17.71 267.47,17.71 264.83,15.07 256.34,15.07 255.38,14.11 242.48,14.11 241.69,14.9 232.92,14.9 232.32,15.5 231.24,15.5 230.86,15.12 230.86,14.29 230.14,13.57 228.28,13.57 226.8,15.05 214.95,15.05 212.6,12.7 206.84,12.7 205.82,11.69 204.88,11.69 204.71,11.86 197.27,11.86 196.24,12.89 193.71,12.89 190.29,16.31 185.64,16.31 184.85,17.1 184.42,17.1 184.11,17.41 100.89,17.41 99.97,16.49 98.04,16.49 96.78,15.22 85.28,15.22 84.14,14.09 83.85,13.8 69.61,13.8 68.02,12.21 62.82,12.21 62.49,12.54 56.62,12.54 54.21,14.96 40.65,14.96 39.06,13.36 v1(39.06,13.18)
  IN4 w0.097: v1(38.87,35.17) 40.11,33.94 40.11,31.23 40.34,31 40.34,28.57 40.01,28.24 40.01,13.63 39.56,13.18 v1(39.06,13.18)
  BOTTOM w0.107: v1(38.87,35.17) 38.23,34.53 CA37.1 RA30.2
I2S_LRCK_R: length 1.7
  BOTTOM w0.107: RA30.1 37.27,33.61 37.06,33.4 36.42,33.4 36.13,33.11 UA1.1
I2S_OUT: length 333.7
  TOP w0.107: JIO.17 326.67,17.85 v1(327.09,18.27) ; v1(38.49,12.02) 38.36,12.02 37.96,11.61 UA4.12 ; v2(39.52,32.53) 39.48,32.53 38.92,31.97 v1(38.92,31.97)
  IN2 w0.091: v1(38.49,12.02) 38.51,12 38.96,12 39.73,12.76 39.73,13.24 41.01,14.52 54.03,14.52 56.44,12.11 62.31,12.11 62.64,11.78 68.21,11.78 69.79,13.36 84.03,13.36 84.32,13.65 85.46,14.79 96.96,14.79 98.23,16.05 100.15,16.05 101.07,16.98 183.93,16.98 184.24,16.66 184.67,16.66 184.7,16.63 185.46,15.87 190.11,15.87 194.6,11.39 201.76,11.39 202.31,10.84 203.41,10.84 203.82,11.26 206.01,11.26 207.02,12.27 212.79,12.27 215.14,14.62 226.62,14.62 228.1,13.14 230.32,13.14 231.3,14.11 231.3,14.94 231.42,15.06 232.14,15.06 232.74,14.47 240.67,14.47 241.47,13.67 255.56,13.67 256.52,14.63 265.01,14.63 267.65,17.28 271.42,17.28 271.97,16.72 273.74,16.72 276.65,13.82 290.23,13.82 291.42,12.63 296.23,12.63 296.45,12.41 302.3,12.41 303.15,11.56 311.13,11.56 311.44,11.88 313.82,11.88 314.35,11.35 316.21,11.35 317.32,12.46 320.16,12.46 324.63,16.93 325.75,16.93 v1(327.09,18.27)
  IN4 w0.097: v1(38.92,31.97) 38.39,31.43 38.39,28.33 39.57,27.15 39.57,14.64 38.02,13.09 38.02,12.32 38.31,12.02 v1(38.49,12.02)
  BOTTOM w0.107: RA31.2 CA36.1 39.06,32.11 v1(38.92,31.97)
I2S_OUT_R: length 1.6
  BOTTOM w0.107: UA1.3 36.46,32.31 36.76,32.6 RA31.1
I_OUT: length 147.5
  TOP w0.254: PR6081.1 290.2,50.25 v1(290.2,49.5)
  IN3 w0.091: v1(208.61,104.5) 208.7,104.41 208.7,91.86 204.69,87.84 204.69,87.43 201.37,84.11 201.37,82.65 v1(200.35,81.63)
  IN4 w0.097: v1(290.2,49.5) 289.71,49.99 288.31,49.99 288.02,49.71 284.34,49.71 284.04,50 284.04,53.32 283.3,54.06 283.3,57.16 281.99,58.47 280.77,58.47 280.26,57.96 278.75,57.96 278.31,58.41 277.7,58.41 277.25,57.96 276.15,57.96 273.85,60.26 270.74,60.26 269.69,61.31 229.49,61.31 224.58,66.22 213.37,66.22 210.33,69.27 206.59,69.27 205.2,70.66 205.2,71.83 203.04,73.98 203.04,74.75 201.94,75.85 201.17,75.85 199.27,77.75 199.27,80.55 v1(200.35,81.63)
  BOTTOM w0.107: v1(208.61,104.5) 209.62,105.52 RV533.1
I_SYS: length 162.5
  TOP w0.203: PU700.9 v1(54.49,23.03)
  IN1 w0.254: v1(54.49,23.03) 55.43,23.97 59.06,23.97 59.76,24.67 59.76,27.91 62.24,30.39 62.24,32.99 65.6,36.35 65.6,39.34 66.37,40.1 66.37,45.94 66.94,46.51 88.73,46.51 93.38,51.16 93.38,52.01 102.74,61.37 102.74,65.45 108.44,71.15 108.45,71.15 114.54,77.24 114.54,123.41 115.15,124.02 v1(119.23,124.02)
  IN3 w0.254: v1(121.22,134.02) 119.07,134.02 117.36,132.3 117.36,125.89 119.23,124.02 119.23,124.02 v1(119.23,124.02)
  BOTTOM w0.254: PR728.2 54.97,22.56 v1(54.49,23.03) ; PR526.2 122.28,135 121.3,134.02 v1(121.22,134.02)
IGPU_ENBKL: length 92.3
  IN1 w0.089: v1(204.08,22.32) 204.18,22.32 204.44,22.57 204.44,22.88 204.26,23.06 203.32,23.06 202.62,23.76 202.62,24.76 201.75,25.63 201.75,28.42 200.24,29.93 200.24,31.26 197.99,33.51 195.67,33.51 194.7,32.54 193.27,32.54
  IN1 w0.097: 193.27,32.54 192.41,32.54 191.32,33.64 191.32,34.37 191.1,34.58 191.1,40.21 187.95,43.36 187.95,45.16 v1(188.41,45.63)
  IN3 w0.091: v1(194.36,92.72) 194.24,92.83 192.51,92.83 186.82,87.15 186.82,74.35 186.12,73.65 186.12,72.73 185.22,71.83 185.22,70.6 185.71,70.11 185.71,64.97 186.59,64.09 186.59,46.24 187.2,45.63 v1(188.41,45.63)
  BOTTOM w0.089: UH1.W35 203.8,22.61 v1(204.08,22.32)
  BOTTOM w0.107: UV22.10 v1(194.36,92.72)
IGPU_ENVDD: length 94.9
  IN1 w0.097: v1(204.29,19.66) 203.92,20.03 203.46,20.03 202.83,20.67 202.83,23.03 201.17,24.68 201.17,28.43 199.78,29.83 199.78,30.75
  IN1 w0.102: 199.78,30.75 199.78,31.07 198.42,32.43 195.73,32.43 195.27,31.97 192.34,31.97 190.86,33.46 190.86,34.18 190.65,34.39 190.65,39.98 187.4,43.23 187.4,52.98 188.84,54.43 188.84,63.26 189.85,64.27 189.85,72.4 192.2,74.75 192.2,75.72 190.25,77.67 190.25,85.69 191.19,86.62 191.19,93.6 v1(190.13,94.66)
  BOTTOM w0.089: v1(204.29,19.66) 203.83,19.2 UH1.W42
  BOTTOM w0.107: v1(190.13,94.66) 189.76,94.66 189.41,94.31 189.41,92.19 189.53,92.07 UV22.6
IGPU_INV_PWM: length 94.8
  IN1 w0.097: v1(203.41,22.27) 203.41,22.71 202.44,23.68 202.44,24.68 201.36,25.76 201.36,28.51 199.97,29.9 199.97,31.15 198.46,32.66 195.5,32.66
  IN1 w0.102: v1(190.16,95.24) 190.36,95.24 191.29,94.31 191.29,94.29 191.41,94.16 191.41,86.52 190.48,85.59 190.48,77.76 192.44,75.81 192.44,72.64 190.08,70.28 190.08,64.17 189.07,63.16 189.07,54.28 187.63,52.84 187.63,43.32 190.87,40.07 190.87,34.49 191.09,34.28 191.09,33.55 192.44,32.2 194.93,32.2 195.39,32.66 195.5,32.66
  BOTTOM w0.089: UH1.W36 203.78,21.95 203.45,22.27 v1(203.41,22.27)
  BOTTOM w0.107: v1(190.16,95.24) 189.84,95.24 189.11,94.52 189.11,90.65 189.64,90.12 UV22.3
IMVP_VR_ON: length 355.6
  TOP w0.107: UE5.121 308.46,19.41 308.56,19.51 CE38.1 309.57,19.97 310.84,19.97 311.06,19.75 311.06,18.8 311.67,18.19 312.62,18.19 v1(314.14,19.72) ; v1(315.54,27.08) 315.54,27.96 v2(318.2,30.62) 320.68,33.1 320.68,39.66 320.24,40.1 320.24,41.93 321.19,42.88 Q7.6
  IN2 w0.091: v1(315.54,27.08) 314.83,26.38 308.74,26.38 308.42,26.7 301.89,26.7 298.36,30.22 293.51,30.22 288.12,35.62 284.66,35.62 284.16,36.12 273.34,36.12 264.02,45.44 229.29,45.44 228.22,46.5 217.57,46.5 216.68,47.4 215.08,47.4 210.92,51.56 210.92,52.47 209.71,53.68 209.71,55 206.74,57.98 201.13,57.98 199.35,59.76 197.23,59.76 192.34,64.65 191.18,64.65 186.02,69.81 186.02,71.92 185.77,72.17 185.77,92.08 183.09,94.76 183.09,98.26 180.88,100.46 180.88,117.34 182.5,118.96 182.5,121.95 189.3,128.75 189.3,143.06 185.26,147.1 177.51,147.1 176.73,146.32 173.19,146.32 172.39,147.12 167.93,147.12 163.98,151.08 158.48,151.08 156.86,152.7 140.48,152.7 138.12,150.34 131.33,150.34 130.52,149.53 123.85,149.53 123.14,148.81 123.14,147 120.71,144.58 120.71,133.87 v1(121.22,133.37)
  IN3 w0.091: v1(314.14,19.72) 314.19,19.76 314.19,22.38 314.99,23.19 314.99,26.53 v1(315.54,27.08)
  BOTTOM w0.107: v1(121.22,133.37) 121.25,133.37 PR523.2
IN1_PEQ#: length 7.1
  BOTTOM w0.107: UV21.52 188.99,110.14 189.1,110.03 RV633.2 RV629.1 188.55,109.03 188.55,108.22 188.08,107.75 RV628.1 188.08,107.17 188.73,106.52 188.92,106.52 v2(189.11,106.33)
IN2_PEQ#: length 12.5
  BOTTOM w0.107: RV631.1 RV630.1 187.17,104.46 v2(187.71,105.01) 189.25,105.01 190.06,105.82 190.06,107.03 190.57,107.54 190.57,108.93 190.05,109.45 RV632.2 190.05,109.92 189.39,110.59 UV21.51
INTRUDER#: length 2.3
  TOP w0.089: RH531.1 216.84,34.24 v1(216.88,34.2) 217.5,34.2 v2(217.75,34.45)
  BOTTOM w0.089: v1(216.88,34.2) 216.71,34.37 UH1.BE11
INV_PWM: length 123.5
  TOP w0.107: JEDP.36 169.12,179.43 169.2,179.36 169.2,177.39 167.9,176.09 v1(167.9,168.18) ; v1(171.25,161.35) 171.25,160.99 170.76,160.5 RV8.1
  IN1 w0.097: v1(167.9,168.18) 167.67,167.94 167.67,164.92 167.95,164.64 167.95,162.67 168.39,162.23 170.94,162.23 171.25,161.93 v1(171.25,161.35)
  IN2 w0.091: v1(171.25,161.35) 171.25,161.05 169.58,159.37 169.58,157.6 170.04,157.13 170.04,155.61 170.65,155 171.06,155 172.8,153.25 177.04,153.25 177.29,153.5 188.92,153.5 191.12,151.3 191.12,149.62 196.39,144.35 196.39,111.82 193.46,108.9 193.46,104.53 192.37,103.43 192.37,95.08 193.05,94.4 193.05,93.07 v1(193.68,92.43)
  BOTTOM w0.107: UV22.4 194.25,90.77 194.59,91.11 194.59,91.91 194.06,92.43 v1(193.68,92.43)
ISEN1_GT: length 38.5
  TOP w0.107: v2(141.17,137.51) 141.42,137.76 v1(141.42,137.96)
  TOP w0.254: PR589.2 142.34,138.32 PR587.2 142.09,138.38 141.67,137.96 v1(141.42,137.96)
  IN1 w0.254: v1(122.32,142.34) 121.75,142.34 121.09,141.68 121.09,138.6 122.18,137.51 125.23,137.51 125.48,137.76 128.53,137.76 129.36,136.94 133.17,136.94 136.79,133.32 139.9,133.32 140.41,133.83 140.41,137.26 141.11,137.96 v1(141.42,137.96)
  BOTTOM w0.203: PC528.2 121.24,144.11 121.67,144.11 121.8,143.98 121.8,142.73 121.87,142.66 121.87,142.65 122.17,142.34 v1(122.32,142.34) 122.57,142.34 122.83,142.08 PU500.9
ISEN1_VCORE: length 54.9
  TOP w0.254: PC527.1 127.7,145.55 v1(127.7,145.37) ; PR560.2 158.67,134.16 ; 158.67,134.16 158.66,134.18 PR558.2 158.2,135.05 157.94,134.79 157.05,134.79 156.67,134.41 v2(155.89,134.41) v1(154.75,134.41) ; 158.67,134.16 PR561.2
  IN4 w0.254: v1(154.75,134.41) 153.69,134.41 152.7,133.42 152.7,130.33 151.44,129.06 146.66,129.06 146.28,128.69 142.85,128.69 142.28,129.25 140.41,129.25 136.79,132.87 136.79,141.22 135.41,142.6 129.83,148.18 128.02,148.18 127.7,147.86 v1(127.7,145.37)
  BOTTOM w0.203: v1(127.7,145.37) 127.7,145.07 127.47,144.84 PU500.21
ISEN2_GT: length 47.1
  TOP w0.254: v1(148.15,137.07) 148.15,137.7 v2(148.37,137.93) 148.79,138.34 PR596.2 150.47,138.32 PR598.2
  IN1 w0.254: v1(148.15,137.07) 148.02,136.94 141.23,136.94 140.85,136.56 140.85,133.38 140.29,132.82 136.65,132.82 133.8,135.67 130.76,135.67 130.31,136.11 121.74,136.11 120.71,137.14 120.71,141.94 121.8,143.03 122.17,143.03 v1(122.27,142.94)
  BOTTOM w0.203: PC525.2 121.73,144.49 121.8,144.49 122.2,144.1 122.2,143.01 v1(122.27,142.94) 122.45,142.94 122.9,142.48 PU500.10
ISEN2_VCORE: length 62.4
  TOP w0.107: v2(129.36,145.7) 128.98,145.32 v1(128.34,145.32)
  TOP w0.254: PC526.1 128.34,145.81 v1(128.34,145.32) ; v1(164.11,135.1) 164.19,135.18 PR568.2 167.14,135.13 167.14,134.35 PR571.2 PR570.2
  IN4 w0.254: v1(164.11,135.1) 164.47,134.73 164.47,131.63 163.69,130.84 158.88,130.84 156.34,128.3 146.97,128.3 146.6,127.92 142.54,127.92 142.1,128.37 139.9,128.37 136.03,132.24 136.03,140.91 134.65,142.28 130.79,146.15 129.16,146.15 v1(128.34,145.32)
  BOTTOM w0.203: v1(128.34,145.32) 128.34,145.13 127.87,144.67 PU500.22
ISEN3_VCORE: length 67.7
  TOP w0.107: v2(173.49,135.22) 173.61,135.1 v1(174.25,135.1)
  TOP w0.254: PR581.2 PR580.2 175.14,135.05 PR578.2 v1(174.25,135.1)
  IN4 w0.254: v1(129.99,145.02) 129.99,144.84 131.16,143.67 132.19,143.67 135.26,140.59 135.26,131.79 139.64,127.41 141.97,127.41 142.22,127.16 146.91,127.16 147.29,127.54 156.66,127.54 158.59,129.47 159.2,130.08 163.49,130.08 164.09,129.47 164.49,129.47 170.12,135.1 v1(174.25,135.1)
  BOTTOM w0.203: v1(129.99,145.02) 129.89,144.93 128.64,144.93 128.27,144.56 PU500.23
  BOTTOM w0.254: PC524.1 130.03,145.06 v1(129.99,145.02)
ISENSEP_L: length 3.2
  TOP w0.203: UA4.25 32.65,14.45 32.77,14.57
  TOP w0.508: RA77.1 RA58.2 33.34,15.14 33.12,14.92 33.12,14.91 32.89,14.69 32.89,14.69 32.77,14.57
ISENSEP_L_R: length 19.4
  TOP w0.127: v1(33.92,16.99) v2(33.92,17.55)
  IN1 w1.016: 37.47,3.59 34.97,3.59 33.98,4.57 33.98,5.3 32.97,6.32 31.57,6.32 30.55,7.33 30.55,13.43 32.86,15.74 33.4,15.74
  vias: v1(33.34,16.99) v1(37.85,2.58) v1(38.48,2.58)
ISENSEP_R: length 5.4
  TOP w0.127: v2(27.96,16.08) RA80.1
  TOP w0.203: 30.87,13.88 31.25,13.88 31.45,13.67 UA4.28
  TOP w0.508: 30.87,13.88 29.85,13.88 28.85,14.88 RA63.2 28.63,15.08 RA80.1
ISENSEP_R_R: length 15.6
  IN1 w1.016: 28.77,15.53 28.83,15.47 28.65,15.28 28.65,7.91 29.22,7.33 29.22,6.11 30.64,4.69 31.35,4.69 31.46,4.79 32.01,4.79 32.53,4.27 32.53,2.58
  vias: v1(28.49,16.42) v1(29.09,16.42) v1(31.73,1.43) v1(32.33,1.43) v2(32.27,2)
ISUMN_GT: length 63
  TOP w0.254: v1(149.61,137.58) 149.61,136.24 149.87,135.99 150.94,135.99 151.42,136.47 PR597.1 ; PR588.1 143.32,136.23 143.07,135.99 141.8,135.99 141.74,136.05 v1(141.42,136.05)
  TOP w0.508: v1(119.83,142.29) 120.7,143.16 v2(120.7,145.76) 120.7,147.48 121.06,147.84 122.33,147.84 122.33,147.84 122.57,147.84 122.6,147.81 PH502.2
  IN1 w0.254: v1(119.83,142.29) 119.83,141.77 120.33,141.27 120.33,136.83 121.48,135.67 130.12,135.67 130.56,135.22 133.68,135.22 136.66,132.24 140.66,132.24 141.36,132.94 141.36,135.99 v1(141.42,136.05) 141.67,136.3 148.34,136.3 v1(149.61,137.58)
  BOTTOM w0.381: PR538.1 119.5,144.56 PC528.1 119.69,144.86 120.35,145.52 PC525.1
  BOTTOM w0.508: PR535.2 PC516.2 PC517.2 120.27,141.84 v1(119.83,142.29) 119.5,142.61 PR540.1 PR538.1 118.64,143.86 PC523.1
ISUMN_SA: length 87.4
  TOP w0.254: PC511.1 130.63,135.72 v1(131.21,136.29)
  IN2 w0.254: v1(131.21,136.29) 131.21,130.9 133.49,128.62 138.95,128.62 141.48,126.08 151.01,126.08 152.66,124.43 152.66,123.41 153.36,122.71 155.2,122.71 157.17,124.69 169.71,124.69 172.42,127.39 174.23,127.39 175.04,128.2 175.04,129.02 176.74,130.73 185.14,130.73 187.77,133.36 187.77,134.85 v1(187.14,135.48)
  BOTTOM w0.254: PR5027.1 PH501.1 187.53,133.2 187.71,133.38 187.71,134.91 v1(187.14,135.48) ; PR529.1 PC510.1 PC512.1 PR524.2 133.09,138.49 PR528.1 133.13,138.48 133.67,137.93 133.67,136.46 133.42,136.2 131.3,136.2 v1(131.21,136.29)
ISUMN_VCORE: length 81.5
  TOP w0.254: PR542.1 PC530.1 PC531.1 127.23,146.94 PC527.2 PC526.2 v1(128.19,147.56) ; PR579.1 176.08,133.25 175.39,132.56 171.26,132.56 v2(170.86,132.97) 170.45,133.37 PR569.1 167.4,132.75 v1(163.84,132.75) 160.11,132.75 PR559.1
  IN4 w0.254: v1(128.19,147.56) 129.16,146.59 130.88,146.59 135.03,142.44 136.41,141.06 136.41,132.49 140.02,128.87 142.13,128.87 142.69,128.31 146.44,128.31 146.82,128.68 156.19,128.68 160.25,132.75 v1(163.84,132.75)
  BOTTOM w0.254: PR541.2 128.21,146.02 PR543.2 129.99,146.94 PC524.2 130.03,147.81 PC529.1 128.49,147.86 v1(128.19,147.56) ; v1(163.84,132.75) 163.84,131.92 163.38,131.47 PH503.1
ISUMP_GT: length 56.1
  TOP w0.254: v1(149.61,138.97) 150.18,138.97 150.58,139.38 PR595.1 ; v1(141.42,138.59) PR572.2 142.31,139.28 PR586.1 ; v1(123.58,148.45) 124.01,148.88 v2(124.53,148.88) 124.98,148.88 125.48,148.37 PR534.1
  IN1 w0.254: v1(149.61,138.97) 149.16,138.53 146.51,138.53 146.06,138.97 141.8,138.97 v1(141.42,138.59) 140.79,138.59 139.96,137.76 139.96,134.15 139.58,133.77 137.04,133.77 133.42,137.38 129.61,137.38 128.85,138.14 125.04,138.14 124.79,137.89 122.37,137.89 121.47,138.8 121.47,141.11 121.74,141.38 v1(121.93,141.38)
  IN2 w0.254: v1(123.58,148.45) 123.58,146.49 121.42,144.33 121.42,141.97 121.93,141.46 v1(121.93,141.38)
  BOTTOM w0.203: PU500.7 122.03,141.28 v1(121.93,141.38)
  BOTTOM w0.254: v1(121.93,141.38) 121.86,141.38 121.4,141.84 PC517.1 PC516.1 PR535.1
ISUMP_SA: length 83.7
  TOP w0.254: v1(187.13,134.77) 187.13,134.29 187.2,134.21 v2(187.2,133.83) PR582.2 187.15,132.76 186.95,132.56 186.72,132.56 PR5003.2
  IN2 w0.254: v1(187.13,134.77) 187.39,134.5 187.39,133.52 184.98,131.11 176.58,131.11 174.66,129.18 174.66,128.36 174.07,127.77 172.26,127.77 169.67,125.18 157.03,125.18 155.01,123.16 153.62,123.16 153.04,123.73 153.04,124.68 151.15,126.58 141.56,126.58 139.07,129.06 133.68,129.06 131.83,130.91 131.83,139.67 v1(131.2,140.31)
  BOTTOM w0.203: v1(131.2,140.31) 131.02,140.48 PU500.32
  BOTTOM w0.254: PR529.2 PC510.2 PC512.2 131.27,140.24 v1(131.2,140.31) ; v1(187.13,134.77) PR530.2
ISUMP_VCORE: length 83
  TOP w0.107: PR544.2 v2(122.31,146.02)
  TOP w0.254: v1(154.72,135.23) 157.43,135.23 PR562.2 158.01,135.8 158.26,135.8 PR557.1 ; PR544.2 PR542.2 PC530.2 PC531.2 126.43,146.02 126.69,145.77 v1(126.69,145.39) ; v1(174.25,135.73) 174.75,136.23 PR577.1 ; v1(164.12,135.73) 166.57,135.73 PR567.1
  IN4 w0.254: v1(174.25,135.73) v1(164.12,135.73) 158.31,135.73 157.8,135.23 v1(154.72,135.23) 153.63,135.23 152.32,133.92 152.32,130.49 151.28,129.45 146.5,129.45 146.12,129.07 143.01,129.07 142.43,129.65 140.55,129.65 137.17,133.03 137.17,141.38 129.86,148.69 127.83,148.69 126.88,147.73 126.88,145.58 v1(126.69,145.39)
  BOTTOM w0.203: v1(126.69,145.39) 126.67,145.37 PU500.19
IVSENSE_L: length 3.2
  TOP w0.203: UA4.26 32.25,14.49 32.14,14.6
  TOP w0.508: 32.14,14.6 32.14,14.6 31.56,15.17 RA78.1 32.45,15.33 RA59.2
IVSENSE_R: length 3
  TOP w0.203: UA4.29 29.98,12.41 29.6,12.8
  TOP w0.508: 29.6,12.8 29.34,13.06 RA81.1 RA64.2
JKSI0: length 43.6
  TOP w0.107: v1(209.74,6.51) 209.76,6.51 212.7,9.44 221.95,9.44 222.22,9.71 222.22,13.28 228.52,19.58 230.69,19.58 231,19.27 v2(231.28,19.27) 231.82,18.73 v1(231.82,18.7)
  BOTTOM w0.107: v1(209.74,6.51) 209.5,6.51 208.97,5.98 JKB.30 ; RE471.1 231.74,29.44 231.74,19.8 231.82,19.72 v1(231.82,18.7)
JKSI1: length 45.4
  BOTTOM w0.107: JKB.29 209.47,8.83 211.21,10.57 214.18,10.57 216.36,12.75 228.46,12.75 230.12,14.42 230.12,16.52 227.97,18.67 227.33,18.67 225.11,20.89 225.11,25.36 225.21,25.46 v2(225.21,25.93) 225.21,26.83 225.11,26.93 225.11,29.04 226.64,30.58 226.64,31.97 226.87,32.2 RE474.1
JKSI2: length 38.7
  TOP w0.107: v1(210.32,6.49) 210.32,6.5 v2(210.97,7.15) 213.03,9.21 222.05,9.21 222.46,9.62 222.46,13.18 228.62,19.34 230.6,19.34 v1(231.24,18.7)
  BOTTOM w0.107: v1(210.32,6.49) 209.97,6.14 JKB.28 ; RE466.1 231.5,26.44 231.5,19.04 231.24,18.77 v1(231.24,18.7)
JKSI3: length 41.1
  BOTTOM w0.107: RE467.1 227.11,28.96 225.86,27.72 225.86,25.51 225.53,25.18 v2(225.53,22.57) 225.53,20.8 227.43,18.9 228.07,18.9 230.36,16.61 230.36,14.32 228.56,12.52 216.78,12.52 214.59,10.32 211.72,10.32 210.47,9.07 JKB.27
JKSI4: length 34.1
  TOP w0.107: v1(230.65,18.7) 230.24,19.11 228.72,19.11 222.69,13.08 222.69,9.32 v2(222.55,9.17) 222.35,8.97 214.05,8.97 212.82,7.75 212.16,7.75 v1(210.97,6.57)
  BOTTOM w0.107: RE461.1 231.27,23.43 231.27,19.32 v1(230.65,18.7) ; JKB.26 v1(210.97,6.57)
JKSI5: length 37.2
  BOTTOM w0.107: RE460.1 226.81,25.72 226.01,24.92 v2(226.01,24.29) 226.35,23.94 226.35,22.3 225.93,21.88 225.93,20.73 227.53,19.14 228.16,19.14 230.59,16.71 230.59,14.22 228.65,12.28 216.88,12.28 214.64,10.04 212.71,10.04 211.47,8.8 JKB.25
JKSI6: length 28.9
  TOP w0.107: v1(211.97,6.57) 214.02,8.62 222.46,8.62 222.92,9.08 222.92,12.99 228.64,18.7 v2(229.12,18.7) v1(230.07,18.7)
  BOTTOM w0.107: JKB.24 v1(211.97,6.57) ; RE455.1 230.07,19.87 v1(230.07,18.7)
JKSI7: length 33.2
  BOTTOM w0.107: RE454.1 226.87,22.49 226.17,21.78 226.17,20.83 227.62,19.37 228.82,19.37 v2(229.11,19.08) 230.82,17.37 230.82,14.12 228.75,12.05 216.98,12.05 214.74,9.81 213.5,9.81 212.47,8.79 JKB.23
JKSI8: length 50.5
  TOP w0.107: v1(227.9,8.53) 227.9,9.93 231.63,13.66 232.44,13.66 233.64,14.85 236.6,14.85 v2(236.76,15.02) 236.76,16.07 236.23,16.61 235.33,16.61 234.94,16.22 v1(234.94,15.53)
  IN1 w0.097: v1(212.97,6.57) 213.23,6.57 214.61,7.94 227.31,7.94 v1(227.9,8.53)
  BOTTOM w0.107: JKB.22 v1(212.97,6.57) ; RE396.1 237.22,30.35 238.43,29.14 238.43,20.8 234.94,17.31 v1(234.94,15.53)
JKSI9: length 40.5
  BOTTOM w0.107: JKB.21 213.47,8.9 214,9.43 215.51,9.43 215.81,9.73 215.81,10.28 v2(216.86,11.34) 217.34,11.82 228.85,11.82 231.06,14.03 231.06,17.09 232.23,18.26 232.23,19.64 231.98,19.89 231.98,30 232.32,30.35 232.32,31.69 232.84,32.2 RE399.1
JKSI10: length 48.5
  TOP w0.107: v1(234.34,15.54) 234.34,16.12 235.07,16.84 236.33,16.84 237.1,16.07 237.1,14.88 236.84,14.62 235.97,14.62 235.75,14.4 235.75,13.86 235.53,13.64 v2(235.06,13.64) 233.34,13.64 232.99,13.29 231.64,13.29 228.48,10.13 v1(228.48,8.53)
  IN1 w0.097: v1(213.97,6.57) 213.97,6.99 214.7,7.72 227.67,7.72 v1(228.48,8.53)
  BOTTOM w0.107: v1(234.34,15.54) 234.34,17.04 238.19,20.89 238.19,26.2 237.28,27.11 RE476.1 ; JKB.20 v1(213.97,6.57)
JKSI11: length 36.3
  BOTTOM w0.107: JKB.19 214.47,8.82 214.83,9.18 215.59,9.18 216.04,9.63 216.04,9.91 217.72,11.58 228.94,11.58 231.29,13.93 231.29,16.73 v2(232.36,17.81) 232.46,17.91 232.46,19.74 232.22,19.99 232.22,28.46 232.72,28.96 RE480.1
JKSI12: length 45.3
  TOP w0.107: v1(233.76,15.53) 233.76,16.04 234.79,17.07 236.42,17.07 237.33,16.16 237.33,14.65 235.99,13.31 233.4,13.31 v2(232.99,12.9) 231.59,12.9 229.07,10.39 v1(229.07,8.53)
  IN1 w0.097: v1(214.97,6.57) 214.97,7.03 215.43,7.49 228.04,7.49 v1(229.07,8.53)
  BOTTOM w0.107: RE482.1 237.96,22.65 237.96,20.99 233.76,16.79 v1(233.76,15.53) ; JKB.18 v1(214.97,6.57)
JKSI13: length 32.4
  BOTTOM w0.107: RE486.1 232.78,25.72 232.45,25.39 232.45,20.08 232.7,19.83 232.7,17.17 231.52,15.99 231.52,13.83 229.04,11.35 218.08,11.35 217.18,10.45 217.18,9.76 v2(216.89,9.47) 216.38,8.96 215.71,8.96 215.47,8.72 JKB.17
JKSI14: length 41.7
  TOP w0.107: v1(233.17,15.53) 233.17,16.04 234.44,17.31 236.52,17.31 237.56,16.26 237.56,14.56 236.08,13.07 233.63,13.07 233.13,12.57 231.62,12.57 229.67,10.62 v2(229.67,9.47) v1(229.67,8.53)
  IN1 w0.097: v1(229.67,8.53) 228.42,7.27 216.29,7.27 215.97,6.95 v1(215.97,6.57)
  BOTTOM w0.107: v1(233.17,15.53) 233.17,16.54 236.74,20.1 RE488.1 ; JKB.16 v1(215.97,6.57)
JKSI15: length 28.4
  BOTTOM w0.107: RE492.1 232.8,22.49 232.68,22.37 232.68,20.18 232.93,19.93 232.93,16.93 v2(232.01,16) 231.76,15.75 231.76,13.74 229.14,11.12 218.18,11.12 217.41,10.35 217.41,9.47 216.47,8.53 JKB.15
JKSI16: length 36.1
  TOP w0.107: RE495.1 232.64,30 232.64,28.91 232.38,28.64 232.38,18.68 231.62,17.92 228.19,17.92 223.16,12.89 223.16,8.7 222.8,8.35 219.46,8.35 v2(219.4,8.29) 218.75,8.29 v1(216.97,6.51)
  BOTTOM w0.107: JKB.14 v1(216.97,6.51)
JKSI17: length 41.8
  TOP w0.107: RE498.1 237.63,32.2 237.9,31.94 237.9,22.54 231.17,15.82 228.45,15.82 v2(226.55,13.91) 225.51,12.87 225.51,9.91 v1(225.1,9.5)
  BOTTOM w0.107: JKB.13 217.47,8.88 217.65,9.06 217.65,10.25 218.28,10.88 224.24,10.88 225.1,10.01 225.1,9.5 v1(225.1,9.5)
JKSI18: length 32
  TOP w0.107: v1(217.97,6.51) 218.32,6.51 219.93,8.12 222.9,8.12 223.39,8.61 223.39,12.79 227.84,17.24 v2(230.26,17.24) 231.27,17.24 232.61,18.58 232.61,26.73 RE502.1
  BOTTOM w0.107: v1(217.97,6.51) JKB.12
JKSI19: length 36.6
  TOP w0.107: v1(224.59,9.86) 225.18,10.45 v2(225.18,12.61) 225.18,13.59 227.64,16.05 231.07,16.05 237.43,22.4 237.43,28.31 236.78,28.96 RE503.1
  BOTTOM w0.107: JKB.11 218.47,8.71 217.88,9.3 217.88,10.15 218.37,10.65 223.81,10.65 v1(224.59,9.86)
JKSI20: length 28
  TOP w0.107: v1(218.97,6.57) 220.29,7.88 223,7.88 223.63,8.51 223.63,12.7 227.73,16.8 v2(228.35,16.8) 231.16,16.8 232.88,18.52 232.88,23.76 RE507.1
  BOTTOM w0.107: JKB.10 v1(218.97,6.57)
JKSI21: length 30.7
  TOP w0.107: RE510.1 236.89,25.79 237.14,25.54 237.14,22.44 230.97,16.28 227.54,16.28 224.75,13.48 v2(224.75,10.7) 224.75,10.6 224.03,9.88 v1(224.03,9.55)
  BOTTOM w0.107: v1(224.03,9.55) 224.03,9.75 223.37,10.42 221.02,10.42 220.76,10.16 220.76,9.62 219.47,8.33 JKB.9
JKSO0: length 61.2
  TOP w0.107: v1(219.97,6.51) v2(220.54,7.08) 221.11,7.65 224,7.65 225.75,9.4 225.75,12.35 228.98,15.58 231.27,15.58 238.13,22.45 238.13,32.03 235.81,34.35 232.88,34.35 231.94,33.41 231.94,29.2 231.53,28.78 231.53,26.63 231,26.1 230.59,26.1 230.39,25.9 230.39,25.55 230.28,25.45 QE49.6 228.69,25.45 228.5,25.26 228.5,23.8 228.12,23.42 227.17,23.42 227.15,23.44 226.95,23.44 226.79,23.6 226.79,23.61 226.7,23.69 226.7,24.48 226.51,24.67 226.08,24.67 225.94,24.53 QE54.6
  BOTTOM w0.107: v1(219.97,6.51) JKB.8
JKSO1: length 30
  TOP w0.107: v1(221.18,9.9) v2(221.18,11.78) 221.18,12.9 226.7,18.42 226.7,20.25 226.28,20.67 QE50.6 225.94,19.84 225.63,19.53 222.06,19.53 221.56,20.03 221.56,21.28 222.36,22.08 222.36,22.43 222.95,23.02 222.95,25.7 223.25,26 223.55,26 223.8,26.26 224.54,26.26 224.64,26.15 QE54.3
  BOTTOM w0.107: JKB.7 220.47,8.78 221.18,9.49 v1(221.18,9.9)
JKSO2: length 59.3
  TOP w0.107: v1(220.97,6.57) 221.69,7.29 224.5,7.29 224.84,7.63 v2(224.84,7.87) 224.84,8.07 225.98,9.21 225.98,9.97 238.36,22.35 238.36,32.13 235.64,34.86 230.6,34.86 230.36,34.62 230.36,34.28 230.66,33.98 230.98,33.98 231.47,33.48 231.47,29.81 230.99,29.33 230.58,29.33 230.39,29.14 230.39,28.8 230.28,28.69 QE51.6 229.3,29.31 228.74,29.31 228.61,29.18 228.61,27.02 228.29,26.7 226.89,26.7 226.48,27.11 QE55.6
  BOTTOM w0.107: v1(220.97,6.57) JKB.6
JKSO3: length 76.6
  TOP w0.107: QE55.3 224.64,29.34 224.48,29.5 223.27,29.5 222.86,29.91 222.86,32.51 224.42,34.07 229.15,34.07 230.4,35.33 235.83,35.33 238.83,32.33 238.83,22.13 232.17,15.47 v2(232.17,14.76) v1(232.17,14.07) ; QE52.6 229.64,22.21 229.42,21.99 229.42,21 228.78,20.35 227.97,20.35 227.46,19.85 227.46,18.85 221.81,13.2 221.81,9.9 v1(221.81,9.9)
  BOTTOM w0.107: v1(232.17,14.07) 232.17,13.81 229.24,10.88 226.15,10.88 225.51,10.24 225.51,9.33 225.27,9.08 223.92,9.08 223.63,9.38 223.63,9.71 223.45,9.89 221.82,9.89 v1(221.81,9.9) 221.81,9.89 221.47,9.55 JKB.5
JKSO4: length 56
  TOP w0.107: QE56.6 224.54,29.81 224.67,29.69 226.04,29.69 226.29,29.94 227.91,29.94 228.1,29.75 229.15,29.75 229.42,30.02 229.42,31.77 229.58,31.92 QE53.6 229.92,34.51 230.5,35.09 235.73,35.09 238.6,32.23 238.6,22.25 226.21,9.87 226.21,9 225.68,8.47 225.68,7.68 224.91,6.91 v2(223.3,6.91) 222.32,6.91 v1(221.97,6.57)
  BOTTOM w0.107: v1(221.97,6.57) JKB.4
JRTC1: length 4.3
  BOTTOM w0.107: PR2.1 283.38,34.89 283.31,34.82 v2(282.79,34.82)
  BOTTOM w0.254: PD5.2 283.24,32.26 283.52,32.54 283.52,33.83 283.74,34.04 PR2.1
JTAG_TCK: length 1.5
  TOP w0.089: v1(228.58,95.15) 228.58,95.57 TV5.1
  BOTTOM w0.1: UG1.AF30 228.57,94.85 228.57,95.15 v1(228.58,95.15)
JTAG_TDI: length 2.1
  TOP w0.089: v1(228.57,97.4) 229.37,97.4 TV3.1
  BOTTOM w0.1: UG1.AD30 228.57,97.25 v1(228.57,97.4)
JTAG_TDO: length 1.7
  TOP w0.089: v1(227.77,97.4) 227.49,97.68 227.22,97.68 TV2.1
  BOTTOM w0.1: UG1.AD31 227.77,97.25 v1(227.77,97.4)
JTAG_TMS: length 1.5
  TOP w0.089: v1(227.77,96.2) 227.38,95.81 TV4.1
  BOTTOM w0.1: UG1.AE31 227.77,96.05 v1(227.77,96.2)
JTAG_TRSTB: length 39.3
  TOP w0.089: 216.73,112.24 216.45,112.52 216.45,112.54 216.18,112.81 RG8.1 ; 216.04,112.81 215.65,112.81
  TOP w0.107: v1(211.08,112.24) 211.65,112.81 215.65,112.81 ; 216.04,112.81 RG8.1 215.59,113.38 TV7.1 ; RG397.1 216.73,112.24
  IN2 w0.091: v1(210.57,102.81) 210.57,103.79 210.89,104.11 210.89,112.05 v1(211.08,112.24)
  IN3 w0.091: v1(228.57,98.6) 227.86,97.89 217.62,97.89 217.39,98.11 v1(217.12,98.11)
  BOTTOM w0.089: 215.65,98.11 v1(217.12,98.11)
  BOTTOM w0.1: v1(228.57,98.6) 228.57,98.45 UG1.AC30
  BOTTOM w0.107: 215.65,98.11 215.64,98.11 213.74,100.02 213.74,100.66 213.57,100.82 212.08,100.82 211.75,101.16 211.75,101.97 211.5,102.21 211.17,102.21 v1(210.57,102.81)
KB_LED_B1_DRV#: length 24.9
  TOP w0.107: v1(168.8,9.91) 168.8,12.85 174.99,19.03 181.74,19.03 181.84,18.93 v2(182.06,18.93) 183.48,18.93 184.24,19.69 UE4.5
  BOTTOM w0.107: v1(168.8,9.91) 167.82,8.93 JKBBL.5
KB_LED_B2_DRV#: length 32
  TOP w0.107: v1(166.32,6.57) 166.32,6.57 166.82,6.07 170.3,6.07 170.84,6.61 170.84,9.22 v2(170.13,9.94) 170.13,10.03 169.68,10.48 169.68,12.73 175.08,18.13 183.51,18.13 183.7,17.94 184.82,17.94 184.87,17.89 186,17.89 186.1,17.78 UE4.9
  BOTTOM w0.107: JKBBL.8 v1(166.32,6.57)
KB_LED_B3_DRV#: length 32.8
  TOP w0.107: UE4.14 188.6,16.67 188.09,16.15 184.67,16.15 183.72,17.11 176.9,17.11 v2(176.8,17.2) 176.67,17.33 175.27,17.33 170.57,12.63 170.57,11.22 170.92,10.87 v1(170.92,10.14)
  BOTTOM w0.107: JKBBL.11 164.82,8.89 166.97,11.04 170.4,11.04 170.92,10.52 v1(170.92,10.14)
KB_LED_B4_DRV#: length 40.1
  TOP w0.107: v1(163.32,6.57) 164.53,5.36 170.66,5.36 171.69,6.39 v2(171.69,12.16) 171.69,12.61 175.48,16.4 183.43,16.4 184.69,15.15 188.54,15.15 190.78,17.39 190.78,17.59 190.89,17.69 190.89,18.1 190.8,18.19 UE4.17
  BOTTOM w0.107: JKBBL.14 v1(163.32,6.57)
KB_LED_B5_DRV#: length 270.1
  TOP w0.107: v1(290.94,39.92) 290.43,40.43 282.08,40.43 v2(281.08,39.43) 278.2,36.56 278.2,32.45 277.63,31.88 277.63,31.27 277.35,30.99 277.35,27.06 v1(277.7,26.71)
  IN2 w0.091: v1(73.45,16.72) 79.82,16.72 80.71,17.6 80.71,18.49 81.06,18.85 96.68,18.85 98.31,20.48 101.33,20.48 101.58,20.23 118.17,20.23 120.41,22.47 168.63,22.47 177.18,31.02 193.21,31.02 194.97,32.78 197.54,32.78 198.71,33.95 202.9,33.95 203.1,34.14 204.9,34.14 207.31,36.55 208.55,36.55 209.11,36 209.41,36 210.11,36.69 211.37,36.69 211.81,37.13 211.81,37.43 213.15,38.78 215.77,38.78 216.24,38.31 216.24,37.07 216.73,36.57 218.3,36.57 218.9,35.97 218.9,34.82 220.48,33.24 222.98,33.24 224.78,35.04 224.78,35.54 225.13,35.89 231.19,35.89 231.83,35.26 233.75,35.26 234.13,34.88 239.67,34.88 239.84,35.05 256.88,35.05 265.14,26.79 275.79,26.79 276.34,26.23 277.21,26.23 v1(277.7,26.71)
  BOTTOM w0.107: v1(73.45,16.72) 73.99,16.19 73.99,10.59 73.21,9.81 73.21,7.13 72.84,6.76 64.72,6.76 64.43,7.05 JKB3.2 ; UE8.21 291.21,40.19 v1(290.94,39.92)
KB_LED_G1_DRV#: length 30.7
  TOP w0.107: UE4.4 184.41,20.19 183.48,19.26 180.97,19.26 180.87,19.36 v2(179.08,19.36) 178.63,19.36 178.54,19.26 174.89,19.26 168.35,12.72 168.35,9.79 168.76,9.37 169.29,9.37 169.35,9.31 169.99,9.31 170.38,8.93 170.38,7.4 170.1,7.12 168.73,7.12 v1(168.32,6.71)
  BOTTOM w0.107: JKBBL.4 v1(168.32,6.71)
KB_LED_G2_DRV#: length 26.3
  TOP w0.107: UE4.8 183.91,18.19 v2(183.78,18.33) 183.74,18.37 174.98,18.37 169.44,12.83 169.44,10.13 v1(169.62,9.96)
  BOTTOM w0.107: v1(169.62,9.96) 169.25,10.32 167.54,10.32 166.82,9.6 JKBBL.7
KB_LED_G3_DRV#: length 34.3
  TOP w0.107: UE4.11 187.1,16.57 186.92,16.39 184.77,16.39 183.82,17.34 178.74,17.34 v2(178.64,17.44) 178.51,17.57 175.17,17.57 170.33,12.73 170.33,11.13 170.51,10.95 170.51,9.97 171.08,9.41 171.08,6.51 170.4,5.83 166.06,5.83 v1(165.32,6.57)
  BOTTOM w0.107: JKBBL.10 v1(165.32,6.57)
KB_LED_G4_DRV#: length 32.4
  TOP w0.107: v1(171.21,11.49) 171.21,12.61 175.24,16.64 183.53,16.64 184.79,15.38 188.24,15.38 v2(188.81,15.95) 189.6,16.74 UE4.16
  BOTTOM w0.107: v1(171.21,11.49) 166.6,11.49 163.82,8.71 JKBBL.13
KB_LED_G5_DRV#: length 272.6
  TOP w0.107: v1(277.11,26.71) 277.11,31.08 277.31,31.29 277.31,31.89 277.97,32.55 277.97,36.88 v2(278.85,37.76) 281.75,40.66 290.86,40.66 v1(291.61,39.92)
  IN2 w0.091: v1(277.11,26.71) 276.6,27.22 265.33,27.22 257.06,35.49 239.66,35.49 239.48,35.32 234.31,35.32 233.93,35.69 232.01,35.69 231.37,36.33 224.95,36.33 224.34,35.72 224.34,35.22 222.8,33.68 220.66,33.68 219.6,34.74 219.6,37.56 218.93,38.23 217.46,38.23 217.24,38.46 217.24,38.84 216.94,39.14 212.91,39.14 211.59,37.81 208.61,37.81 208.36,38.06 207.67,38.06 207.1,37.5 207.1,36.86 204.75,34.5 202.95,34.5 202.75,34.31 198.56,34.31 197.94,33.69 195.26,33.69 193.03,31.46 177,31.46 168.44,22.9 120.23,22.9 117.99,20.66 101.8,20.66 101.45,21.02 98.09,21.02 96.35,19.29 80.88,19.29 80.27,18.67 80.27,17.78 79.64,17.16 74.66,17.16 v1(74.23,17.59)
  BOTTOM w0.107: v1(74.23,17.59) 74.72,17.1 74.72,10.66 73.68,9.62 73.68,6.88 73.05,6.26 64.21,6.26 63.93,5.97 JKB3.3 ; v1(291.61,39.92) 291.71,40.02 UE8.20
KB_LED_R1_DRV#: length 26.4
  TOP w0.107: UE4.3 184.58,20.69 183.39,19.5 181.07,19.5 180.87,19.7 178.5,19.7 178.3,19.5 174.79,19.5 167.9,12.61 v2(167.9,11.97) 167.9,9.49 168.43,8.96 v1(168.82,8.96)
  BOTTOM w0.107: JKBBL.3 v1(168.82,8.96)
KB_LED_R2_DRV#: length 30.5
  TOP w0.107: UE4.6 184.62,19.19 184.52,19.3 184.18,19.3 183.48,18.6 174.88,18.6 169.21,12.92 169.21,9.79 169.45,9.55 170.09,9.55 170.61,9.02 170.61,7.3 v2(169.91,6.6) 169.61,6.3 167.65,6.3 v1(167.32,6.63)
  BOTTOM w0.107: JKBBL.6 v1(167.32,6.63)
KB_LED_R3_DRV#: length 28.1
  TOP w0.107: v1(170.1,10.63) 170.06,10.67 170.06,12.78 175.08,17.8 v2(180.48,17.8) 180.55,17.8 180.65,17.71 183.78,17.71 184.87,16.62 186.45,16.62 186.6,16.77 UE4.10
  BOTTOM w0.107: JKBBL.9 165.82,8.93 167.52,10.63 v1(170.1,10.63)
KB_LED_R4_DRV#: length 36.9
  TOP w0.107: v1(164.32,6.57) 165.29,5.6 170.56,5.6 171.36,6.39 171.36,10.76 170.8,11.32 170.8,12.53 175.14,16.87 183.62,16.87 184.68,15.82 v2(185.11,15.82) 188.14,15.82 189.1,16.79 UE4.15
  BOTTOM w0.107: JKBBL.12 v1(164.32,6.57)
KB_LED_R5_DRV#: length 272.7
  TOP w0.107: v1(276.53,26.71) 276.76,26.95 v2(276.76,27.65) 276.76,31.1 277.05,31.39 277.05,31.96 277.71,32.62 277.71,37.1 281.51,40.9 291.22,40.9 v1(292.21,39.91)
  IN2 w0.091: v1(276.53,26.71) 276.17,26.71 275.88,27 265.23,27 256.97,35.27 239.75,35.27 239.58,35.1 234.22,35.1 233.84,35.48 231.92,35.48 231.28,36.11 225.04,36.11 224.56,35.63 224.56,35.13 222.89,33.46 220.57,33.46 219.38,34.65 219.38,35.74 218.37,36.75 216.81,36.75 216.42,37.14 216.42,38.39 215.85,38.96 213.08,38.96 211.74,37.62 208.54,37.62 208.29,37.88 207.74,37.88 207.28,37.42 207.28,36.78 204.82,34.32 203.03,34.32 202.83,34.13 198.63,34.13 198.02,33.51 195.39,33.51 193.12,31.24 177.09,31.24 168.53,22.69 120.32,22.69 118.08,20.45 101.71,20.45 101.42,20.73 98.12,20.73 96.45,19.07 80.97,19.07 80.49,18.58 80.49,17.69 79.73,16.94 74.05,16.94 v1(73.81,17.18)
  BOTTOM w0.107: JKB3.4 63.43,7.04 63.93,6.53 72.94,6.53 73.45,7.03 73.45,9.71 74.45,10.71 74.45,16.55 v1(73.81,17.18) ; UE8.19 v1(292.21,39.91)
KB_RST#: length 121.4
  TOP w0.089: v1(212.35,30.89) 211.42,31.83 v2(210.07,31.83) 209,31.83 RH518.1
  TOP w0.107: RE646.1 307.29,23.78 306.02,22.51 304.78,22.51 303.82,21.55 303.82,18.35 302.29,16.81 v1(302.29,15.46)
  IN2 w0.091: v1(302.29,15.46) 301.65,14.83 297.9,14.83 297.64,15.09 292.47,15.09 291.78,15.78 278.39,15.78 274.44,19.73 272.54,19.73 270.97,21.3 269.82,21.3 268.38,19.87 265.92,19.87 263.65,17.6 262.51,17.6 261.72,16.82 256.27,16.82 255.63,17.46 231.74,17.46 231.34,17.86 229.01,17.86 227.35,19.52 227.35,21.32 226.77,21.9 226.1,21.9 224.82,23.18 224.82,26.28 221.95,29.14 220.24,29.14 219.14,30.25 215.72,30.25 215.43,30.54 212.71,30.54 v1(212.35,30.89)
  BOTTOM w0.089: v1(212.35,30.89) 212.22,31.02 UH1.AT17
KSI0: length 250
  TOP w0.107: v1(282.34,36.77) 281.67,36.1 280.98,36.1 280.09,35.22 280.09,34.15 279.39,33.45 279.39,31.54 281.3,29.64 281.3,19.9 287.12,14.08 289.62,14.08 290.28,13.41 UE5.55 ; RE630.1 v1(143.26,9.86)
  IN1 w0.097: v1(221.62,47.87) 221.62,41.37 224.73,38.26 224.73,34.32 224.34,33.93 224.34,31.24 225.04,30.54 226.51,30.54 227.44,31.46 v1(229.02,31.46) 229.17,31.31 232.58,31.31 234.35,29.53 235.31,29.53 235.56,29.28 240.06,29.28 248.61,37.83 252.41,37.83 254.33,39.75 256.61,39.75 257.47,40.6 268.54,40.6 271.66,37.49 281.63,37.49 v1(282.34,36.77) ; v1(143.26,9.86) 145.39,11.98 145.39,36.76 v1(145.74,37.12)
  IN4 w0.097: v1(145.74,37.12) 145.74,37.12 147.95,39.33 178.05,39.33 178.81,40.1 181.12,40.1 184.39,43.37 184.39,51.59 183.7,52.28 183.7,56.93 187.39,60.62 193.28,60.62 194.61,61.94 195.84,61.94 197.11,60.67 205.06,60.67 206.74,58.99 208.43,58.99 209.68,57.73 209.68,55.91 211.96,53.63 211.96,52.49 214.72,49.72 219.77,49.72 v1(221.62,47.87)
  BOTTOM w0.107: v1(229.02,31.46) 228.56,31.92 QE42.3 228.04,32.78 RE469.2
KSI0_R: length 7.9
  TOP w0.107: v2(140.09,6.26) 141.33,7.5 v1(141.47,7.5) 142.47,8.5 RE630.2
  BOTTOM w0.107: JKB2.5 141.38,7.59 v1(141.47,7.5) 141.38,7.41 JKB2.6
KSI1: length 246.4
  TOP w0.107: RE632.1 v1(144.53,9.86) ; v1(281.72,36.77) 281.28,36.34 280.88,36.34 279.71,35.17 279.71,34.1 279.16,33.54 279.16,31.45 281.07,29.54 281.07,19.8 287.03,13.85 289.43,13.85 290.27,13.01 UE5.56
  IN1 w0.097: v1(220.94,47.85) 220.94,41.74 224.51,38.17 224.51,34.41 224.12,34.02 224.12,31.15 224.95,30.32 226.77,30.32 227.33,30.88 v1(229.02,30.88) 229.22,31.08 232.48,31.08 234.26,29.31 235.21,29.31 235.47,29.05 240.15,29.05 248.7,37.6 270.03,37.6 270.86,36.77 v1(281.72,36.77) ; v1(144.53,9.86) 145.83,11.15 145.83,34.73 146.38,35.27 v1(146.38,37.12)
  IN4 w0.097: v1(220.94,47.85) 219.28,49.5 214.63,49.5 211.74,52.4 211.74,53.54 209.46,55.81 209.46,57.64 208.33,58.77 206.65,58.77 204.96,60.45 197.02,60.45 195.75,61.72 194.7,61.72 193.37,60.39 187.48,60.39 184.62,57.53 184.62,43.28 181.21,39.87 178.9,39.87 178.14,39.11 149.03,39.11 147.04,37.12 v1(146.38,37.12)
  BOTTOM w0.107: RE470.2 229.98,32.71 229.45,32.18 229.45,31.87 229.42,31.84 229.42,31.29 v1(229.02,30.88) 229.27,30.62 QE42.6
KSI1_R: length 6.5
  TOP w0.107: 143.53,7.5 RE632.2 ; 143.53,7.5 143.56,7.5 143.67,7.39 v2(143.67,6.38) ; 143.53,7.5 v1(143.47,7.5)
  BOTTOM w0.107: JKB2.10 143.38,7.41 v1(143.47,7.5) 143.38,7.59 JKB2.9
KSI2: length 241.1
  TOP w0.107: RE634.1 v1(145.87,9.86) ; v1(279.2,34.9) 279.2,34.57 278.93,34.3 278.93,31.35 280.83,29.44 280.83,19.71 286.93,13.61 289.34,13.61 290.34,12.61 UE5.57
  IN1 w0.097: v1(279.2,34.9) 278.36,35.74 265.17,35.74 264.01,36.9 248.95,36.9 239.32,27.27 236.37,27.27 235.58,26.48 234.49,26.48 233.79,25.78 230.8,25.78 230.04,26.54 230.04,27.2 v1(229.02,28.23) 228.69,28.56 227.08,28.56 226.19,29.44 225.41,29.44 223.9,30.96 223.9,34.12 224.29,34.51 224.29,38.08 220.35,42.01 v1(220.35,47.85) ; v1(145.87,9.86) 146.28,10.27 146.28,34.55 147.27,35.53 147.27,36.67 v1(147.67,37.07)
  IN4 w0.097: v1(220.35,47.85) 218.92,49.28 214.54,49.28 211.51,52.3 211.51,53.44 209.24,55.72 209.24,57.55 208.24,58.54 206.55,58.54 204.87,60.23 196.93,60.23 195.66,61.49 194.79,61.49 193.47,60.17 187.57,60.17 184.84,57.44 184.84,43.19 181.3,39.65 179,39.65 178.23,38.89 149.48,38.89 v1(147.67,37.07)
  BOTTOM w0.107: v1(229.02,28.23) 228.56,28.69 QE41.3 228.04,29.54 RE464.2
KSI2_R: length 7.3
  TOP w0.107: v2(147.2,6.38) 146.5,7.08 145.74,7.08 145.47,7.35 v1(145.47,7.5) 145.87,7.9 RE634.2
  BOTTOM w0.107: JKB2.14 145.38,7.41 v1(145.47,7.5) 145.38,7.59 JKB2.13
KSI3: length 241.6
  TOP w0.107: RE635.1 v1(146.5,9.86) ; UE5.58 290.41,12.21 289.24,13.38 287.03,13.38 286.83,13.38 280.6,19.61 280.6,29.34 278.68,31.27 278.68,32.38 278.44,32.61 278.44,34.71 v1(278.61,34.88)
  IN1 w0.097: v1(147.67,36.42) 147.67,35.62 146.5,34.45 v1(146.5,9.86) ; v1(278.61,34.88) 277.97,35.52 275.46,35.52 274.62,34.67 265.92,34.67 263.92,36.68 249.04,36.68 239.41,27.05 236.46,27.05 235.67,26.26 234.58,26.26 233.88,25.56 230.71,25.56 229.82,26.45 229.82,26.84 v1(229.02,27.64) 228.33,28.33 226.99,28.33 226.1,29.22 225.01,29.22 223.67,30.56 223.67,34.25 224.06,34.64 224.06,37.99 219.27,42.77 v1(219.27,47.66)
  IN4 w0.097: v1(219.27,47.66) 217.89,49.05 214.45,49.05 211.29,52.21 211.29,53.35 209.01,55.63 209.01,57.45 208.15,58.32 206.46,58.32 204.78,60 196.83,60 195.56,61.27 194.89,61.27 193.56,59.95 187.66,59.95 185.06,57.34 185.06,43.09 181.4,39.42 179.09,39.42 178.33,38.66 149.91,38.66 v1(147.67,36.42)
  BOTTOM w0.107: RE463.2 229.98,29.41 229.42,28.85 229.42,28.05 v1(229.02,27.64) 229.27,27.39 QE41.6
KSI3_R: length 6.4
  TOP w0.107: v2(147.77,8.22) 147.05,7.5 v1(146.47,7.5) 146.5,7.53 RE635.2
  BOTTOM w0.107: JKB2.15 146.38,7.59 v1(146.47,7.5) 146.38,7.41 JKB2.16
KSI4: length 258.4
  TOP w0.107: RE633.1 v1(145.17,9.86) ; UE5.59 290.47,11.81 290.06,12.22 v4(289.7,12.22) 289.57,12.22 289.18,11.83 v1(289.18,11.65)
  IN1 w0.089: 218.95,42.08 219.18,41.85
  IN1 w0.097: v1(146.85,36.23) 146.85,35.44 146.06,34.64 146.06,10.74 v1(145.17,9.86) ; v1(218.64,47.66) 218.86,47.44 218.86,42.17 218.95,42.08 ; v1(285.63,34.02) 285.63,34.07 285.23,34.47 282.67,34.47 282.2,34 280.8,34 280.77,33.97 265.36,33.97 263.54,35.78 249.1,35.78 243.97,30.66 243.97,27.14 241.91,25.08 236.98,25.08 235.59,23.69 235.59,23.27 234.99,22.66 232.33,22.66 231.02,23.97 230.03,23.97 v1(229.02,24.99) 228.21,25.8 228.21,26.55 226.99,27.77 226.99,28.01 226.01,29 224.92,29 223.45,30.47 223.45,34.32 222.99,34.79 221.97,34.79 221.29,34.11 220.87,34.11 220.41,34.57 220.41,36.79 219.9,37.3 219.9,41.13 219.18,41.85
  IN4 w0.097: v1(146.85,36.23) 147.07,36.01 148.79,36.01 151.18,38.39 178.37,38.39 178.6,38.62 179.49,38.62 180.08,39.2 181.49,39.2 185.29,43 185.29,57.25 187.76,59.72 189.37,59.72 190.05,59.05 195.26,59.05 195.99,59.78 199.84,59.78 201.52,58.1 208.05,58.1 208.79,57.36 208.79,55.54 211.07,53.26 211.07,52.12 214.35,48.83 217.47,48.83 v1(218.64,47.66)
  BOTTOM w0.107: JEC.4 285.11,9.94 285.38,10.21 287.31,10.21 288.76,11.65 v1(289.18,11.65) 289.19,11.65 289.63,11.21 289.94,11.21 290.71,11.97 290.71,18.02 288.12,20.61 288.12,29.6 285.5,32.22 285.5,33.9 v1(285.63,34.02) ; RE459.2 227.99,26.25 227.99,25.5 QE40.3 228.56,25.45 v1(229.02,24.99)
KSI4_R: length 6.7
  TOP w0.107: v2(145.42,6.38) 145.42,6.64 144.56,7.5 v1(144.47,7.5) 145.17,8.2 RE633.2
  BOTTOM w0.107: JKB2.12 144.38,7.41 v1(144.47,7.5) 144.38,7.59 JKB2.11
KSI5: length 255.4
  TOP w0.107: v1(289.81,11.65) 290.06,11.65 290.3,11.41 UE5.60 ; v4(285.33,34.88) 285,34.55 v1(285,34.02) ; RE631.1 v1(143.9,9.86)
  IN1 w0.089: 219.18,41.53 218.64,42.07 218.64,42.08
  IN1 w0.097: v1(145.79,35.53) 145.61,35.35 145.61,11.57 v1(143.9,9.86) ; v1(285,34.02) 282.54,34.02 282.29,33.78 280.9,33.78 280.86,33.75 265.26,33.75 263.45,35.56 249.19,35.56 244.19,30.56 244.19,27.05 242,24.86 237.07,24.86 235.81,23.6 235.81,23.17 235.08,22.44 232.24,22.44 230.93,23.75 229.94,23.75 229.28,24.4 v1(229.02,24.4) 227.98,25.43 227.98,26.46 226.76,27.68 226.76,27.92 225.91,28.77 224.83,28.77 223.23,30.37 223.23,34.23 222.89,34.57 222.06,34.57 221.38,33.89 220.77,33.89 220.19,34.48 220.19,36.7 219.66,37.23 219.66,41.06 219.18,41.53 ; v1(217.91,47.66) 218.64,46.93 218.64,42.08
  IN4 w0.097: v1(217.91,47.66) 216.97,48.61 214.26,48.61 210.84,52.03 210.84,53.17 208.57,55.44 208.57,57.27 207.96,57.87 201.43,57.87 199.75,59.55 196.09,59.55 192.5,55.97 188.44,55.97 188.25,55.97 185.51,53.23 185.51,42.91 181.58,38.98 180.17,38.98 179.59,38.39 178.69,38.39 178.47,38.17 176.89,38.17 175.99,37.26 156.29,37.26 154.81,35.78 146.04,35.78 v1(145.79,35.53)
  BOTTOM w0.107: QE40.6 229.27,24.15 v1(229.02,24.4) 229.42,24.81 229.42,25.61 229.98,26.17 RE457.2 ; v1(285,34.02) 285,32.39 287.88,29.51 287.88,20.3 290.27,17.91 290.27,12.11 v1(289.81,11.65) 289.4,12.06 288.83,12.06 287.22,10.44 JEC.5
KSI5_R: length 7.1
  TOP w0.107: RE631.2 143.37,7.97 142.94,7.97 v1(142.47,7.5) 141.87,6.9 v2(141.87,6.32)
  BOTTOM w0.107: JKB2.7 142.38,7.59 v1(142.47,7.5) 142.38,7.41 JKB2.8
KSI6: length 105.9
  TOP w0.107: v4(287.33,30.94) 286.77,31.5 v1(286.77,32.23) ; UE5.61 290.13,11.01 289.95,11.2 289.54,11.2 v1(289.11,10.76)
  IN1 w0.097: v1(229.02,21.75) 233.46,21.75 234.58,20.63 234.83,20.63 236.7,22.49 237.68,22.49 239.15,23.96 242.37,23.96 245.09,26.68 245.09,30.19 249.56,34.67 263.08,34.67 264.89,32.85 275.13,32.85 276.07,31.91 276.98,31.91 277.92,32.85 279.57,32.85 280.52,31.91 283.66,31.91 284.38,32.63 286.37,32.63 v1(286.77,32.23)
  BOTTOM w0.107: v1(229.02,21.75) 228.5,21.75 QE39.3 228.04,23.06 RE452.2 ; JEC.2 285.24,8.94 286.01,9.72 287.48,9.72 288.53,10.76 v1(289.11,10.76) 289.52,10.35 289.92,10.35 291.17,11.61 291.17,18.21 288.66,20.72 288.66,30.98 287.41,32.23 v1(286.77,32.23)
KSI7: length 100.5
  TOP w0.107: v4(286.38,32.93) 286.14,32.68 v1(286.14,32.23) ; UE5.62 289.9,10.61 v1(289.75,10.76)
  IN1 w0.097: v1(286.14,32.23) 284.3,32.23 283.76,31.69 280.42,31.69 279.48,32.63 278.02,32.63 277.07,31.69 275.98,31.69 275.04,32.63 262.72,32.63 254.79,24.7 252.39,24.7 250.33,22.64 249.87,22.64 249.62,22.9 238.4,22.9 237.77,22.27 236.79,22.27 234.92,20.4 234.49,20.4 233.73,21.16 v1(229.02,21.16)
  BOTTOM w0.107: RE451.2 229.98,22.93 229.42,22.37 229.42,21.57 v1(229.02,21.16) 229.27,20.91 QE39.6 ; JEC.3 285.1,9.44 285.63,9.97 287.41,9.97 288.61,11.17 289.34,11.17 v1(289.75,10.76) 289.83,10.76 290.94,11.87 290.94,18.11 288.35,20.7 288.35,29.7 286.14,31.91 v1(286.14,32.23)
KSI8: length 75.8
  TOP w0.107: v1(282.99,32.93) 282.99,31.13 283.26,30.85 283.26,24.04 v2(283.3,24) 283.3,21.35 288.03,16.61 UE5.47
  IN3 w0.091: v1(282.99,32.93) 282.59,33.32 277.75,33.32 276.97,34.1 258.54,34.1 256.87,35.77 249.02,35.77 248.28,35.03 243.26,35.03 238.95,30.72 236.96,30.72 236.38,31.3 235.11,31.3 v1(234.95,31.46)
  BOTTOM w0.107: RE398.2 233.82,32.65 233.82,32.05 QE29.3 234.49,31.92 v1(234.95,31.46)
KSI9: length 77.3
  TOP w0.107: v1(282.4,32.92) 282.4,31.21 282.95,30.66 282.95,21.36 288.03,16.28 v2(288.04,16.28) 288.11,16.21 UE5.48
  IN3 w0.091: v1(234.95,30.88) 235.15,31.08 236.29,31.08 236.87,30.5 239.04,30.5 243.35,34.81 248.38,34.81 249.11,35.55 256.78,35.55 258.45,33.88 276.88,33.88 277.66,33.1 278.29,33.1 279.08,32.31 280.93,32.31 281.53,32.92 v1(282.4,32.92)
  BOTTOM w0.107: QE29.6 235.2,30.62 v1(234.95,30.88) 235.34,31.27 235.34,31.28 235.36,31.3 235.36,32.05 235.36,32.06 235.36,32.12 235.89,32.65 RE400.2
KSI10: length 79.8
  TOP w0.107: v1(282.31,35.27) 281.92,34.88 281.92,31.3 282.7,30.51 282.7,21.14 288.03,15.81 v2(289.76,15.81) UE5.49
  IN1 w0.097: v1(282.31,35.27) 281.39,36.19 265.35,36.19 264.16,37.38 248.79,37.38 239.64,28.23 v1(234.95,28.23)
  BOTTOM w0.107: v1(234.95,28.23) 234.49,28.69 QE43.3 233.95,29.54 RE475.2
KSI11: length 80.7
  TOP w0.107: UE5.50 288.1,15.41 282.47,21.05 282.47,30.41 281.64,31.25 281.64,35.2 v1(281.57,35.27)
  IN1 w0.097: v1(281.57,35.27) 280.87,35.97 265.26,35.97 264.07,37.16 248.89,37.16 239.37,27.64 v1(234.95,27.64)
  BOTTOM w0.107: RE477.2 235.89,29.47 235.36,28.94 235.36,28.06 235.34,28.04 235.34,28.04 v1(234.95,27.64) 235.2,27.39 QE43.6
KSI12: length 80.8
  TOP w0.107: UE5.51 287.99,15.01 v2(282.52,20.48) 282.24,20.76 282.24,30.32 281.41,31.15 281.41,34.85 v1(280.98,35.27)
  IN1 w0.097: v1(234.95,24.99) 236.25,24.99 236.89,25.62 238.3,25.62 249.13,36.45 263.82,36.45 265.83,34.45 279.31,34.45 280.14,35.27 v1(280.98,35.27)
  BOTTOM w0.107: RE481.2 233.95,26.3 QE44.3 234.49,25.45 v1(234.95,24.99)
KSI13: length 81.8
  TOP w0.107: v1(281,34.64) 281.11,34.52 281.11,31.11 282,30.22 282,20.53 v2(283.68,18.85) 287.75,14.78 290,14.78 290.16,14.61 UE5.52
  IN1 w0.097: v1(281,34.64) 280.55,34.2 265.77,34.2 263.73,36.23 249.23,36.23 238.39,25.4 236.98,25.4 235.98,24.4 v1(234.95,24.4)
  BOTTOM w0.107: QE44.6 235.2,24.15 v1(234.95,24.4) 235.34,24.8 235.34,24.8 235.36,24.82 235.36,25.64 235.89,26.17 RE483.2
KSI14: length 81.7
  TOP w0.107: v1(280.7,32.89) 280.7,31.19 281.77,30.12 281.77,20.29 v2(284.88,17.18) 287.51,14.55 289.9,14.55 290.23,14.21 UE5.53
  IN1 w0.097: v1(234.88,21.81) 235.39,21.81 236.37,22.8 236.51,22.94 237.49,22.94 238.96,24.41 242.19,24.41 244.64,26.86 244.64,30.38 249.37,35.11 263.27,35.11 265.08,33.3 280.29,33.3 v1(280.7,32.89)
  BOTTOM w0.107: v1(234.88,21.81) 234.49,22.21 QE45.3 233.95,23.06 RE487.2
KSI15: length 84.2
  TOP w0.107: v1(280.12,32.88) 280.12,31.44 281.53,30.03 281.53,20 287.22,14.31 289.8,14.31 290.3,13.81 UE5.54
  IN1 w0.097: v1(280.12,32.88) 279.92,33.08 277.83,33.08 276.89,32.13 276.17,32.13 275.22,33.08 264.99,33.08 263.17,34.89 249.47,34.89 244.86,30.29 244.86,26.77 242.28,24.19 239.06,24.19 237.59,22.72 236.61,22.72 236.46,22.57 235.12,21.23 v1(234.83,21.23)
  BOTTOM w0.107: QE45.6 235.15,20.91 v1(234.83,21.23) 235,21.4 235.05,21.4 235.36,21.71 235.36,22.4 235.89,22.93 RE489.2
KSI16: length 73.8
  TOP w0.107: UE5.45 288.28,17.41 v2(285.67,20.02) 284.53,21.16 284.53,24.11 283.79,24.85 283.79,34.62 v1(283.13,35.27) ; QE46.3 235.85,32.36 235.89,32.4 RE493.2 236.01,32.99 v1(236.43,32.99)
  IN3 w0.091: v1(283.13,35.27) 282.68,35.72 278.15,35.72 277.74,36.14 258.18,36.14 257.36,36.96 248.53,36.96 247.79,36.22 239.67,36.22 v1(236.43,32.99)
KSI17: length 82.2
  TOP w0.107: QE46.6 234.32,30.62 234.51,30.81 234.51,31.62 v1(234.95,32.05) 234.63,32.05 234.03,32.65 RE494.2 ; UE5.46 288.13,17.01 284.29,20.85 284.29,24.02 283.55,24.76 283.55,34.17 282.72,35 282.72,35.85 282.93,36.06 v1(282.93,36.77)
  IN1 w0.097: v1(234.95,32.05) 242.51,32.05 248.52,38.05 252.32,38.05 254.24,39.97 256.52,39.97 257.37,40.83 268.64,40.83 271.75,37.71 281.99,37.71 v1(282.93,36.77)
KSI18: length 88.3
  TOP w0.107: v1(299.51,9.43) 299.54,9.4 UE5.81 ; QE47.3 235.85,29.12 235.89,29.16 RE500.2 236.01,29.75 v1(236.43,29.75) ; v2(290.31,29.6) 290.8,29.6 v1(290.84,29.64)
  IN3 w0.091: v1(236.43,29.75) 236.83,30.15 239,30.15 243.44,34.6 248.47,34.6 249.19,35.32 256.7,35.32 258.36,33.66 276.79,33.66 278.11,32.34 278.68,32.34 279.49,31.53 287.13,31.53 289.02,29.64 v1(290.84,29.64)
  BOTTOM w0.107: v1(290.84,29.64) 290.75,29.55 290.75,21.9 292.02,20.63 292.02,13.52 294.01,11.53 295.82,11.53 296.63,10.72 298.22,10.72 v1(299.51,9.43)
KSI19: length 94.4
  TOP w0.107: v2(290.48,31.4) 291.29,30.6 v1(291.29,29.24) ; RE499.2 234.03,29.34 234.45,28.92 234.83,28.92 v1(234.95,28.81) 234.51,28.38 234.51,27.58 234.32,27.39 QE47.6 ; UE5.82 299.94,9.07 299.92,9.09 299.92,9.63 299.54,10.01 v1(299.51,10.01)
  IN3 w0.091: v1(234.95,28.81) 237.96,28.81 243.53,34.38 248.56,34.38 249.28,35.1 256.61,35.1 258.27,33.44 275.75,33.44 277.07,32.12 278.58,32.12 279.4,31.31 286.78,31.31 288.85,29.24 v1(291.29,29.24)
  BOTTOM w0.107: v1(291.29,29.24) 290.99,28.93 290.99,21.99 292.25,20.73 292.25,13.62 294.11,11.76 295.92,11.76 296.72,10.95 298.6,10.95 299.51,10.04 v1(299.51,10.01)
KSI20: length 93.4
  TOP w0.107: v1(300.45,9.48) 300.62,9.48 301.14,8.96 UE5.85 ; v1(293.98,26.48) 294.17,26.67 294.17,27.19 293.59,27.77 v2(293.05,27.77) ; v1(236.43,26.45) 235.95,26.45 RE505.2 235.89,25.94 235.85,25.9 QE48.3
  IN3 w0.091: v1(293.98,26.48) 293.16,26.48 290.98,28.66 289.13,28.66 286.69,31.09 277.79,31.09 275.66,33.22 258.18,33.22 256.52,34.88 249.37,34.88 248.65,34.16 243.62,34.16 236.43,26.97 v1(236.43,26.45)
  BOTTOM w0.107: v1(300.45,9.48) 299.95,9.98 299.95,10.18 298.95,11.18 296.82,11.18 296.01,11.99 294.21,11.99 292.49,13.71 292.49,24.99 v1(293.98,26.48)
KSI21: length 96.3
  TOP w0.107: RE506.2 234.03,26.11 234.45,25.69 234.83,25.69 v1(234.95,25.57) 234.51,25.14 234.51,24.34 234.32,24.15 QE48.6 ; v2(301.33,6.22) 301.33,6.65 301.54,6.86 UE5.86 301.54,9.21 300.68,10.06 v1(300.45,10.06)
  IN3 w0.091: v1(293.98,25.88) 293.45,25.88 290.89,28.44 289.04,28.44 286.6,30.87 277.7,30.87 275.57,33 258.09,33 256.43,34.66 249.46,34.66 248.74,33.94 246.33,33.94 237.96,25.57 v1(234.95,25.57)
  BOTTOM w0.107: v1(300.45,10.06) 300.4,10.06 299.04,11.42 296.92,11.42 296.11,12.23 294.3,12.23 292.72,13.81 292.72,24.62 v1(293.98,25.88)
KSO0: length 89.9
  TOP w0.107: UE5.39 288.58,19.81 285.7,22.7 285.7,26.83 284.81,27.72 284.81,32.23 286.04,33.46 286.04,35.05 284.74,36.35 284.74,38.22 v1(284.52,38.45) ; v1(233.05,33.94) 232.38,33.26 232.38,30.42 232.18,30.22 232.18,29.1 231.76,28.69 231.76,26.29 231.2,25.72 RE513.1
  IN1 w0.097: v1(284.52,38.45) 284.01,37.94 283.27,37.94 282.83,38.38 272.03,38.38 268.91,41.5 257.1,41.5 256.24,40.64 253.96,40.64 253.49,40.18 244.19,40.18 238.4,34.39 233.5,34.39 v1(233.05,33.94)
