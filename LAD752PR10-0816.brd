# Allegro board LAD752PR10-0816.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PCH_AZ_BITCLK: length 29
  TOP w0.107: v1(224.42,17.98) 222.89,16.45 220.64,16.45 220.04,15.84 RP2.5
  IN1 w0.097: v1(214.59,35.17) 215.02,35.17 216.85,33.33 218.74,33.33 219.46,32.61 219.46,28.98 223.95,24.5 223.95,18.45 v1(224.42,17.98)
  BOTTOM w0.089: UH1.BA9 214.61,35.2 214.64,35.17 v1(214.59,35.17)
PCH_AZ_CODEC_BITCLK: length 208.9
  TOP w0.107: v1(220.35,9.91) 220.35,9.93 220.04,10.25 RP2.4
  IN3 w0.091: v1(35.51,27.15) 35.32,26.96 35.32,25.67 35.85,25.14 37.83,25.14 38.15,24.83 38.77,24.83 39.28,24.32 39.28,20.92 45.98,14.22 50.07,14.22 51.33,12.96 53.7,12.96 54.03,12.63 62.63,12.63 63.17,12.08 68.63,12.08 69.66,11.05 93.18,11.05 93.95,11.82 103.36,11.82 104.87,10.32 109.45,10.32 109.58,10.45 121.29,10.45 122.63,11.78 122.63,12.48 123.04,12.89 147.68,12.89 148.84,14.05 185.23,14.05 188.91,10.37 192.32,10.37 194.26,8.43 205.48,8.43 206.46,9.41 220.04,9.41 220.35,9.72 v1(220.35,9.91)
  BOTTOM w0.107: RA2.1 36.89,27.65 36.23,28.31 UA1.13 35.21,28.31 35.06,28.16 35.06,27.59 v1(35.51,27.15)
PCH_AZ_CODEC_RST#: length 200.2
  TOP w0.107: v1(219.69,9.9) 219.69,9.9 219.54,10.06 v2(219.54,10.83) RP2.3
  IN3 w0.091: v1(219.69,9.9) 219.69,9.9 218.86,10.73 215.05,10.73 214.64,10.32 203.89,10.32 202.97,9.4 198.99,9.4 196.48,11.91 194.2,11.91 191.64,14.47 186.09,14.47 185.53,15.03 148.53,15.03 147.3,13.8 111.54,13.8 109.89,12.15 104.57,12.15 103.98,12.73 93.2,12.73 92.62,12.15 69.85,12.15 69,12.99 63.55,12.99 63,13.53 54.41,13.53 54.08,13.86 51.71,13.86 50.45,15.13 48.14,15.13 46.41,16.86 44.62,16.86 40.19,21.29 40.19,24.97 v1(38.93,26.23)
  BOTTOM w0.107: RA17.1 37.16,26 37.28,25.88 38.58,25.88 v1(38.93,26.23)
PCH_AZ_CODEC_RST#_R: length 4.8
  BOTTOM w0.107: UA1.15 34.82,26.65 34.94,26.53 35.14,26.53 35.2,26.58 35.99,26.58 36.13,26.44 36.64,26.44 36.84,26.64 37.6,26.64 37.74,26.5 RA17.2 38.25,26.25 v2(38.64,26.64)
PCH_AZ_CODEC_SDIN0: length 249.3
  IN1 w0.097: v1(218.32,37.69) 218.32,38.77 218.25,38.85 218.25,41.52 217.65,42.12 217.65,42.17 217.64,42.18 217.64,46.5 214.86,49.29 214.86,52.43 209.84,57.45 v1(206.38,57.45) ; v1(174.76,36.48) 176.35,34.89 176.35,34.26 179.21,31.4 v1(179.21,21.56)
  IN3 w0.091: v1(38.81,24.23) 38.81,20.72 42.99,16.54 v1(43.06,16.54)
  IN4 w0.097: v1(206.38,57.45) 206.18,57.65 201.34,57.65 199.65,59.33 196.18,59.33 192.59,55.75 188.35,55.75 185.73,53.13 185.73,42.81 181.67,38.75 180.26,38.75 179.68,38.17 178.99,38.17 177.86,37.04 176.84,37.04 176.28,36.48 v1(174.76,36.48) ; v1(179.21,21.56) 179.21,21.2 176.64,18.63 137.9,18.63 135.17,15.91 114.31,15.91 110.11,11.7 104.3,11.7 103.94,12.06 95.74,12.06 93.7,14.1 74.47,14.1 72.49,12.12 52.43,12.12 50.57,13.99 45.51,13.99 43.06,16.44 v1(43.06,16.54)
  BOTTOM w0.089: UH1.BE7 216.49,36.49 216.57,36.57 216.71,36.57 217,36.86 217.88,36.86 218.32,37.31 v1(218.32,37.69)
  BOTTOM w0.107: v1(38.81,24.23) 38.81,24.99 38.43,25.36 RA18.1
PCH_AZ_CODEC_SDOUT: length 203.6
  TOP w0.107: v1(218.39,9.91) 218.39,11.4 218.54,11.55 RP2.1
  IN3 w0.091: v1(218.39,9.91) 218.38,9.91 217.99,10.3 215.23,10.3 214.82,9.88 204.07,9.88 203.09,8.9 194.45,8.9 192.52,10.84 189.11,10.84 185.43,14.52 148.64,14.52 147.48,13.36 111.82,13.36 109.25,10.79 105.06,10.79 103.56,12.3 93.38,12.3 92.61,11.52 69.86,11.52 68.82,12.55 63.37,12.55 62.82,13.1 54.23,13.1 53.9,13.43 51.53,13.43 50.26,14.69 47.96,14.69 46.23,16.42 44.44,16.42 39.75,21.11 39.75,24.52 38.61,25.66 36.01,25.66 v1(35.72,25.94)
  BOTTOM w0.107: UA1.17 34.02,26.61 34.58,26.04 35.62,26.04 v1(35.72,25.94) 36.03,25.64 RA10.1
PCH_AZ_CODEC_SYNC: length 201.1
  TOP w0.107: RP2.2 219.04,13.13 218.99,13.09 v1(218.99,9.9)
  IN3 w0.091: v1(36.25,27.46) 36.26,27.46 37.84,25.88 38.7,25.88 39.97,24.61 39.97,21.2 44.53,16.64 46.32,16.64 48.05,14.91 50.35,14.91 51.62,13.65 53.99,13.65 54.32,13.32 62.91,13.32 63.46,12.77 68.91,12.77 69.76,11.93 92.71,11.93 93.29,12.51 103.89,12.51 104.48,11.93 110.08,11.93 111.73,13.58 147.39,13.58 148.62,14.81 185.44,14.81 186,14.26 191.55,14.26 194.11,11.69 196.39,11.69 198.9,9.18 203.06,9.18 203.98,10.1 214.73,10.1 215.14,10.51 218.38,10.51 v1(218.99,9.9)
  BOTTOM w0.107: UA1.14 36.02,27.91 36.25,27.68 v1(36.25,27.46)
PCH_AZ_RST#: length 33.4
  TOP w0.107: RP2.6 219.54,16.03 221.03,17.53 223.25,17.53 224.14,18.42 225.25,18.42 v1(225.69,17.98)
  IN1 w0.097: v1(225.69,17.98) 226.11,18.41 226.11,19.29 225.25,20.15 225.25,26.19 223.51,27.93 223.51,29.26 221.47,31.3 221.47,32.29 219.72,34.04 219.72,36.04 218.89,36.87 v1(218.89,36.87)
  BOTTOM w0.089: v1(218.89,36.87) 218.89,36.87 218.89,36.86 218.26,36.86 217.94,36.54 217.25,36.54 217.1,36.39 216.64,36.39 216.32,36.07 216.04,36.07 UH1.BD8
PCH_AZ_SDOUT: length 35.6
  TOP w0.097: RH16.2 214.83,37.33 214.83,36.95 214.99,36.8 215.51,36.8 v1(215.51,36.79)
  TOP w0.107: RP2.8 218.54,16.14 221.29,18.89 223.13,18.89 v2(223.44,19.2) 223.9,19.2 224,19.3 225.28,19.3 v1(225.69,18.89)
  IN1 w0.097: v1(215.51,36.79) 217.94,36.79 219.5,35.24 219.5,33.95 221.24,32.2 221.24,31.21 223.28,29.17 223.28,27.84 225.03,26.09 225.03,19.55 v1(225.69,18.89)
  BOTTOM w0.089: v1(215.51,36.79) 215.51,36.8 215.18,36.8 UH1.BB7
PCH_AZ_SYNC: length 30.7
  TOP w0.107: RP2.7 219.04,16.17 v2(220.8,17.94) 221.25,18.38 223.42,18.38 223.92,18.89 v1(225.08,18.89)
  IN1 w0.097: v1(225.08,18.89) 224.8,19.17 224.8,26 223.06,27.75 223.06,27.87 221.02,29.91 221.02,32.11 219.27,33.85 219.27,34.86 v1(218,36.13)
  BOTTOM w0.089: UH1.BD9 215.85,35.52 216.23,35.89 216.39,35.89 216.66,36.16 217.97,36.16 v1(218,36.13)
PCH_BATLOW#: length 174.2
  TOP w0.107: v1(170.52,161.83) 170.58,161.76 171.48,161.76 171.74,162.02 RT14.2
  IN1 w0.089: 212.34,42.08 212.34,40.98 212.12,40.76 212.12,38.09 211.81,37.78 211.81,35.54 212.64,34.7 214.64,34.7 215.17,34.17 v1(215.29,34.17)
  IN1 w0.097: v1(202.64,65.74) 202.64,64.8 202.83,64.61 202.83,64.61 202.99,64.45 202.99,57.72 202.65,57.38 202.65,55.52 203.23,54.93 203.23,53.91 204.05,53.1 206.8,53.1 209.54,50.35 209.54,45.45 212.34,42.65 212.34,42.08
  IN2 w0.091: v1(170.52,161.83) 170.45,161.76 170.25,161.76 169.74,161.26 169.74,160.81 168.56,159.63 168.56,157.63 168.8,157.38 168.8,155.92 170.38,154.34 170.79,154.34 172.53,152.6 177.32,152.6 177.5,152.78 185.21,152.78 185.8,152.19 188.79,152.19 190.47,150.51 190.47,149.35 195.73,144.08 195.73,112.09 192.81,109.17 192.81,104.8 191.39,103.38 191.39,74.54 191.52,74.4 192.07,74.4 193.68,72.79 193.68,72.42 200.33,65.77 202.6,65.77 v1(202.64,65.74)
  BOTTOM w0.089: 218.17,34.3 218.17,34.16 217.56,33.55 216.63,33.55 216.43,33.76 UH1.BD13 215.97,33.78 215.57,34.17 v1(215.29,34.17)
  BOTTOM w0.107: 218.17,34.3 218.43,34.56 218.89,34.56 219.16,34.3 219.16,33.42 219.59,32.99 RH515.1
PCH_CPU_BCLK_N: length 96.8
  IN1 w0.097: v1(187.65,57.87) 187.5,57.71 187.06,57.71 186.57,58.2 186.57,60.46 186.78,60.66 186.78,65.67 186.57,65.87 186.57,67.8 187.26,68.49 187.26,73.19 188.99,74.92 188.99,86.2 189.87,87.09 189.87,92.65 180.55,101.97 180.55,115.52 179.54,116.54 173.89,116.54 v1(173.63,116.81)
  BOTTOM w0.076: CPU1.A32 173.28,116.46 v1(173.63,116.81)
  BOTTOM w0.099: UH1.H2 198.11,39.07 198.11,39.21 198.19,39.29 198.19,40.27 197.72,40.74 197.72,42.02 197.72,42.02 197.72,42.1 197.72,42.1 v3(197.72,44.67) 197.72,47.2 190.13,54.79 190.13,57.33 189.74,57.71 187.81,57.71 v1(187.65,57.87)
PCH_CPU_BCLK_P: length 97.3
  IN1 w0.097: v1(187.65,57.28) 187.4,57.54 186.99,57.54 186.4,58.12 186.4,60.53 186.6,60.73 186.6,65.59 186.4,65.8 186.4,67.87 187.09,68.56 187.09,73.26 188.82,74.99 188.82,86.28 189.7,87.16 189.7,92.58 180.38,101.9 180.38,115.45 179.47,116.36 173.77,116.36 v1(173.63,116.22)
  BOTTOM w0.076: v1(173.63,116.22) 173.42,116.01 CPU1.B31
  BOTTOM w0.099: v1(187.65,57.28) 187.89,57.52 189.66,57.52 189.94,57.25 189.94,54.71 197.53,47.12 197.53,44.99 197.5,44.96 197.5,44.38 197.53,44.36 197.53,42.16 197.53,42.16 197.53,42.1 197.53,40.66 198,40.19 198,39.37 197.87,39.25 197.87,39.15 UH1.G2
PCH_CPU_PCIBCLK_N: length 100.9
  IN1 w0.097: v1(187.65,59.05) 187.49,58.88 187.35,58.88 187.22,59.01 187.22,59.88 187.43,60.08 187.43,63.75 187.91,64.24 187.91,72.92 189.64,74.65 189.64,85.93 190.55,86.85 190.55,92.89 181.2,102.24 181.2,116.14 179.84,117.51 175.74,117.51 174.42,118.82 171.51,118.82 171.38,118.62 171.09,118.56 v1(170.84,118.73)
  BOTTOM w0.076: CPU1.C36 170.84,118.73 v1(170.84,118.73)
  BOTTOM w0.099: UH1.J1 198.64,39.51 198.64,42.1 198.64,42.11 198.64,47.24 190.83,55.04 190.83,58.23 190.2,58.86 187.85,58.86 v1(187.65,59.05)
PCH_CPU_PCIBCLK_P: length 100.6
  IN1 w0.097: v1(187.65,58.46) 187.41,58.71 187.28,58.71 187.05,58.94 187.05,59.95 187.26,60.15 187.26,63.82 187.74,64.31 187.74,72.99 189.47,74.72 189.47,86.01 190.38,86.92 190.38,92.82 181.03,102.17 181.03,116.07 179.77,117.33 175.67,117.33 174.35,118.65 171.61,118.65 171.46,118.43 171.49,118.3 v1(171.61,118.22)
  BOTTOM w0.076: v1(171.61,118.22) 171.59,118.24 CPU1.D35
  BOTTOM w0.099: v1(187.65,58.46) 187.85,58.66 190.12,58.66 190.64,58.15 190.64,54.96 198.44,47.16 198.44,42.19 198.44,42.18 198.44,39.33 198.65,39.11 UH1.J2
PCH_DPWROK: length 143.9
  TOP w0.089: v4(211.1,34.44) 211.1,34.61 RH90.2 212.43,35.43 v1(212.68,35.19)
  TOP w0.107: v1(302.87,15.46) 302.87,16.82 304.24,18.18 304.24,21.37 304.68,21.81 UE5.127
  IN3 w0.091: v1(302.87,15.46) 302.87,17.59 301.95,18.52 301.95,20.13 302.69,20.87 302.69,22.06 300.91,23.83 293.49,23.83 290.31,27.02 283.14,27.02 281.54,28.63 276.89,28.63 276.6,28.33 265.93,28.33 262.73,25.14 259.07,25.14 257.54,23.61 253.23,23.61 251.15,21.53 251.15,21.23 249.45,19.53 245.83,19.53 245.57,19.27 242.38,19.27 241.34,20.3 233.81,20.3 232.19,21.93 229.73,21.93 229.29,22.37 227.08,22.37 226.45,23 226.45,24.08 225.57,24.96 225.57,27.41 225.12,27.87 225.12,31.11 v1(225.54,31.53)
  IN4 w0.097: v1(212.68,35.19) 212.35,34.86 212.35,33.5 213.24,32.61 216.29,32.61 216.96,31.94 219.35,31.94 219.95,31.34 219.95,31.08 220.25,30.78 224.02,30.78 224.76,31.53 v1(225.54,31.53)
  BOTTOM w0.089: UH1.AV11 212.68,34.96 v1(212.68,35.19)
  BOTTOM w0.107: v1(225.54,31.53) 224.87,31.53 223.98,32.42 223.98,38.99 222.13,40.84 221.17,40.84 DE4.2
PCH_JTAG_TCK: length 222
  TOP w0.107: JPCMC.32 120.24,160.27 120.55,160.58 122.27,160.58 122.44,160.42 v1(122.44,160.01) 122.44,159.75 122.9,159.29 124.81,159.29 126.62,157.49 RC35.1 126.62,155.94 v4(127.39,155.16)
  IN2 w0.091: v1(130.69,112.22) 130.96,112.22 131.15,112.04 131.15,110.7 132.29,109.56 132.29,105.34 130.71,103.75 130.71,102.79 127.3,99.38 127.3,95.44 128.27,94.47 128.27,80.17 138.66,69.78 181.39,69.78 192.07,59.1 198.74,59.1 201.23,56.61 204.67,56.61 205.94,55.34 v1(205.94,54.52)
  IN3 w0.091: v1(205.94,54.52) 209.17,51.28 209.17,46.12 210.08,45.21 212.33,45.21 v1(213.05,44.5)
  IN4 w0.097: v1(122.44,160.01) 121.77,160.67 120.71,160.67 119.68,159.64 118.41,159.64 115.27,156.5 115.27,155.54 115.74,155.06 117.45,155.06 119.05,153.46 119.05,153.09 119.05,152.92 119.8,152.17 119.8,149.16 118.94,148.3 118.94,147.99 118.4,147.45 118.4,131.01 126.95,122.46 126.95,117.69 127.53,117.11 127.53,114.19 129.5,112.22 v1(130.69,112.22)
  BOTTOM w0.076: v1(130.69,112.22) 131.2,112.72 131.96,112.72 132.15,112.91 132.5,112.91 CPU1.BR28
  BOTTOM w0.089: 212.19,41.02 212.19,40.82 211.58,40.2 211.58,39.19 211.55,39.16 211.55,38.85 211.78,38.61 UH1.AR3
  BOTTOM w0.127: v1(213.05,44.5) 213.05,44.2 212.48,43.64 212.48,41.31 212.19,41.02
PCH_PECI: length 4.4
  BOTTOM w0.089: UH1.AL3 209.51,38.61 209.27,38.85 209.27,39.17 209.34,39.23 209.34,39.66 209.34,39.66 209.43,39.74 209.43,40.75 209.21,40.98 209.21,41.56 v2(209.2,41.57) 209.2,42 209.11,42.08
  BOTTOM w0.107: RH73.1 209.11,42.08
PCH_PLTRST#: length 214.9
  TOP w0.089: UH3.2 214.77,23.39 214.89,23.27 215.34,23.27 215.42,23.36 UH3.1 215.42,24.07 215.71,24.35 v2(217.18,24.35) v1(218,24.35)
  IN1 w0.097: v1(202.32,94.34) 202.72,93.94 202.72,89 200.76,87.03 200.76,80.7 200.34,80.29 200.34,74.89 199.46,74.01 199.46,70.17 196.06,66.77 196.06,62.86 194.43,61.22 194.43,60.81 192.61,59 192.61,50.63 196.05,47.19 196.05,41.88 198.72,39.21 202.63,39.21 203.81,38.03 203.81,31.97 204.84,30.95 207.28,30.95 208.1,30.13 208.84,30.13 209.03,29.94 209.03,29.57 209.35,29.24 209.82,29.24 210.01,29.05 210.01,28.34 211.6,26.75 214.88,26.75 215.07,26.57 215.07,26.45 216.47,25.05 217.31,25.05 v1(218,24.35)
  IN3 w0.091: v1(202.32,94.34) 201.16,95.51 201.16,98.14 198.97,100.33 198.97,105.61 197.53,107.04 195.1,107.04 191.65,110.5 191.65,110.65 190.02,112.29 190.02,117.06 190.7,117.74 192.33,117.74 194.64,120.05 194.64,148.34 191.08,151.9 191.08,152.48 187.99,155.56 185.13,155.56 184.97,155.4 181.96,155.4 181.32,156.04 181.32,156.74 180.83,157.23 175.12,157.23 174.82,156.94 173.73,156.94 173.58,157.09 171.69,157.09 171.69,157.09 171.1,157.09 170.72,157.46 170.72,158.6 170.44,158.88 169.53,158.88 165.36,163.05 165.36,164.46 165.55,164.64 165.55,165.91 165.35,166.11 164.54,166.11 163.06,167.59 163.06,168.99 v1(160.21,171.83)
  BOTTOM w0.089: UH1.BB27 215.34,27.17 215.89,27.17 216.03,27.32 217.01,27.32 218,26.33 v1(218,24.35)
  BOTTOM w0.107: v1(160.21,171.83) 160.47,172.09 UM3.2
PCH_PWR_EN: length 195
  TOP w0.107: RE74.1 310.65,13.53 v1(310.65,13.56) ; C268.1 197.96,64.06 v1(198.13,63.89) 198.28,64.04 U18.4 ; v1(224.97,39.75) 226.93,37.78 v2(231.49,37.78) 232.84,37.78 233.6,37.03 238.7,37.03 241.04,34.68 241.69,34.68 241.93,34.44 241.93,33.35 241.63,33.05 241.63,26.93 242.3,26.25 242.3,18.85 242.3,18.84 244.75,16.39 245.42,16.39 245.98,15.83 248.89,15.83 249.06,16 PR300.1
  IN3 w0.091: v1(310.65,13.56) 305.53,13.56 304.84,14.25 304.84,19.31 304.94,19.4 305.6,19.4 305.97,19.77 305.97,22.68 304.33,24.32 304.33,28.58 302.31,30.59 292.18,30.59 287.67,35.1 286.08,35.1 283.87,37.31 269.72,37.31 269.44,37.6 257.85,37.6 257.69,37.75 248.17,37.75 247.47,37.05 241.15,37.05 238.86,39.34 230.61,39.34 230.02,39.93 227.09,39.93 226.9,39.75 v1(224.97,39.75)
  BOTTOM w0.107: v1(224.97,39.75) 224.16,40.56 224.16,44.48 222.4,46.24 217.32,46.24 215.96,47.59 215.38,47.59 211.91,51.06 209.66,51.06 206.97,53.76 206.97,57.44 200.52,63.89 v1(198.13,63.89)
PCH_PWROK: length 106.3
  TOP w0.107: CE44.1 293.14,25.46 UE5.32 ; CE44.1 293.37,25.48 293.57,25.69 293.57,26.83 v1(293.76,27.02) ; CE44.1 RE75.1 v2(290.93,25.48)
  IN3 w0.091: v1(293.76,27.02) 293.76,27.33 291.03,30.07 289.7,30.07 287.14,32.63 284.4,32.63 283.32,33.71 277.97,33.71 277.19,34.49 258.71,34.49 257.03,36.17 248.86,36.17 248.12,35.43 240.9,35.43 237.62,32.15 235.56,32.15 235.18,32.53 234.17,32.53 233.59,31.95 230.74,31.95 230.13,32.56 227.07,32.56 226.3,33.33 225.13,33.33 v1(225.12,33.31)
  IN4 w0.097: v1(213.22,35.19) 212.73,34.7 212.73,33.94 212.99,33.69 215.21,33.69 215.56,33.33 219.3,33.33 220.47,32.16 223.51,32.16 224.66,33.31 v1(225.12,33.31)
  BOTTOM w0.089: UH1.AW11 213.65,34.67 213.22,35.1 v1(213.22,35.19)
  BOTTOM w0.107: DE3.2 223.36,40.77 224.8,39.33 224.8,33.63 v1(225.12,33.31)
PCH_RTCRST#: length 159.2
  TOP w0.089: v1(217.56,35.12) 217.56,35.53 217.75,35.72 218.83,35.72 218.95,35.84 v4(218.95,36.1) 218.95,36.4 218.86,36.49 217.76,36.49 217.24,35.97 216.95,35.97 RH84.2 216.24,37.06 216.43,37.25 216.43,39.73 216.68,39.99 v1(216.68,40.84) CH53.1
  TOP w0.107: v1(227.72,39.1) 228.34,38.48 235.07,38.48 236.03,37.51 238.9,37.51 240.85,35.56 263.61,35.56 266.76,38.71 278.31,38.71 282.13,42.53 282.13,45.02 282.71,45.6 287.7,45.6 292.17,41.13 QE5.1
  IN3 w0.089: 219.18,40.89 218.21,40.89 218.16,40.84 v1(216.68,40.84)
  IN3 w0.091: v1(227.72,39.1) 226.99,38.37 224.84,38.37 222.32,40.89 219.18,40.89
  IN4 w0.089: v1(217.56,35.12) 217.56,35.59 216.99,36.16 215.5,36.16 213.92,37.75 213.02,37.75 212.93,37.66 210.16,37.66 210.01,37.51 208.73,37.51 208.27,37.97 207.68,37.97 206.82,37.11 206.82,36.66 204.59,34.42 203.95,34.42 203.28,33.75 203.28,33.12 201.92,31.76 199.31,31.76 198.26,30.71 198.26,29.94 197.68,29.36 196.62,29.36 195.97,30.01 195.67,30.01 195.28,29.62 194,29.62 193.56,30.06 193.56,30.29 193.27,30.58
  IN4 w0.097: 193.27,30.58 192.07,31.78 189.59,31.78 189.05,32.32 189.05,33.18 188.71,33.52 185.02,33.52 181.44,29.94 v1(173.51,29.94)
  BOTTOM w0.089: v1(217.56,35.12) 217.37,34.93 216.39,34.93 216.25,34.8 215.64,34.8 UH1.BC10
  BOTTOM w0.107: v1(173.51,29.94) 173.51,32.18 174.35,33.03 CLRP1.1
PCH_RTCX1: length 8.9
  BOTTOM w0.089: 219.18,36.15 218.69,36.15 218.3,35.76 217.38,35.76 217.2,35.95 216.79,35.95 216.51,35.67 216.26,35.67 216.12,35.54 216.12,35.48 215.93,35.28 215.59,35.28 215.36,35.52 UH1.BC9
  BOTTOM w0.127: YH1.1 221.78,38.02 220.91,37.15 v2(220.58,37.15) 219.74,37.15 CH45.1 RH70.1 219.18,36.15
PCH_RTCX2: length 7.2
  BOTTOM w0.089: 219.18,35.53 v2(218.63,35.53) 217.45,35.53 217.03,35.11 216.31,35.11 216.24,35.03 UH1.BD10
  BOTTOM w0.127: 219.18,35.53 219.29,35.53 219.59,35.24 RH70.2 219.66,35.26 CH46.1 221.2,36.15 221.83,35.52 YH1.2
PCH_SATADET#: length 97.8
  TOP w0.356: RS8.1 123.16,10.17 122.37,10.95 v2(122.37,17.11) 122.37,17.75 v1(122.82,18.19)
  TOP w0.508: RH512.1 204.87,15.91 v1(204.97,16.01)
  IN2 w0.508: v1(204.97,16.01) 204.36,15.4 203.46,15.4 202.45,16.42 200.22,16.42 198.64,18 194.94,18 193.99,17.05 185.81,17.05 184.68,18.18 184.26,18.18 184.25,18.19 v1(122.82,18.19)
  BOTTOM w0.203: v1(204.97,16.01) 204.97,16.09 206.07,17.19 206.07,18.09 UH1.AD44
PCH_SMBCLK: length 125.8
  TOP w0.089: v1(214,17.24) 214.27,16.97 214.27,16.3 213.57,15.6 RH463.2
  TOP w0.107: v1(176.69,58.64) 178.09,57.25 179.27,57.25 181.81,59.79 v3(181.81,60.7) 181.81,62.01 185.88,66.08 185.88,67.72 185.43,68.17 184.14,68.17 183.9,68.41 US1.4
  IN1 w0.097: v1(189.86,12.53) 189.68,12.71 189.68,12.99 189.33,13.34 186.03,13.34 180.54,18.82 180.54,45.05 180.13,45.47 179.77,45.47 v1(179.65,45.59)
  IN4 w0.097: v1(176.69,58.64) 176.97,58.64 177.38,58.23 177.38,56.22 177.64,55.96 178.3,55.96 178.65,55.61 178.65,53.73 180.67,51.72 180.67,47.21 179.1,45.64 179.1,45.45 179.19,45.36 179.42,45.36 v1(179.65,45.59)
  BOTTOM w0.089: UH1.AW44 213.51,18.27 213.76,18.02 213.76,17.49 v1(214,17.24)
  BOTTOM w0.107: JDIMM1.253 v1(176.69,58.64) ; v1(179.65,45.59) 179.47,45.41 178.85,45.41 178.55,45.12 177.49,45.12 176.69,45.91 JDIMM2.253 ; v1(214,17.24) 214.23,17.01 214.23,16.57 214.6,16.2 215.3,16.2 215.59,15.91 215.59,15.51 215.97,15.13 215.97,13.05 214.44,11.53 210.63,11.53 209.05,9.95 204.41,9.95 200.15,5.68 191.46,5.68 189.69,7.46 189.69,10.17 189.82,10.3 JTP.15 189.82,11.9 189.69,12.03 189.69,12.36 v1(189.86,12.53)
PCH_SMBDATA: length 132.3
  TOP w0.089: RH462.2 214.32,16.1 214.45,16.22 214.45,17.11 v1(214.58,17.24) 214.58,17.62 214.7,17.74 v1(214.7,18.26)
  TOP w0.107: v1(176.74,53.37) 177.12,53.74 177.12,56.22 177.91,57.01 179.37,57.01 182.04,59.69 182.04,61.91 v3(183.75,63.62) 186.11,65.98 186.11,67.82 185.56,68.37 185.56,69.82 185.29,70.08 US1.6
  IN1 w0.097: v1(189.28,12.53) 189.41,12.67 189.41,12.67 189.46,12.72 189.46,12.89 189.24,13.11 185.94,13.11 180.32,18.73 180.32,44.96 180.03,45.24 179.88,45.24 v1(179.65,45.01)
  IN4 w0.097: v1(179.65,45.01) 179.52,45.14 179.09,45.14 178.87,45.36 178.87,45.74 180.44,47.3 180.44,51.63 178.43,53.64 178.43,55.52 178.21,55.74 177.64,55.74 177.45,55.55 177.45,54.07 v1(176.74,53.37)
  BOTTOM w0.089: UH1.BB43 214.7,18.58 v1(214.7,18.26)
  BOTTOM w0.107: v1(214.58,17.24) 214.43,17.09 214.43,16.65 214.68,16.39 215.38,16.39 215.78,15.99 215.78,15.59 216.2,15.17 216.2,12.96 214.54,11.29 210.72,11.29 209.14,9.71 204.51,9.71 200.24,5.45 191.36,5.45 189.45,7.36 189.45,10.17 189.32,10.3 JTP.16 189.32,11.9 189.45,12.03 189.45,12.36 v1(189.28,12.53) ; JDIMM2.254 176.94,40.18 176.95,40.18 176.95,40.49 177.32,40.87 177.32,43.21 177.6,43.48 177.6,44.8 177.68,44.88 178.65,44.88 178.95,45.17 179.48,45.17 v1(179.65,45.01) ; v1(176.74,53.37) 176.94,53.16 JDIMM1.254
PCH_SPI_CLK: length 14.9
  BOTTOM w0.107: UH4.6 226.3,16.66 226.19,16.77 226.19,17.39 226.09,17.49 225.87,17.49 225.77,17.39 225.77,17.02 225.66,16.92 225.45,16.92 225.34,17.02 225.34,17.47 225.23,17.57 225.02,17.57 224.91,17.47 224.91,17.02 224.81,16.92 224.54,16.92 224.43,17.02 224.43,17.45 224.33,17.56 224.11,17.56 224.01,17.45 224.01,17.02 223.9,16.92 223.57,16.92 223.47,17.02 223.47,17.38 223.35,17.49 223.02,17.49 222.89,17.62 222.89,17.87 223,17.97 223.91,17.97 224.02,18.08 224.02,18.32 223.88,18.46 221.98,18.46 221.88,18.57 221.88,18.85 221.98,18.96 223.51,18.96 223.62,19.06 RH104.1
PCH_SPI_CLK_R: length 10.7
  BOTTOM w0.089: 219.18,20 v2(218.32,20.86) 217.69,21.49 217.69,22.71 216.92,23.48 216.92,24.13 216.07,24.97 215.89,24.97 215.58,24.66 UH1.BC31
  BOTTOM w0.107: 219.18,20 221.63,20 222.04,19.58 RH104.2
PCH_SPI_CS#: length 36.7
  TOP w0.089: v1(216.3,15.76) 216.66,15.76 v2(218.19,17.3) 218.7,17.81 v1(218.7,18.75)
  BOTTOM w0.089: v1(218.7,18.75) 218.7,19.84 217.51,21.04 217.51,22.64 216.74,23.41 216.74,24.05 216.11,24.68 215.99,24.68 UH1.BD31
  BOTTOM w0.107: RH74.2 219.16,18.75 v1(218.7,18.75) ; v1(216.3,15.76) 216.48,15.58 216.48,13.18 216.67,12.99 218.91,12.99 219.35,13.43 222.61,13.43 222.72,13.54 222.72,14.15 222.82,14.26 223.14,14.26 223.25,14.15 223.25,13.54 223.36,13.43 223.68,13.43 223.78,13.54 223.78,14.15 223.89,14.26 224.21,14.26 224.32,14.15 224.32,13.54 224.42,13.43 224.74,13.43 224.85,13.54 224.85,14.15 224.96,14.26 225.28,14.26 225.38,14.15 225.38,13.54 225.49,13.43 225.84,13.43 226.01,13.6 226.01,14.76 225.81,14.95 222,14.95 221.17,14.12 UH4.1
PCH_SPI_HOLD#: length 20.3
  IN4 w0.097: v1(222.64,16.86) 223.53,16.86 223.66,16.99 223.66,17.37 223.53,17.49 222.27,17.49 221.99,17.77 221.99,20.2 v1(222.14,20.34)
  BOTTOM w0.107: v1(222.14,20.34) 221.99,20.48 RPH5.4 ; UH4.7 226.21,15.39 226.1,15.5 226.1,16.18 225.99,16.28 225.78,16.28 225.67,16.18 225.67,15.5 225.57,15.39 225.35,15.39 225.25,15.5 225.25,16.34 225.14,16.44 224.93,16.44 224.82,16.34 224.82,15.5 224.71,15.39 224.5,15.39 224.39,15.5 224.39,16.34 224.29,16.44 224.07,16.44 223.97,16.34 223.97,15.5 223.86,15.39 223.65,15.39 223.54,15.5 223.54,16.34 223.43,16.44 223.22,16.44 223.11,16.34 223.11,15.5 223.01,15.39 222.77,15.39 222.64,15.53 v1(222.64,16.86)
PCH_SPI_HOLD#_R: length 9.9
  TOP w0.089: v1(219.16,20.54) 219.16,20.91 v2(218.96,21.11)
  TOP w0.107: v1(219.16,20.54) 219.95,20.54 RH455.2 220.03,20.61 RH78.2
  BOTTOM w0.089: 219.18,20.54 v1(219.16,20.54) ; UH1.BD30 216.01,25.28 217.09,24.2 217.09,23.56 217.86,22.79 217.86,22.08 219.16,20.79
  BOTTOM w0.107: 219.18,20.54 219.23,20.48 RPH5.5 ; 219.16,20.79 v1(219.16,20.54)
PCH_SPI_SI: length 17.6
  BOTTOM w0.107: UH4.5 226.3,17.93 226.2,18.04 226.2,18.34 226.3,18.45 226.6,18.45 226.7,18.55 226.7,18.77 226.6,18.87 226.3,18.87 226.2,18.98 226.2,19.4 226.02,19.57 225.87,19.57 225.58,19.29 225.36,19.29 225.24,19.4 225.24,19.55 225.57,19.88 225.57,20.03 225.42,20.18 225.27,20.18 224.56,19.47 224.41,19.47 224.26,19.62 224.26,19.77 224.96,20.48 224.96,20.63 224.8,20.8 224.61,20.8 224.46,20.95 224.46,21.69 224.35,21.8 224.14,21.8 224.03,21.69 v2(224.03,21.18) 224.03,20.38 223.92,20.28 223.71,20.28 223.6,20.38 223.6,21.69 223.5,21.8 223.28,21.8 223.18,21.69 223.18,20.74 223.07,20.63 222.8,20.63 222.7,20.72 222.7,21.04 222.33,21.42 221.44,21.42 221.38,21.48 RPH5.2
PCH_SPI_SI_R: length 38.3
  BOTTOM w0.089: 218.49,22.5 218.49,23.59 218.38,23.69 217.54,23.69 217.45,23.78 217.45,24.35 216.85,24.94 216.85,25.17 216.6,25.42 216.6,25.42 216.51,25.51 215.58,25.51 215.48,25.61 215.38,25.61 215.17,25.82 UH1.BB29
  BOTTOM w0.107: 218.49,22.5 219.5,21.48 RPH5.7 220.48,21.48 220.56,21.56 220.56,22.53 220.67,22.64 223.83,22.64 RH1.2 224.23,22.37 224.88,23.01 224.88,30.83 223.57,32.13 223.57,38.82 221.96,40.43 v2(221.57,40.43) 220.31,40.43 RH489.1
PCH_SPI_SO: length 19.6
  IN4 w0.097: v1(222,16.86) 222,17.12 221.78,17.33 220.98,17.33 220.88,17.24 220.88,16.77 220.79,16.67 220.5,16.67 220.4,16.77 220.4,17.24 220.31,17.33 220.02,17.33 219.92,17.24 219.92,16.77 219.82,16.67 219.43,16.67 219.34,16.77 219.34,17.73 219.43,17.82 221.67,17.82 221.77,17.91 221.77,18.2 221.67,18.3 220.7,18.3 220.61,18.4 220.61,18.69 220.7,18.78 221.67,18.78 221.77,18.88 221.77,19.57 221.55,19.8 221.55,21.65 221.64,21.75 222.05,21.75 222.14,21.65 v1(222.14,20.92)
  BOTTOM w0.107: v1(222,16.86) 222,15.78 221.62,15.39 UH4.2 ; RPH5.3 222.08,20.98 v1(222.14,20.92)
PCH_SPI_SO_R: length 6
  BOTTOM w0.089: UH1.BE30 216.38,25.16 217.27,24.27 217.27,23.63 218.04,22.86 218.04,22.47 v2(218.26,22.26) 219.11,21.4
  BOTTOM w0.107: 219.11,21.4 219.53,20.98 RPH5.6
PCH_SPI_WP#: length 18.5
  IN4 w0.097: v1(222.77,21.56) 223.21,21.11 223.21,20.39 223.31,20.29 224.13,20.29 224.23,20.19 224.23,19.92 224.13,19.82 222.49,19.82 222.38,19.71 222.38,19.48 222.48,19.38 224.45,19.38 224.55,19.29 224.55,19.05 224.45,18.96 222.46,18.96 222.36,18.86 222.36,18.61 222.46,18.51 223.94,18.51 224.04,18.41 224.04,18.16 223.94,18.07 222.62,18.07 v1(222.49,17.94)
  BOTTOM w0.107: v1(222.49,17.94) 221.69,17.94 221.28,17.53 221.28,16.83 221.11,16.66 UH4.3 ; RPH5.1 221.39,21.98 221.69,21.69 222.64,21.69 v1(222.77,21.56)
PCH_SPI_WP#_R: length 263.6
  TOP w0.107: RC354.2 129.31,160.55 129.87,159.99 v1(129.87,159.73) ; RH75.2 220.03,23.78 219.93,23.88 219.04,23.88 v1(218.64,24.29)
  IN1 w0.097: v1(202.32,95.37) 203.13,94.56 203.13,88.83 201.16,86.86 201.16,80.53 200.74,80.12 200.74,74.72 199.86,73.84 199.86,70 196.47,66.61 196.47,62.69 194.83,61.06 194.83,60.65 193.01,58.83 193.01,50.8 196.45,47.36 196.45,42.16 199.21,39.4 202.7,39.4 204,38.11 204,32.05 204.35,31.7 207.04,31.7 207.8,30.94 208.38,30.94 209.22,30.1 209.22,29.64 209.43,29.43 209.89,29.43 210.19,29.13 210.19,28.42 211.66,26.95 215.1,26.95 216.69,25.36 217.57,25.36 v1(218.64,24.29)
  IN3 w0.091: v1(129.87,159.73) 130.76,158.85 137.75,158.85 138.85,159.95 142.38,159.95 142.98,160.54 142.98,162.63 143.49,163.15 144.46,163.15 144.71,163.4 144.71,167.26 148.41,170.97 148.41,175.8 149.23,176.63 152.79,176.63 154.5,174.91 159.58,174.91 162.28,172.22 162.28,170.44 163.45,169.27 163.45,167.76 164.71,166.5 165.52,166.5 165.94,166.08 165.94,164.47 165.76,164.29 165.76,163.22 169.7,159.28 170.61,159.28 171.12,158.76 171.12,157.63 171.26,157.48 171.85,157.48 173.74,157.48 173.84,157.39 174.7,157.39 174.94,157.63 180.99,157.63 181.75,156.88 181.75,156.18 182.13,155.8 184.8,155.8 184.97,155.96 188.16,155.96 191.48,152.64 191.48,152.07 195.04,148.5 195.04,119.89 192.49,117.34 190.86,117.34 190.41,116.89 190.41,112.45 192.05,110.81 192.05,110.66 195.27,107.44 197.7,107.44 199.37,105.77 199.37,100.49 201.55,98.3 201.55,96.14 v1(202.32,95.37)
  BOTTOM w0.089: v1(218.64,24.29) 218.26,23.91 217.84,23.91 217.63,24.12 217.63,24.42 217.03,25.02 217.03,25.24 216.58,25.69 215.65,25.69 UH1.BC29
  BOTTOM w0.107: v1(218.64,24.29) 218.7,24.23 218.7,22.59 219.09,22.2 219.46,22.2 219.67,21.98 RPH5.8
PCH_SRTCRST#: length 10.4
  TOP w0.089: RH83.2 216.05,32.55 CH52.1 v2(217.69,32.23) 218.78,32.23 219.1,32.55 219.1,34.19 v1(218.14,35.14)
  BOTTOM w0.089: v1(218.14,35.14) 217.76,34.75 216.46,34.75 216.32,34.61 215.44,34.61 215.14,34.91 UH1.BB10
PCH_SYS_PWROK_XDP: length 1.9
  BOTTOM w0.107: v2(216.74,45.05) RH493.2 RH489.2
PCH_TRIGGER: length 102
  TOP w0.107: v1(179.92,97.63) 179.92,103.46 179.36,104.01 176.7,104.01 176.09,104.62 173.49,104.62 172.98,105.12 172.98,107.6 173.49,108.11 174.6,108.11 RH167.1
  IN1 w0.097: v1(209.64,41.05) 209.64,41.12 206.4,44.36 203.16,44.36 200.69,46.83 200.69,49.19 199.02,50.86 199.02,51.59 201.41,53.98 201.41,59 201.07,59.34 201.07,66.01 204.03,68.98 v1(204.03,71.09)
  IN4 w0.097: v1(204.03,71.09) 203.69,71.44 203.35,71.44 199.72,75.07 199.55,75.07 198,76.62 194.3,76.62 193.04,77.88 192.07,77.88 187.23,82.73 187.23,94.31 184.41,97.12 180.43,97.12 v1(179.92,97.63)
  BOTTOM w0.089: UH1.AL2 209.51,39.16 209.61,39.26 209.61,40.31 209.75,40.46 209.75,40.97 209.66,41.05 v1(209.64,41.05)
PCH_XDP_CLK_N: length 2.2
  TOP w0.089: v1(200.16,40.8) 200.34,40.98 200.34,40.98 T49.1
  BOTTOM w0.089: v1(200.16,40.8) 199.79,40.44 199.79,39.97 199.84,39.92 199.84,39.46 UH1.L1
PCH_XDP_CLK_P: length 2.2
  TOP w0.089: T50.1 200.19,39.63 v1(200.19,40.25)
  BOTTOM w0.089: UH1.L2 200.04,39.14 200.04,40.1 v1(200.19,40.25)
PCIE_GEN3#_GEN2: length 37.2
  TOP w0.107: UE1.18 318.6,18.84 319.54,19.78 319.54,21.88 326.04,28.38 v2(326.04,29.56) 326.04,32 326.5,32.45 328.03,32.45 328.91,33.33 328.91,33.34 329.65,34.08 332.75,34.08 335.7,37.03 335.7,42.42 335.16,42.96 334.72,42.96 334.22,43.45 UE6.11
PCIE_PRX_DTX_N5: length 175.1
  IN3 w0.099: v1(199.22,30.79) 199.22,30.61 199.12,30.51 198.74,30.51 198.64,30.61 198.64,34.77 197.56,35.84 195.54,35.84 194.89,36.49 194.89,37.76 193.62,39.03 193.62,40.06 191.31,42.37 191.31,51.5 190.19,52.62 190.19,63.72 190.61,64.14 190.61,83.38 192.79,85.57 199.22,85.57 201.13,87.48 202.34,87.48 205.37,90.5 205.37,90.97 206.09,91.7 206.09,100.57 203.02,103.64 203.02,108.43 198.34,113.11 198.34,143.25 203.35,148.26 220.21,148.26 220.62,148.67 222.46,148.67 224.27,150.48 228.08,150.48 229.22,149.34 231.38,149.34 231.47,149.26 231.47,149.03 231.37,148.93 v1(231.31,148.93)
  BOTTOM w0.089: UH1.K19 198.92,30.49 v1(199.22,30.79)
  BOTTOM w0.099: CL2.2 234.7,148.34 234.7,147.75 234.49,147.54 233.86,147.54 232.43,148.97 231.68,148.97 231.58,149.07 231.45,149.07 v1(231.31,148.93)
PCIE_PRX_DTX_N5_C: length 1.6
  BOTTOM w0.099: CL2.1 234.58,149.87 234.58,150.21 234.69,150.32 UL1.29
PCIE_PRX_DTX_N6: length 145.2
  IN4 w0.097: v1(197.49,29.75) 197.38,29.75 197.03,30.09 197.03,30.77 196.61,31.19 195.78,31.19 194.19,32.78 193.44,32.78 192.41,33.8 192.41,39.22 195.57,42.38 196.72,42.38 198.8,44.45 206.75,44.45 206.98,44.69 207.24,44.94 214.18,44.94 214.94,44.18 227.65,44.18 229.81,42.02 229.81,40.8 234.39,36.23 240.04,36.23 240.78,35.48 263.16,35.48 265.32,33.32 281.69,33.32 281.79,33.42 286.31,33.42 288.43,35.55 290.91,35.55 292.37,37.01 301.88,37.01 303.34,35.55 311.12,35.55 v1(311.32,35.35)
  BOTTOM w0.089: UH1.G22 197.39,29.65 v1(197.49,29.75)
  BOTTOM w0.099: v1(311.32,35.35) 310.93,35.74 310.73,35.74 310.52,35.52 310.52,34.75 310.82,34.44 JWLAN.35
PCIE_PRX_DTX_N9: length 62
  IN4 w0.097: v1(243.47,10.86) 243.68,10.65 243.68,10.56 243.57,10.45 242.17,10.45 240.45,12.16 239.17,12.16 238.45,12.89 233.22,12.89 232.72,13.39 230.41,13.39 230.03,13.01 228.29,13.01 227.57,13.73 211.75,13.73 211.29,14.19 210.7,14.19 210.24,13.73 206.44,13.73 205.99,14.18 200.94,14.18 199.51,15.61 199.51,17.69 199.46,17.74 199.46,19.21 198.82,19.85 198.82,20.54 198.56,20.8 197.93,20.8 197.67,21.05 197.67,22.58 197.55,22.7 197.55,23.32 198.31,24.09 198.45,24.09 v1(198.61,23.93)
  BOTTOM w0.099: UH1.G31 197.77,24.5 198.06,24.79 198.3,24.79 198.61,24.49 v1(198.61,23.93) ; JSSD3.43 243.53,12 243.68,11.85 243.68,11.07 v1(243.47,10.86)
PCIE_PRX_DTX_N10: length 69.2
  IN4 w0.097: v1(197.75,25.04) 197.51,25.04 197.14,25.4 196.83,25.4 195.76,24.33 195.76,23.75 196.31,23.2 196.31,21.66 196.52,21.44 196.52,21.12 196.19,20.79 196.19,20.02 196.54,19.67 196.98,19.67 197.42,19.23 198.06,19.23 198.52,18.76 198.52,16.87 198.24,16.59 198.24,15.43 200.36,13.32 205.59,13.32 206,12.91 227.23,12.91 228.08,12.06 230.53,12.06 231.04,12.56 232.27,12.56 232.77,12.06 238.11,12.06 238.83,11.34 240.11,11.34 241.84,9.61 246.57,9.61 247.04,10.08 v1(247.04,10.86)
  BOTTOM w0.099: JSSD3.29 247.02,12 246.87,11.85 246.87,11.03 v1(247.04,10.86) ; v1(197.75,25.04) 197.39,25.39 UH1.G29
PCIE_PRX_DTX_N11: length 63.9
  IN4 w0.097: v1(250.09,10.85) 249.87,11.07 249.87,11.25 249.68,11.45 246.26,11.45 245.62,12.09 243.2,12.09 241.63,13.66 239.52,13.66 238.99,14.19 236.99,14.19 236.53,14.64 233.49,14.64 232.32,15.81 228.45,15.81 227.71,15.07 212.67,15.07 211.29,16.46 209.49,16.46 208.67,15.64 202.7,15.64 202.24,16.1 202.24,17.93 201.22,18.95 201.22,20.31 200.61,20.92 200.61,22.01 200.19,22.43 199.66,22.43 199.43,22.66 199.43,23.23 199.66,23.46 199.66,23.71 v1(199.96,24)
  BOTTOM w0.099: v1(199.96,24) 199.71,24.25 UH1.L31 ; JSSD3.17 250.02,12.18 249.86,12.01 249.86,11.08 250.09,10.85 v1(250.09,10.85)
PCIE_PRX_DTX_N12: length 68.8
  IN4 w0.097: v1(245.11,10.86) 245.23,10.86 245.37,11 245.37,11.17 245.28,11.27 242.86,11.27 241.29,12.84 239.18,12.84 238.65,13.36 236.65,13.36 236.52,13.49 233.39,13.49 232.41,14.47 230.81,14.47 229.83,13.49 228.49,13.49 227.73,14.25 212.22,14.25 211.48,14.99 209.43,14.99 209.17,14.73 201.22,14.73 200.29,15.66 200.29,17.17 200.06,17.41 200.06,17.89 200.31,18.15 200.31,19.99 199.46,20.84 199.46,21.22 198.19,22.49 198.19,22.77 v1(197.94,23.02)
  BOTTOM w0.099: JSSD3.5 253.02,10.73 252.29,10 245.33,10 245.11,10.21 v1(245.11,10.86) ; UH1.G33 197.58,23.44 197.94,23.08 v1(197.94,23.02)
PCIE_PRX_DTX_N13: length 157.8
  IN1 w0.097: v1(197.02,22.27) 197.02,22.31 196.7,22.59 196.55,22.59 196.35,22.39 196.35,21.78 196.66,21.46 196.66,21.02 196.35,20.7 196.35,20.11 196.58,19.88 197.02,19.88 197.37,19.53 198.18,19.53 200.95,16.76 201.46,16.76 202.57,15.65 207.82,15.65 208.25,15.22 211.33,15.22 212.12,14.42 227.38,14.42 228.8,15.84 229.32,15.84 230.31,16.83 233.29,16.83 233.53,17.07 236.3,17.07 237.63,18.4 256,18.4 260.59,22.98 260.6,22.98 260.84,23.22 260.84,23.24 264.77,27.17 269.98,27.17 270.45,27.64 277.59,27.64 278.24,26.99 279.18,26.99 279.55,26.62 280.57,26.62 281.61,27.66 289.01,27.66 290.13,28.78 291.4,28.78 292.69,30.07 303.73,30.07 305.67,32.01 324.65,32.01 325.74,33.09 327.13,33.09 328.03,33.98 328.03,37.91 328.88,38.77 328.88,39.09 329.24,39.45 v1(329.24,39.56)
  BOTTOM w0.099: v1(197.02,22.27) 197.28,22.53 UH1.G35 ; JSSD1.29 326.77,41.11 326.92,40.95 328.09,40.95 328.47,40.58 328.47,39.65 328.82,39.3 329.03,39.3 329.24,39.51 v1(329.24,39.56)
PCIE_PRX_DTX_N14: length 148.2
  IN1 w0.097: v1(197.05,20.79) 197.13,20.88 197.55,20.88 197.72,20.7 198.29,20.7 198.66,20.32 198.66,19.88 199.35,19.19 200.33,19.19 201.45,18.07 201.96,18.07 202.52,17.52 202.52,16.93 202.92,16.52 203.38,16.52 203.69,16.83 206.62,16.83 207.23,16.21 211.11,16.21 212.42,14.9 226.89,14.9 228.32,16.33 229.13,16.33 230.11,17.31 233.09,17.31 233.33,17.55 236.1,17.55 237.43,18.88 251.96,18.88 252.5,19.41 255.86,19.41 260.24,23.79 260.72,23.79 264.57,27.64 269.78,27.64 270.25,28.12 278.06,28.12 278.71,27.46 280.74,27.46 281.41,28.13 288.77,28.13 291.3,30.66 303.65,30.66 305.47,32.48 320.43,32.48 321.52,33.57 325.63,33.57 326.57,34.5 326.57,37.55 326.7,37.68 327.31,37.68 v1(327.52,37.47)
  BOTTOM w0.099: UH1.D39 197.04,20.78 v1(197.05,20.79) ; v1(327.52,37.47) 327.31,37.68 326.71,37.68 326.63,37.61 JSSD1.43
PCIE_PRX_DTX_N17: length 86.6
  IN3 w0.099: v1(198.25,20.03) 198.07,19.84 198.07,19.53 198.32,19.27 198.32,18.51 197.94,18.13 197.31,18.13 196.99,17.81 196.99,16.84 197.23,16.6 197.94,16.6 199.08,15.46 199.08,14.9 201.09,12.89 202.11,12.89 202.89,12.12 203.9,12.12 204.36,11.65 214.09,11.65 214.5,12.06 219.83,12.06 220.43,11.46 226.19,11.46 227.31,10.33 252.59,10.33 253.06,10.8 256.69,10.8 258.1,12.2 265.12,12.2 266.92,14 269.61,14 269.82,13.79 269.82,13.31 v1(269.88,13.25)
  BOTTOM w0.099: UH1.H42 198.25,20.03 v1(198.25,20.03) ; JSSD2.43 271.02,13.76 270.71,14.06 269.79,14.06 269.49,13.77 269.49,13.65 v1(269.88,13.25)
PCIE_PRX_DTX_N18: length 84.9
  IN3 w0.099: v1(198.04,21.87) 198.15,21.87 198.64,21.38 198.64,20.97 198.83,20.78 198.83,18.76 200.35,17.24 200.35,15.57 201.7,14.23 205.9,14.23 207.14,12.98 213.54,12.98 213.95,13.39 220.46,13.39 221.06,12.79 226.74,12.79 227.87,11.66 240.81,11.66 241.32,12.17 242.31,12.17 242.56,12.43 246.47,12.43 246.76,12.14 256.15,12.14 257.54,13.54 264.57,13.54 266.63,15.59 267.17,15.59 267.44,15.85 269.42,15.85 269.7,16.13 269.7,16.44 v1(269.54,16.6)
  BOTTOM w0.099: JSSD2.29 269.85,17.25 269.64,17.04 269.64,16.71 v1(269.54,16.6) ; v1(198.04,21.87) 198.25,21.66 UH1.K37
PCIE_PRX_DTX_N19: length 83.4
  IN3 w0.099: v1(269.53,19.18) 269.93,18.79 269.93,18.7 269.8,18.57 268.74,18.57 268.24,18.07 266.87,18.07 264.89,16.09 264.89,15.86 263.89,14.87 256.99,14.87 255.6,13.47 247.31,13.47 247.02,13.76 242.01,13.76 241.75,13.5 240.73,13.5 240.23,12.99 233.25,12.99 232.69,13.56 231.33,13.56 230.77,12.99 228.42,12.99 227.27,14.14 221.6,14.14 220.99,14.74 210.61,14.74 210.52,14.83 208.45,14.83 207.69,15.59 203.4,15.59 202.29,16.69 201.25,16.69 201.15,16.8 201.15,19.36 199.84,20.67 199.27,20.67 199.08,20.86 v1(199.08,21.05)
  BOTTOM w0.089: UH1.L37 199.49,21.46 v1(199.08,21.05)
  BOTTOM w0.099: JSSD2.17 269.91,20.25 269.53,19.87 v1(269.53,19.18)
PCIE_PRX_DTX_N20: length 83.1
  IN3 w0.099: v1(270.07,23.43) 270.07,22.16 268.96,21.05 267.28,21.05 266.2,19.97 265.5,19.97 265.15,19.62 264.01,19.62 260.69,16.29 256.28,16.29 255.71,16.86 254.01,16.86 252.1,14.96 246.33,14.96 246.27,14.9 241.54,14.9 241.28,14.64 240.26,14.64 240.08,14.47 237.76,14.47 237.29,14.94 232.93,14.94 232.59,15.28 230.63,15.28 229.93,14.58 229.5,14.58 229.48,14.6 228.76,14.6 228.08,15.28 222.07,15.28 221.44,15.92 217.35,15.92 216.87,16.4 214.73,16.4 214.2,15.88 212.45,15.88 212.33,16 210.05,16 209.84,16.21 208.89,16.21 207.97,17.13 207.97,17.55 207.71,17.81 203.76,17.81 202.83,18.74 202.83,19.64 202.24,20.23 201.61,20.23 200.6,21.24 200.16,21.24 v1(200.03,21.11)
  BOTTOM w0.089: v1(200.03,21.11) 200.03,21.08 UH1.N39
  BOTTOM w0.099: v1(270.07,23.43) 269.76,23.12 269.76,23.05 269.86,22.95 270.77,22.95 271.07,23.25 JSSD2.5
PCIE_PRX_DTX_P5: length 175.2
  IN3 w0.099: v1(199.23,30.02) 199.23,30.02 198.92,30.33 198.66,30.33 198.45,30.53 198.45,34.69 197.49,35.66 195.46,35.66 194.7,36.42 194.7,37.69 193.43,38.95 193.43,39.98 191.12,42.3 191.12,51.43 190,52.55 190,63.79 190.42,64.22 190.42,83.46 192.72,85.75 199.14,85.75 201.05,87.66 202.27,87.66 205.18,90.58 205.18,91.05 205.91,91.77 205.91,100.49 202.83,103.56 202.83,108.36 198.15,113.04 198.15,143.32 203.28,148.45 220.13,148.45 220.54,148.86 222.39,148.86 224.19,150.66 228.16,150.66 229.29,149.52 231.09,149.52 v1(231.31,149.74)
  BOTTOM w0.089: v1(199.23,30.02) 199.23,30.09 199.51,30.37 UH1.L19
  BOTTOM w0.099: v1(231.31,149.74) 231.31,149.61 231.76,149.16 232.51,149.16 233.94,147.73 234.41,147.73 234.51,147.83 234.51,148.13 CL1.2
PCIE_PRX_DTX_P5_C: length 1.6
  BOTTOM w0.099: CL1.1 234.38,149.82 234.38,150.21 234.29,150.31 UL1.30
PCIE_PRX_DTX_P6: length 145.4
  IN4 w0.097: v1(311.32,35.93) 311.11,35.72 303.41,35.72 301.95,37.18 292.3,37.18 290.84,35.72 288.36,35.72 286.24,33.59 281.72,33.59 281.62,33.49 265.39,33.49 263.23,35.65 240.85,35.65 240.11,36.4 234.46,36.4 229.98,40.88 229.98,42.09 227.72,44.35 215.01,44.35 214.25,45.12 207.16,45.12 206.91,44.86 206.67,44.63 198.73,44.63 196.65,42.55 195.5,42.55 192.24,39.29 192.24,33.73 193.37,32.61 194.12,32.61 195.71,31.02 196.54,31.02 196.86,30.7 v1(196.86,29.75)
  BOTTOM w0.089: v1(196.86,29.75) 196.86,29.49 UH1.E22
  BOTTOM w0.099: JWLAN.33 310.32,35.6 310.65,35.93 v1(311.32,35.93)
PCIE_PRX_DTX_P9: length 62.1
  IN4 w0.097: v1(197.78,24.1) 197.78,23.8 197.37,23.4 197.37,22.63 197.5,22.5 197.5,20.98 197.86,20.62 198.49,20.62 198.65,20.47 198.65,19.78 199.29,19.14 199.29,17.67 199.34,17.62 199.34,15.54 200.86,14.01 205.92,14.01 206.36,13.56 210.32,13.56 210.77,14.02 211.22,14.02 211.68,13.56 227.5,13.56 228.22,12.84 230.1,12.84 230.48,13.21 232.64,13.21 233.14,12.71 238.38,12.71 239.1,11.99 240.38,11.99 242.1,10.27 243.64,10.27 243.85,10.48 243.85,10.66 v1(244.05,10.86)
  BOTTOM w0.099: v1(197.78,24.1) 197.74,24.1 197.64,24 197.64,23.86 197.89,23.61 198.03,23.61 198.24,23.83 198.24,24.09 198.39,24.23 198.39,24.4 198.29,24.5 UH1.H31 ; v1(244.05,10.86) 244,10.86 243.87,10.99 243.87,11.85 244.02,12 JSSD3.41
PCIE_PRX_DTX_P10: length 69.2
  IN4 w0.097: v1(246.45,10.86) 246.86,10.45 246.86,10.15 246.5,9.79 241.91,9.79 240.18,11.51 238.9,11.51 238.18,12.24 232.84,12.24 232.34,12.74 230.96,12.74 230.46,12.24 228.15,12.24 227.3,13.08 206.08,13.08 205.67,13.49 200.43,13.49 198.42,15.51 198.42,16.52 198.7,16.8 198.7,18.83 198.13,19.4 197.49,19.4 197.05,19.84 196.61,19.84 196.37,20.09 196.37,20.72 196.69,21.04 196.69,21.52 196.48,21.73 196.48,23.27 195.93,23.82 195.93,24.26 196.49,24.82 196.63,24.82 196.82,24.63 196.86,24.63 197.19,24.31 197.32,24.31 197.55,24.54 197.55,24.67 197.19,25.04 v1(196.99,25.04)
  BOTTOM w0.099: v1(246.45,10.86) 246.68,11.09 246.68,11.85 246.53,12 JSSD3.31 ; UH1.E29 196.99,25.29 v1(196.99,25.04)
PCIE_PRX_DTX_P11: length 63.8
  IN4 w0.097: v1(249.51,10.85) 249.7,11.05 249.7,11.18 249.6,11.28 246.18,11.28 245.55,11.92 243.13,11.92 241.56,13.49 239.45,13.49 238.92,14.01 236.91,14.01 236.46,14.47 233.41,14.47 232.25,15.64 228.52,15.64 227.78,14.9 212.6,14.9 211.22,16.29 209.56,16.29 208.74,15.47 202.63,15.47 202.07,16.03 202.07,17.85 201.05,18.88 201.05,20.23 200.44,20.84 200.44,21.94 200.12,22.26 199.59,22.26 199.25,22.59 199.25,23.3 199.49,23.53 199.49,23.67 v1(199.16,24)
  BOTTOM w0.099: UH1.K31 199.16,24.29 v1(199.16,24) ; v1(249.51,10.85) 249.5,10.85 249.67,11.01 249.67,12.06 249.53,12.2 JSSD3.19
PCIE_PRX_DTX_P12: length 68.8
  IN4 w0.097: v1(198.6,22.97) 198.37,22.74 198.37,22.56 199.64,21.29 199.64,20.92 200.49,20.06 200.49,18.07 200.23,17.82 200.23,17.48 200.47,17.24 200.47,15.73 201.3,14.9 209.09,14.9 209.36,15.17 211.55,15.17 212.29,14.42 227.8,14.42 228.56,13.66 229.76,13.66 230.74,14.64 232.48,14.64 233.46,13.66 236.59,13.66 236.72,13.54 238.72,13.54 239.25,13.01 241.36,13.01 242.93,11.44 245.35,11.44 245.55,11.24 245.55,10.92 245.64,10.83 245.83,10.83 v1(245.87,10.86)
  BOTTOM w0.099: v1(245.87,10.86) 245.69,10.86 245.31,10.48 245.31,10.29 245.41,10.19 252.21,10.19 252.83,10.81 252.83,11.81 252.73,11.91 252.62,11.91 252.53,12.01 JSSD3.7 ; v1(198.6,22.97) 198.34,23.23 UH1.H33
PCIE_PRX_DTX_P13: length 157.8
  IN1 w0.097: v1(329.29,38.93) 328.2,37.84 328.2,33.91 327.21,32.92 325.81,32.92 324.73,31.83 305.74,31.83 303.8,29.89 292.76,29.89 291.47,28.61 290.2,28.61 289.08,27.48 281.68,27.48 280.64,26.44 279.48,26.44 279.11,26.81 278.17,26.81 277.52,27.46 270.52,27.46 270.05,26.99 264.84,26.99 261.01,23.16 261.01,23.15 260.67,22.81 260.66,22.81 256.08,18.23 237.7,18.23 236.37,16.9 233.6,16.9 233.36,16.66 230.38,16.66 229.39,15.67 228.87,15.67 227.45,14.25 212.05,14.25 211.26,15.04 208.17,15.04 207.74,15.47 202.5,15.47 201.38,16.59 200.88,16.59 198.11,19.35 197.3,19.35 196.94,19.71 196.51,19.71 196.18,20.03 196.18,20.78 196.49,21.09 196.49,21.39 196.18,21.71 196.18,22.47 196.47,22.76 196.78,22.77 196.78,22.77 196.91,22.78 v1(196.99,22.87)
  BOTTOM w0.099: UH1.E35 196.66,22.53 v1(196.99,22.87) ; JSSD1.31 326.77,40.61 326.92,40.76 328.01,40.76 328.28,40.5 328.28,39.57 328.74,39.1 329.11,39.1 329.29,38.93 v1(329.29,38.93)
PCIE_PRX_DTX_P14: length 148.2
  IN1 w0.097: v1(197.09,21.41) 197.45,21.05 197.62,21.05 197.8,20.88 198.36,20.88 198.84,20.4 198.84,19.95 199.42,19.36 200.4,19.36 201.52,18.24 202.04,18.24 202.69,17.59 202.69,17 203,16.69 203.31,16.69 203.62,17 206.69,17 207.31,16.38 211.18,16.38 212.49,15.07 226.82,15.07 228.25,16.5 229.06,16.5 230.04,17.48 233.02,17.48 233.26,17.72 236.03,17.72 237.36,19.05 251.89,19.05 252.42,19.58 255.79,19.58 260.17,23.96 260.65,23.96 264.5,27.82 269.71,27.82 270.18,28.29 278.13,28.29 278.78,27.64 280.67,27.64 281.34,28.31 288.7,28.31 291.23,30.84 303.58,30.84 305.4,32.66 320.36,32.66 321.44,33.74 325.56,33.74 326.4,34.58 326.4,37.62 326.63,37.85 327.31,37.85 v1(327.52,38.06)
  BOTTOM w0.099: v1(197.09,21.41) 196.99,21.51 UH1.E37 ; v1(327.52,38.06) 327.33,37.87 326.79,37.87 326.55,38.11 JSSD1.41
PCIE_PRX_DTX_P17: length 86.5
  IN3 w0.099: v1(269.3,13.25) 269.63,13.59 269.63,13.72 269.54,13.82 267,13.82 265.2,12.02 258.17,12.02 256.77,10.62 253.13,10.62 252.66,10.15 227.24,10.15 226.11,11.27 220.36,11.27 219.75,11.87 214.58,11.87 214.17,11.46 204.29,11.46 203.82,11.93 202.81,11.93 202.03,12.7 201.02,12.7 198.9,14.82 198.9,15.38 197.86,16.42 197.15,16.42 196.8,16.77 196.8,17.89 197.23,18.32 197.87,18.32 198.13,18.59 198.13,19.2 197.88,19.45 197.88,19.71 v1(197.68,19.91)
  BOTTOM w0.099: JSSD2.41 269.71,14.25 269.3,13.85 v1(269.3,13.25) ; UH1.H40 197.87,20.31 197.87,20.1 v1(197.68,19.91)
PCIE_PRX_DTX_P18: length 84.8
  IN3 w0.099: v1(270.12,16.6) 269.89,16.37 269.89,16.06 269.5,15.67 267.51,15.67 267.25,15.4 266.7,15.4 264.65,13.35 257.62,13.35 256.23,11.95 246.68,11.95 246.39,12.24 242.64,12.24 242.38,11.98 241.39,11.98 240.89,11.48 227.79,11.48 226.66,12.6 220.99,12.6 220.39,13.21 214.03,13.21 213.62,12.79 207.06,12.79 205.82,14.04 201.62,14.04 200.17,15.49 200.17,17.16 198.64,18.69 198.64,20.7 198.45,20.89 198.45,21.05 198.26,21.24 v1(198.07,21.24)
  BOTTOM w0.099: v1(198.07,21.24) 197.87,21.05 197.68,21.05 197.58,21.15 UH1.G37 ; v1(270.12,16.6) 270.11,16.6 269.83,16.88 269.83,16.96 269.93,17.06 270.75,17.06 271.06,16.76 JSSD2.31
PCIE_PRX_DTX_P19: length 83.3
  IN3 w0.099: v1(199.21,20.16) 199.21,20.34 199.35,20.48 199.76,20.48 200.97,19.28 200.97,16.72 201.18,16.51 202.22,16.51 203.32,15.4 207.61,15.4 208.37,14.64 210.44,14.64 210.53,14.56 220.91,14.56 221.52,13.95 227.2,13.95 228.34,12.81 230.84,12.81 231.41,13.37 232.61,13.37 233.17,12.81 240.31,12.81 240.81,13.31 241.83,13.31 242.09,13.57 246.95,13.57 247.23,13.29 255.67,13.29 257.07,14.68 263.97,14.68 265.07,15.78 265.07,16.01 266.95,17.89 268.32,17.89 268.82,18.39 269.88,18.39 270.11,18.62 v1(270.11,19.18)
  BOTTOM w0.089: v1(199.21,20.16) 199.21,20.28 UH1.L39
  BOTTOM w0.099: JSSD2.19 270.98,19.76 270.67,20.06 269.99,20.06 269.72,19.79 269.72,19.58 v1(270.11,19.18)
PCIE_PRX_DTX_P20: length 83.1
  IN3 w0.099: v1(200.03,21.69) 200.29,21.43 200.67,21.43 201.68,20.42 202.32,20.42 203.02,19.72 203.02,18.82 203.84,18 207.79,18 208.15,17.63 208.15,17.21 208.97,16.4 209.91,16.4 210.12,16.19 212.4,16.19 212.53,16.06 214.13,16.06 214.65,16.59 216.94,16.59 217.43,16.1 221.51,16.1 222.15,15.47 228.16,15.47 228.84,14.79 229.56,14.79 229.58,14.77 229.86,14.77 230.55,15.46 232.66,15.46 233.01,15.12 237.37,15.12 237.84,14.66 240.01,14.66 240.18,14.83 241.2,14.83 241.46,15.09 246.2,15.09 246.25,15.14 252.03,15.14 253.93,17.05 255.79,17.05 256.36,16.48 260.61,16.48 263.94,19.8 265.07,19.8 265.43,20.16 266.12,20.16 267.2,21.24 268.88,21.24 269.88,22.24 269.88,23.03 v1(269.48,23.43)
  BOTTOM w0.089: UH1.N38 200.38,21.34 v1(200.03,21.69)
  BOTTOM w0.099: v1(269.48,23.43) 269.57,23.35 269.57,22.97 269.78,22.76 JSSD2.7
PCIE_PTX_DRX_N5: length 175.4
  IN3 w0.099: v1(196.87,28.6) 196.73,28.74 196.73,29.24 196.41,29.56 196.41,30.44 197.56,31.58 197.56,32.28 198.07,32.79 198.07,34.52 197.51,35.08 195.34,35.08 194.4,36.02 194.4,37.42 193.05,38.78 193.05,39.69 190.64,42.1 190.64,48.27 189.52,49.39 189.52,64.08 189.94,64.51 189.94,83.67 192.51,86.23 198.84,86.23 200.91,88.3 201.69,88.3 205.43,92.04 205.43,99.92 202.29,103.06 202.29,107.64 197.67,112.26 197.67,143.52 203.22,149.07 218.09,149.07 219.58,150.55 223.06,150.55 224,151.5 229.52,151.5 230.64,152.61 230.64,153.6 230.42,153.83 v1(229.74,153.83)
  BOTTOM w0.089: UH1.D22 196.36,29.11 v1(196.87,28.6)
  BOTTOM w0.099: v1(229.74,153.83) 230.06,153.51 230.39,153.51 CL4.2
PCIE_PTX_DRX_N5_C: length 2.2
  BOTTOM w0.099: CL4.1 231.9,153.49 232.85,153.49 232.97,153.62 UL1.36
PCIE_PTX_DRX_N6: length 141.1
  TOP w0.099: CN24.2 307.72,39.29 307.72,39.74 v1(307.92,39.94)
  IN4 w0.097: v1(194.64,30.07) 194.45,30.26 194.45,30.39 194.7,30.64 194.7,31.27 194.26,31.72 193.37,31.72 191.76,33.32 191.76,40.07 194.87,43.18 196.6,43.18 198.53,45.1 206.48,45.1 206.97,45.59 215.97,45.59 216.73,44.83 227.92,44.83 229.33,43.42 229.82,43.42 236.25,36.99 240.19,36.99 241.05,36.13 263.43,36.13 265.52,34.03 281.42,34.03 281.78,34.39 283.72,34.39 284.12,34.78 286.35,34.78 288.35,36.79 289.49,36.79 290.52,37.81 306.89,37.81 307.73,38.65 307.73,39.75 v1(307.92,39.94)
  BOTTOM w0.099: v1(194.64,30.07) 194.49,29.92 194.49,29.25 194.82,28.92 195.08,28.92 UH1.B22
PCIE_PTX_DRX_N6_C: length 5.9
  TOP w0.099: CN24.1 307.68,37.73 307.68,37.25 v1(307.86,37.07)
  BOTTOM w0.099: v1(307.86,37.07) 307.65,36.87 307.65,36.21 307.94,35.93 308.68,35.93 309.19,35.42 309.19,34.63 309.32,34.5 JWLAN.29
PCIE_PTX_DRX_N9: length 7.6
  TOP w0.099: CH210.1 239.3,10.07 239.65,10.07 239.97,9.75 239.97,9.01 v1(239.99,8.98)
  BOTTOM w0.099: v1(239.99,8.98) 239.72,9.25 239.72,9.39 240.53,10.2 241.57,10.2 242.5,11.14 242.5,12.03 242.53,12.06 JSSD3.47
PCIE_PTX_DRX_N9_C: length 71.5
  TOP w0.099: v1(237.19,8.99) 237.39,8.8 237.54,8.8 237.74,8.99 237.74,9.62 238.04,9.93 238.33,9.93 CH210.2
  IN4 w0.097: v1(193.18,24.6) 192.94,24.6 192.85,24.7 192.85,24.84 193.01,25 193.41,25 193.51,25.1 193.51,25.24 193.37,25.38 192.75,25.38 192.43,25.05 192.43,24.75 191.91,24.23 191.6,24.23 191.13,23.76 191.13,20.56 192.25,19.44 192.25,10.86 194.93,8.18 205.26,8.18 207.45,10.37 213.42,10.37 213.53,10.48 226.11,10.48 226.97,9.62 235.44,9.62 236.44,8.62 236.84,8.62 236.95,8.73 236.95,8.92 237.02,8.99 v1(237.19,8.99)
  BOTTOM w0.089: UH1.C31 195.53,24.54 195.2,24.87 194.9,24.87 194.75,24.72 194.59,24.72 194.29,25.02 193.6,25.02 v1(193.18,24.6)
PCIE_PTX_DRX_N10: length 7.4
  TOP w0.099: v1(244.85,8.56) 244.79,8.62 244.79,9.12 244.13,9.77 CH212.1
  BOTTOM w0.099: v1(244.85,8.56) 244.65,8.75 244.65,11.1 244.95,11.4 245.24,11.4 245.45,11.61 245.45,12.05 245.53,12.12 JSSD3.35
PCIE_PTX_DRX_N10_C: length 70.7
  TOP w0.099: CH212.2 242.01,9.77 241.8,9.56 241.8,8.74 241.67,8.6 241.13,8.6 241.1,8.57 239.8,8.57 239.58,8.35 239.58,8.09 v1(239.44,7.95)
  IN4 w0.097: v1(239.44,7.95) 239.59,8.1 239.59,8.24 239.44,8.39 238.58,8.39 236.86,10.1 227.2,10.1 226.34,10.96 211.7,10.96 211.58,10.84 207.14,10.84 206.51,10.22 205.2,10.22 203.64,8.66 196.58,8.66 192.73,12.51 192.73,19.28 192.73,19.35 192.73,19.73 192.05,20.41 192.05,21.41 192.11,21.47 192.11,21.88 192.78,22.55 192.78,22.9 192.86,22.98 192.86,22.99 193.41,23.54 193.41,23.68 v1(193.23,23.86)
  BOTTOM w0.089: UH1.C32 195.57,23.69 195.06,23.69 194.86,23.49 194.03,23.49 194,23.46 193.63,23.46 v1(193.23,23.86)
PCIE_PTX_DRX_N11: length 3.4
  TOP w0.099: CH203.2 248.12,10.15 248.12,10.7 v1(248.28,10.86)
  BOTTOM w0.099: JSSD3.23 248.53,12.14 248.37,11.98 248.37,11.79 248.04,11.46 248.04,11.1 v1(248.28,10.86)
PCIE_PTX_DRX_N11_C: length 68.8
  TOP w0.099: v1(248.27,8.77) 248.1,8.94 248.1,9.2 CH203.1
  IN4 w0.097: v1(248.27,8.77) 247.86,9.18 247.86,9.29 247.66,9.49 247.17,9.49 246.82,9.14 241.63,9.14 239.9,10.86 238.64,10.86 237.91,11.59 227.88,11.59 227.03,12.43 206.57,12.43 205.83,11.69 204.59,11.69 203.96,11.06 202.72,11.06 202.26,11.53 199.08,11.53 198.26,12.35 198.26,13.49 197.11,14.64 197.11,15.46 195.78,16.8 195.78,18.31 194.87,19.22 194.87,19.65 195.41,20.19 195.41,21.86 194.87,22.4 194.31,22.4 194.14,22.58 194.14,22.83 v1(194.19,22.88)
  BOTTOM w0.099: v1(194.19,22.88) 194.19,23 194.31,23.12 195.02,23.12 195.11,23.2 195.2,23.2 195.32,23.09 195.39,23.09 195.47,23.17 195.47,23.35 195.57,23.44 UH1.C33
