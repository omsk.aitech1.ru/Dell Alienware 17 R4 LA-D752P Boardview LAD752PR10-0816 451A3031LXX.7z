# Allegro board LAD752PR10-0816.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_CS2_DIMMB#: length 63.2
  IN1 w0.089: v1(155.22,99.74) 154.7,99.23 154.7,99.01 154.44,98.75 154.44,97.58 154.76,97.25 154.76,96.64 154.76,94.35 155.51,93.6 155.51,87.22 156.72,86.02 156.72,83.85
  IN1 w0.152: v1(150.99,45.57) 151.17,45.75 151.17,48.8 151.78,49.42 151.78,51.15 152.36,51.74 152.36,59.28 151.81,59.83 151.81,61.67 151.19,62.29 151.19,68.14 156.72,73.67 156.72,83.85
  BOTTOM w0.076: CPU1.AF11 154.84,100.1 155.19,99.74 v1(155.22,99.74)
  BOTTOM w0.175: v1(150.99,45.57) 150.39,44.97 150.14,44.97 149.8,45.31 149.8,45.56 150.69,46.45 JDIMM2.149
DDR_CS3_DIMMB#: length 66
  IN1 w0.089: v1(156.09,97.15) 155.72,96.78 155.72,95.27 156.6,94.39 156.6,88.61 158.76,86.45 158.76,83.85
  IN1 w0.152: 158.76,83.85 158.76,72.82 154.38,68.44 154.38,68.15 154.53,68 155.13,68 155.29,67.84 155.29,67.54 155.13,67.38 154.6,67.38 154.38,67.16 154.38,66.91 154.53,66.76 155.13,66.76 155.29,66.61 155.29,66.3 155.13,66.14 154.6,66.14 154.38,65.92 154.38,65.67 154.53,65.52 155.13,65.52 155.29,65.37 155.29,65.06 155.13,64.9 154.6,64.9 154.38,64.68 154.38,61.1 155.42,60.06 155.42,51.9 154.2,50.68 154.2,48.86 154.2,48.86 154.2,48.37 153.33,47.51 153.33,44.66 v1(152.85,44.17)
  BOTTOM w0.076: CPU1.AE7 156.04,97.15 v1(156.09,97.15)
  BOTTOM w0.175: JDIMM2.157 152.69,46.43 153.36,45.77 153.36,44.68 v1(152.85,44.17)
DDR_RCOMP0: length 6.2
  BOTTOM w0.109: RH148.2 v2(171.88,88.83)
  BOTTOM w0.254: 170.9,92.78 170.49,93.19 169.8,93.19 CPU1.G1
  BOTTOM w0.381: 170.9,92.78 171.88,91.8 RH148.2
DDR_RCOMP1: length 5.3
  BOTTOM w0.089: RH149.2 169.63,90.29 169.63,89.19 v2(169.34,88.89)
  BOTTOM w0.254: CPU1.H1 168.54,92.91 168.98,92.47
  BOTTOM w0.381: RH149.2 169.16,91.16 169.26,91.26 169.26,92.19 168.98,92.47
DDR_RCOMP2: length 3.9
  BOTTOM w0.254: RH150.2 168.18,90.85 v2(168.18,91.73) 168.18,91.77 168.35,91.94 168.35,92.49 167.96,92.89 167.96,93.96 CPU1.J2
DDR_VTT_PG_CTRL: length 28.5
  TOP w0.127: UC1.2 v2(124.93,81.44) 124.93,83.36 128.66,87.09 128.66,95.55 127.33,96.88 127.33,99.13 130.37,102.18 v1(131.31,102.18)
  BOTTOM w0.089: v1(131.31,102.18) 131.88,101.61 CPU1.BT13
DEBUG_CTL1: length 2.7
  TOP w0.107: v1(199.17,161.76) 199.02,161.76 198.76,161.51 198.76,160.81 199.14,160.43 RT66.2
  BOTTOM w0.076: v1(199.17,161.76) 199.47,162.07 UT4.E4
DEBUG_CTL2: length 2.8
  TOP w0.107: v2(201.04,160.05) RT67.2 200.03,160.66 199.82,160.88 v1(199.82,161.21)
  BOTTOM w0.076: v1(199.82,161.21) 199.83,161.21 200.16,161.54 UT4.D5
DEMB0: length 4
  BOTTOM w0.107: UM8.53 137.52,154.68 138.06,154.15 v2(138.06,153.64) 138.06,153.24 138.16,153.13 RM75.2 RM79.2
DEMB1: length 4.7
  BOTTOM w0.107: RM86.2 138.46,150.45 137.78,151.14 RM62.2 137.47,151.26 v2(137.47,152.18) 137.47,153.99 137.29,154.18 UM8.54
DEPOP#_EC: length 368.5
  TOP w0.107: UE6.2 330.54,39.96 v1(330.65,39.85)
  IN2 w0.091: v1(330.65,39.85) 330.65,38.86 330.18,38.39 330.18,34.49 327.8,32.1 326.98,32.1 320.6,25.72 313.38,25.72 310.98,23.32 298.25,23.32 296.85,21.92 295.19,21.92 290.72,26.39 285.47,26.39 281.03,30.83 273.71,30.83 273.2,31.34 271.7,31.34 262.03,41 257.51,41 256.72,40.22 234.11,40.22 232.59,41.74 227.22,41.74 226.86,42.1 222.9,42.1 222.19,42.81 214.4,42.81 214.22,43 213.7,43 213.45,42.75 212.93,42.75 212.26,43.42 207.72,43.42 207.13,42.83 205.22,42.83 204.66,42.27 202.91,42.27 202.53,42.66 198.79,42.66 197.76,41.63 184.09,41.63 178.05,35.59 174.14,35.59 173.34,36.39 156.16,36.39 154.67,34.91 138.7,34.91 134.7,38.91 112.93,38.91 110.78,41.06 109.38,41.06 105.78,44.66 98.77,44.66 97.76,45.67 96,45.67 95.89,45.56 93.25,45.56 93.2,45.6 92.33,45.6 91.62,46.32 58,46.32 57.2,47.12 55.91,47.12 55.9,47.1 53.71,47.1 52.9,46.3 36.14,46.3 30.86,41.03 29.47,41.03 27.31,38.87 v1(27.31,37.43)
  IN3 w0.091: v1(38.11,20.42) 37.16,21.37 37.16,23.84 36.58,24.42 34.17,24.42 33.54,25.05 33.54,26.32 34.04,26.83 34.04,27.21 34.72,27.88 34.72,32.86 33.71,33.86 33.71,34.98 32.08,36.62 32.08,37.94 31.31,38.7 28.58,38.7 v1(27.31,37.43)
  BOTTOM w0.254: DA2.3 38.46,20.77 v1(38.11,20.42)
DET: length 208.6
  TOP w0.107: v1(164.73,179.36) 165.12,179.75 JEDP.28
  IN1 w0.097: v1(202.07,22.42) 201.6,22.89 200.8,22.89 200.61,23.08 200.61,26.58 200.16,27.03 200.16,27.91 198.76,29.3 198.46,29.3 197.52,30.25 196.3,30.25 195.13,31.42 192.26,31.42 190.41,33.27 190.41,33.99 186.93,37.47 186.93,53.15 188.39,54.62 188.39,63.45 189.4,64.45 189.4,71.12 v1(188.98,71.53)
  IN2 w0.091: v1(164.73,179.36) 164.73,178.85 164.15,178.27 162.83,178.27 161.51,176.96 161.51,175.03 162.87,173.66 162.87,167.11 164.31,165.68 164.31,161.49 164.72,161.07 164.72,155.77 169.25,151.25 169.25,150.97 170.45,149.77 186.64,149.77 191.73,144.68 191.73,127.31 185.87,121.45 185.87,111.2 185.2,110.53 185.2,100.9 186.58,99.53 186.58,95.21 188.62,93.16 188.62,73.54 189.39,72.77 189.39,71.93 v1(188.98,71.53)
  BOTTOM w0.107: RH584.1 RH585.2 201.4,14.35 202.09,15.04 202.09,17.25 202.54,17.71 202.54,19.31 202.95,19.72 202.95,21.54 202.74,21.76 202.49,21.76 202.07,22.18 v1(202.07,22.42) 201.68,22.81 UH1.R35
DEVSLP0: length 55.3
  IN1 w0.089: v1(207.86,19.39) 209.56,21.1 211.51,21.1 211.96,21.55 214.33,21.55 216.99,18.89 v1(216.99,17.94)
  IN3 w0.089: 219.18,16.67 217.75,16.67 216.99,17.43 v1(216.99,17.94)
  IN3 w0.091: 219.18,16.67 221.62,16.67 222.35,15.95 236.19,15.95 236.36,15.78 v1(236.36,15.75)
  BOTTOM w0.089: v1(207.86,19.39) UH1.AG42
  BOTTOM w0.107: v1(236.36,15.75) 236.36,15.78 237.75,17.18 239.47,17.18 239.78,16.86 239.78,16.02 238.72,14.96 238.72,10.74 238.32,10.33 238.32,7.79 238.79,7.32 244.05,7.32 244.77,6.6 JSSD3.38
DEVSLP1: length 170.3
  IN4 w0.097: v1(207.06,17.18) 207.08,17.16 207.08,16.61 207.34,16.35 208.8,16.35 209.33,16.88 211.89,16.88 212.86,15.91 213.99,15.91 214.5,16.42 218.12,16.42 218.76,15.77 226.99,15.77 227.72,16.51 235.02,16.51 236.19,15.34 237.05,15.34 237.5,14.89 239.88,14.89 240.18,14.58 241.7,14.58 243.49,12.79 245.91,12.79 246.43,12.27 250.27,12.27 250.45,12.09 264.81,12.09 268.08,15.36 291.89,15.36 292.94,14.32 294.01,14.32 295.72,12.61 302.07,12.61 302.8,13.34 309.66,13.34 310.3,12.71 316.16,12.71 319.5,9.37 v1(335.99,9.37)
  BOTTOM w0.089: v1(207.06,17.18) 207.08,17.18 207.21,17.3 207.21,18.32 207.36,18.47 UH1.AG43
  BOTTOM w0.107: v1(335.99,9.37) 335.99,37.62 334.76,38.86 JSSD1.38
DEVSLP3: length 98.4
  IN4 w0.097: v1(119.63,11.32) 119.67,11.35 122.39,11.35 125.04,14 135.79,14 139.09,17.29 177.47,17.29 184.91,24.73 185.8,24.73 187.68,26.62 193.12,26.62 193.96,25.77 201.35,25.77 202.91,24.22 203.55,24.22 203.84,23.92 203.84,23.08 204.78,22.14 204.78,20.78 v1(204.29,20.29)
  BOTTOM w0.089: v1(204.29,20.29) 204.54,20.29 204.9,19.93 UH1.AB41
  BOTTOM w0.107: v1(119.63,11.32) 119.61,11.32 119.42,11.13 JHDD.13
DEVSLP4: length 91.8
  IN3 w0.089: 219.18,20.03 219.04,20.17 219.01,20.17 218.89,20.29 217.69,20.29 215.81,18.41 215.21,18.41 215,18.62 214.5,18.62 214,18.13 211.6,18.13 211.4,17.93 209.29,17.93 208.26,18.96 206.6,18.96 v1(205.38,20.17)
  IN3 w0.091: 219.18,20.03 220.04,20.03 221.33,18.74 222.68,18.74 223.01,18.74 224.19,17.56 238.96,17.56 239.58,16.94 246.54,16.94 246.75,17.14 250.36,17.14 251.91,18.69 255.92,18.69 259.08,21.85 265.41,21.85 265.85,22.28 265.85,22.92 269.08,26.15 274.74,26.15 v1(275.28,25.62)
  BOTTOM w0.089: v1(205.38,20.17) 205.19,19.97 205.19,19.31 UH1.AB42
  BOTTOM w0.107: JSSD2.38 278.44,15.01 276.2,17.24 276.2,24.7 v1(275.28,25.62)
DGPU_ENBKL: length 44.8
  TOP w0.089: RG25.1 231.3,90.92 v1(232.02,90.2)
  TOP w0.107: v1(199.4,92.74) 199.43,92.71 v2(200.8,92.71) 204.13,92.71 204.86,93.44 208.54,93.44 209.27,92.71 211.28,92.71 215.32,88.67 215.98,88.67 217.1,87.55 v1(217.1,86.71)
  IN4 w0.1: v1(217.1,86.71) 217.56,87.17 224.43,87.17 224.82,86.77 226.17,86.77 226.98,85.96 228.65,85.96 229.46,86.77 229.99,86.77 230.74,87.52 230.74,88.92 v1(232.02,90.2)
  BOTTOM w0.089: UG1.AK26 v1(232.02,90.2)
  BOTTOM w0.107: v1(199.4,92.74) 199.36,92.74 198.68,92.07 UV22.11
DGPU_ENVDD: length 49.5
  TOP w0.089: v1(233.22,90.2) 232.76,90.66 RG26.1 ; v1(215.67,87.92) 215.65,87.92
  TOP w0.107: v1(194.18,91.45) v2(198.95,91.45) 199.83,91.45 200.42,92.04 209.05,92.04 210.7,90.39 212.54,90.39 215.02,87.92 215.65,87.92
  IN4 w0.1: v1(215.67,87.92) 216.17,87.42 224.66,87.42 225.04,87.04 226.45,87.04 226.68,86.81 228.63,86.81 229.1,87.28 229.1,88.92 229.3,89.12 230.16,89.12 231.64,90.6 232.82,90.6 v1(233.22,90.2)
  BOTTOM w0.1: v1(233.22,90.2) UG1.AK25
  BOTTOM w0.107: v1(194.18,91.45) 194.14,91.42 UV22.5
DGPU_HOLD_RST#: length 141.1
  TOP w0.107: v1(201.14,117.87) 209.22,117.87 v1(209.27,117.82)
  IN1 w0.097: v1(202.32,93.76) 201.83,93.27 201.83,89.24 199.54,86.95 199.54,76.21 197.04,73.72 197.04,71.92 194.45,69.32 194.45,62.38 193.62,61.55 193.62,61.14 191.81,59.33 191.81,53.14 191.7,53.03 191.7,48.97 191.15,48.42 191.15,44.39 192.16,43.38 193.14,43.38 195.93,40.59 196.81,40.59 198.64,38.76 202.51,38.76 203.44,37.83 203.44,36.68 203.27,36.5 203.27,31.16 203.85,30.57 207.13,30.57 207.65,30.05 207.65,25.68 208.38,24.95 208.38,23.84 208.48,23.75 208.48,22.19 v1(209.11,21.56)
  BOTTOM w0.089: v1(209.11,21.56) 209.25,21.56 UH1.AL36
  BOTTOM w0.107: v1(209.27,117.82) 209.38,117.82 209.59,118.03 UG2.1 209.6,118.45 RG2.1 ; v1(201.14,117.87) 202.12,117.87 203.84,116.15 203.84,109.82 199.91,105.89 195.16,105.89 192.99,103.72 192.99,97.12 195.91,94.19 197.76,94.19 198.38,93.57 202.13,93.57 v1(202.32,93.76)
DGPU_INV_PWM: length 55.6
  TOP w0.107: v1(193.75,89.69) 193.75,91.6 194.32,92.17 v2(196.67,92.17) 199.72,92.17 199.84,92.3 211.36,92.3 215.22,88.44 215.94,88.44 216.73,87.64 216.73,86.56 216.95,86.34 217.54,86.34 v1(217.57,86.37)
  IN4 w0.1: v1(217.57,86.37) 218.17,86.97 224.1,86.97 225.14,85.92 226.25,85.92 227.02,85.15 228.63,85.15 229.46,85.97 230.64,85.97 231.23,86.56 231.23,88.9 231.48,89.15 232.82,89.15 v1(233.22,89.55)
  BOTTOM w0.089: v1(217.57,86.37) 217.41,86.2 216.48,86.2 216.04,86.65 215.65,86.65
  BOTTOM w0.1: UG1.AL26 233.07,89.55 v1(233.22,89.55)
  BOTTOM w0.107: RG24.1 215.65,86.65 ; UV22.2 193.52,89.47 v1(193.75,89.69)
DGPU_PEX_RST#: length 80.4
  TOP w0.107: v1(198.54,145.61) 200.83,145.61 204.34,149.12 207.2,149.12 208.77,150.69 208.77,151.63 v2(209.98,152.84) 209.98,155.41 210.26,155.69 210.26,156.83 v1(210.68,157.25) ; v1(210.15,116.13) 209.97,116.32 209.97,118.19 209.04,119.12 v1(201.12,119.12) ; v1(225.23,162.42) 224.29,161.49 UX1.2
  IN1 w0.097: v1(225.23,162.42) 225.23,161.83 222.08,158.67 219.87,158.67 218.87,157.67 214.57,157.67 213.74,158.5 211.93,158.5 v1(210.68,157.25)
  BOTTOM w0.107: v1(210.15,116.13) 209.88,115.86 RG152.2 ; v1(198.54,145.61) 198.6,145.61 198.77,145.44 198.77,120.89 200.54,119.12 v1(201.12,119.12) ; UX2.2 211.49,158.06 v1(210.68,157.25)
DGPU_PRSNT#: length 5.1
  TOP w0.089: v1(217.38,29.74) 217.38,29.77 217.8,30.19 v2(218.07,30.19) 218.09,30.21 219.03,30.21 219.18,30.36
  TOP w0.107: RH135.2 219.18,30.36
  BOTTOM w0.089: v1(217.38,29.74) 216.88,30.24 215.74,30.24 215.59,30.39 UH1.BC19
DGPU_PWR_EN: length 402.4
  TOP w0.107: UE5.1 305.54,24.8 v1(306.46,25.72)
  TOP w0.254: v1(207.8,20.04) 207.97,20.04 208.3,19.71 208.3,18.78 208.1,18.57 208.1,17.18 207.71,16.79 v1(207.6,16.79) ; PR801.2 197.1,72.66 v1(198.44,72.66) 199.04,72.66 199.46,72.23 199.46,71.15 200.16,70.45 PR1303.2 ; v1(203.84,84.68) 203.84,83.2 201.26,80.61 v2(201.26,80.3) 201.26,77.01 201.18,76.93 v1(201.18,76.8) ; PR8212.2 v1(278.74,152.69)
  IN1 w0.097: v1(259.72,43.51) 255.74,43.51 254.99,42.75 223.03,42.75 222.94,42.85 222.94,44.68 223.59,45.33 223.59,47.89 222.27,49.21 221.61,49.21 209.83,60.99 208.1,60.99 207.84,61.25 v1(206.46,61.25)
  IN3 w0.089: 198.52,42.08 198.52,39.58 199.08,39.02 200.16,39.02 200.59,38.59 200.59,33.95 200.73,33.82 200.73,32.97 200.41,32.66 200.4,32.66 200.2,32.46 200.2,27.33 200.9,26.63 200.9,24.19 201.71,23.38 201.71,22.27 201.92,22.06 202.32,22.06 203.24,21.15 203.54,21.15 203.9,21.51 204.78,21.51 205.54,20.75 207.06,20.75 207.78,20.04 v1(207.8,20.04)
  IN3 w0.091: 198.52,42.08 198.52,48.24 194.25,52.51 194.25,53.16 193.55,53.86 193.55,68.72 197.07,72.23 198.01,72.23 v1(198.44,72.66) 198.59,72.8 199.34,72.8 200.86,74.33 200.86,76.49 v1(201.18,76.8) 203.78,76.8 205.89,74.7 205.89,61.81 v1(206.46,61.25) ; v1(293.51,54.2) 293.9,54.2 294.37,53.73 294.37,50.3 291.77,47.7 290.84,47.7 287.12,43.97 287.12,40.92 288.57,39.47 288.57,36.23 292.21,32.58 303.5,32.58 306.86,29.22 306.86,26.12 v1(306.46,25.72)
  IN4 w0.097: v1(293.51,54.2) 292.69,53.38 292.69,49.21 291.57,48.09 286.57,48.09 284.93,46.45 280.19,46.45 279.35,47.29 273.39,47.29 268.03,41.93 261.31,41.93 v1(259.72,43.51)
  BOTTOM w0.107: v1(259.72,43.51) 257.26,45.97 257.26,48.9 257.4,49.04 258.36,49.04 258.49,48.91 QG505.2 258.49,48.09 258.7,47.89 259.53,47.89 259.67,48.03 259.67,48.65 259.9,48.88 260.98,48.88 261.11,48.75 QG507.2
  BOTTOM w0.254: v1(207.6,16.79) 208.11,16.28 208.11,15.8 207.78,15.48 RH537.1 ; DG1.1 204.98,91.87 205.3,91.55 205.3,89.22 205.47,89.06 RG50.2 204.56,87.05 203.84,86.33 v1(203.84,84.68) ; v1(278.74,152.69) 278.74,151.84 285.9,144.68 285.9,99.77 287.22,98.44 287.22,92.87 290.08,90.01 290.08,75.85 295.73,70.2 295.73,60.23 296.62,59.34 296.62,54.01 296.3,53.69 294.65,53.69 294.14,54.2 v1(293.51,54.2) 292.76,54.2 PR6017.2 ; UH1.AJ39 208.18,20.42 v1(207.8,20.04)
DGPU_PWR_EN#: length 1.1
  BOTTOM w0.107: v2(208.29,88.11) 208.45,87.95 RG49.1
DGPU_PWR_ENP: length 3.5
  TOP w0.107: PR8212.1 v2(277.82,152.69)
  TOP w0.203: PC8211.1 277.64,154.83 PU8200.3
  TOP w0.254: PC8211.1 277.83,153.66 PR8212.1
DGPU_PWROK: length 172.1
  TOP w0.089: v1(208.61,17.28) 208.36,17.52 208.36,18.47 208.56,18.67 208.56,20.71 208.1,21.18 206.52,21.18 RH516.2
  TOP w0.107: v1(328.43,44.43) 328.91,43.95 UE6.19 ; PR6018.1 298.67,54.46 298.34,54.13 296.29,54.13 v1(295.94,54.49)
  IN1 w0.097: v1(208.61,17.28) 209.15,17.28 209.81,17.94 211.4,17.94 211.59,18.13 212.54,18.13 212.92,17.75 216.64,17.75 217.94,16.46 226.25,16.46 227.68,17.88 228.49,17.88 229.71,19.1 235.46,19.1 236.79,20.43 242.01,20.43 242.54,20.96 247.58,20.96 247.95,20.59 248.28,20.59 248.49,20.8 250.33,20.8 252.93,23.41 255.33,23.41 260,28.08 262.81,28.08 263.93,29.2 269.14,29.2 269.86,29.92 274.4,29.92 275.1,30.61 279.6,30.61 279.83,30.39 284.29,30.39 284.65,30.75 288.09,30.75 292.11,34.77 v1(292.49,34.77) 297.79,34.77 298.52,34.04 319.73,34.04 321.24,35.54 322.48,35.54 326.4,39.47 326.4,43.15 327.68,44.43 v1(328.43,44.43)
  IN3 w0.091: v1(295.94,54.49) 295.94,54.24 295.94,54.23 295.94,46.65 295.12,45.83 295.12,38.78 292.49,36.15 v1(292.49,34.77)
  BOTTOM w0.089: UH1.AJ44 208.45,17.43 v1(208.61,17.28)
  BOTTOM w0.107: PR6056.1 294.84,54.96 295.35,54.45 295.9,54.45 v1(295.94,54.49)
DH_1.2V: length 3.6
  TOP w0.107: v1(89.93,42.94) 89.93,42.96 v2(89.54,43.34)
  IN4 w1.016: 88.97,43.09 88.27,42.39 88.27,40.29
  vias: v1(89.29,39.2) v1(89.29,38.58) v1(90.31,43.39)
DH_CHG: length 12.4
  IN1 w1.016: 73.01,19.99 71.53,19.99 70.81,19.27 64.22,19.27 62.12,21.37 62.12,21.69
  vias: v1(61.54,22.57) v1(62.18,22.57) v1(74.18,20.16) v1(74.81,20.16) v2(74.94,19.46)
DIMM_CHA_SA0: length 3.8
  TOP w0.107: RD1.2 RD28.1 177.25,51.15 v1(177.25,50.42) 177.54,50.13 v2(177.68,50.13)
  BOTTOM w0.127: JDIMM1.256 177.44,50.61 v1(177.25,50.42)
DIMM_CHA_SA1: length 4.3
  TOP w0.107: v2(177.36,53.25) 177.62,53.25 v1(177.87,53.5) 177.68,53.69 RD29.1 178.47,54.25 RD2.2
  BOTTOM w0.127: JDIMM1.260 178.44,52.93 v1(177.87,53.5)
DIMM_CHA_SA2: length 6.8
  TOP w0.107: RD3.2 RD30.1 155.15,46.77 154.69,47.23 v1(154.69,49.15)
  BOTTOM w0.127: JDIMM1.166 154.94,50.71 155.1,50.56 155.1,49.55 v1(154.69,49.15)
DIMM_CHB_SA0: length 4.3
  TOP w0.107: RD38.1 176.35,37.62 v2(176.43,37.7) v1(177.17,37.7) 177.17,38.18 RD4.2
  BOTTOM w0.107: v1(177.17,37.7) 177.45,37.98 177.45,38.99 JDIMM2.256
DIMM_CHB_SA1: length 3.9
  TOP w0.107: RD5.2 177.55,38.32 177.81,38.07 v1(177.81,37.69) 177.81,37.37 177.24,36.8 RD39.1
  BOTTOM w0.107: 178.44,38.26 177.88,37.69 v1(177.81,37.69)
  BOTTOM w0.127: JDIMM2.260 178.44,38.26
DIMM_CHB_SA2: length 6.4
  TOP w0.107: v2(157.49,37.47) 157.12,37.84 RD6.2 156.23,39.41 RD40.1 156.23,40.25 155.59,40.89 v1(155.5,40.89)
  BOTTOM w0.107: JDIMM2.166 154.94,40.33 v1(155.5,40.89)
DISP_CEC: length 3.2
  BOTTOM w0.107: RV18.2 233.39,167.77 v2(233.39,168.62) 233.39,169.43 233.57,169.61 JDP.6
DISP_CLK_AUXP_CONN: length 23.4
  IN4 w0.097: v1(235.72,168.56) 235.93,168.36 236.25,168.36 236.74,167.86 236.74,164.69 236.29,164.24 236.29,163.3 233.88,160.89 231.88,160.89 231.68,161.1 231.45,161.1 v1(231.28,160.92)
  BOTTOM w0.107: v1(235.72,168.56) 236.01,168.27 236.24,168.27 236.46,168.48 236.46,168.97 236.77,169.29 236.77,169.54 236.57,169.74 JDP.16 ; RV15.2 232.36,160.85 231.88,160.85 231.69,161.04 231.4,161.04 v1(231.28,160.92) 231.03,161.17 229.51,161.17 228.87,160.53 228.87,159.99 229.75,159.12 UV3.4
DISP_DAT_AUXN_CONN: length 23.4
  IN4 w0.097: v1(231.28,161.51) 231.51,161.27 231.75,161.27 231.96,161.06 233.81,161.06 236.12,163.37 236.12,164.31 236.57,164.76 236.57,167.79 236.17,168.18 235.93,168.18 v1(235.72,167.98)
  BOTTOM w0.107: RV16.2 232.45,161.07 231.97,161.07 231.78,161.26 231.52,161.26 v1(231.28,161.51) 231.16,161.39 229.42,161.39 228.66,160.62 228.66,159.92 227.8,159.06 UV3.7 ; v1(235.72,167.98) 235.8,168.05 236.33,168.05 236.67,168.39 236.67,168.88 236.99,169.2 236.99,169.58 237.18,169.76 JDP.18
DISPOFF#: length 24.1
  TOP w0.107: v1(166,161.25) v2(166.5,160.75) 167.22,160.03 RV1.1 167.74,159.81 168.32,159.81 DV1.1 ; JEDP.35 168.62,179.28 v1(168.72,179.19)
  IN2 w0.091: v1(168.72,179.19) 168.72,177.03 166.52,174.84 166.52,171.61 165.93,171.01 165.93,169.26 166.12,169.06 166.12,163.99 165.84,163.7 165.84,162.94 166.15,162.64 166.15,161.39 v1(166,161.25)
DL_1.2V: length 7.3
  IN4 w1.016: 95.51,35.72 91.39,39.85 91.39,40.66
  BOTTOM w0.107: v1(91.07,41.88) 91.07,41.37 v2(90.94,41.24)
  vias: v1(91.4,42.41) v1(95.58,34.51) v1(95.58,33.88)
DL_CHG: length 2.8
  TOP w0.107: v1(60.85,20.54) 61.41,20.54 v2(61.48,20.48)
  IN4 w1.016: 61.79,19.84 63.25,19.84 63.76,20.35
  vias: v1(60.4,20.95) v1(64.46,21.05) v1(65.1,21.05)
DMI_CRX_PTX_N0: length 94.8
  IN1 w0.097: v1(187.94,28.83) 187.94,29.07 183.45,33.55 183.45,50.6 182.93,51.11 182.93,53.86 182.27,54.52 182.27,65.42 181.51,66.18 181.51,74.85 182.25,75.59 182.25,83.72 184.79,86.25 184.79,91.74 183.01,93.52 180.42,93.52 180.17,93.27 175.32,93.27 173.95,94.64 173.95,96.92 173.18,97.7 171.16,97.7 170.91,97.94 170.91,98.2 170.82,98.3 v1(170.71,98.3)
  BOTTOM w0.076: v1(170.71,98.3) CPU1.E8
  BOTTOM w0.089: 193.35,27.52 193.35,27.52 194.09,26.79 194.1,26.79 194.13,26.77 194.73,26.77 195.03,26.47 195.3,26.47 UH1.C27
  BOTTOM w0.099: v1(187.94,28.83) 188.3,28.83 189.6,27.52 193.35,27.52
DMI_CRX_PTX_N1: length 88.7
  IN1 w0.097: v1(170.06,97.51) 170.43,97.14 172.59,97.14 173.11,96.62 173.11,94.78 175.53,92.36 175.93,92.36 178.27,90.02 178.27,88.89 180.99,86.18 180.99,79.59 180.43,79.03 180.43,66.21 181.62,65.03 181.62,54.25 182.28,53.59 182.28,50.84 182.8,50.33 182.8,32.97 188.12,27.65 188.6,27.65 188.79,27.46 188.79,27.22 v1(188.6,27.02)
  BOTTOM w0.076: v1(170.06,97.51) 169.71,97.17 CPU1.F6
  BOTTOM w0.099: v1(188.6,27.02) 188.79,26.82 188.79,26.47 189,26.26 191.7,26.26 191.95,26.52 193.37,26.52 193.51,26.37 193.96,26.37 194.16,26.17 194.17,26.17 194.25,26.09 194.88,26.09 195.02,26.23 UH1.B28
DMI_CRX_PTX_N2: length 91.7
  IN1 w0.097: v1(191.73,23.11) 191.54,23.29 191.3,23.29 191.1,23.49 191.1,25.3 190.12,26.28 188.33,26.28 187.8,26.81 187.8,27.06 182.15,32.7 182.15,45.74 181.38,46.51 181.38,50.82 180.26,51.95 180.26,53.53 180.97,54.24 180.97,60.02 180.6,60.39 180.6,64.05 179.65,65 179.65,79.97 180.34,80.66 180.34,85.91 177.59,88.66 177.59,89.79 175.52,91.85 175.34,91.85 173.56,93.63 172.55,93.63 172.32,93.86 172.32,94.89 170.95,96.26 170.95,96.48 v1(170.71,96.72)
  BOTTOM w0.076: CPU1.E5 170.38,96.4 v1(170.71,96.72)
  BOTTOM w0.099: v1(191.73,23.11) 191.95,23.33 192.18,23.33 192.41,23.57 192.41,23.66 192.42,23.66 192.42,25.23 192.87,25.68 194.83,25.68 195.04,25.48 195.14,25.48 195.22,25.55 195.22,25.67 UH1.B29
DMI_CRX_PTX_N3: length 97.2
  IN1 w0.097: v1(191.67,22.27) 191.47,22.07 191.11,22.07 191.02,22.16 191.02,22.9 190.62,23.29 190.62,23.91 190.01,24.53 187.41,24.53 186.76,25.17 186.76,27.41 181.67,32.51 181.67,45.52 180.58,46.61 180.58,50.85 179.78,51.64 179.78,54.34 180.49,55.05 180.49,59.77 180.12,60.14 180.12,63.51 179.14,64.48 179.14,81.69 179.4,81.95 179.4,86.18 177.11,88.46 177.11,89.57 173.4,93.28 172.31,93.28 171.82,93.77 171.82,94.3 170.17,95.95 170.17,96.7 169.62,97.26 169.62,98.52 169.42,98.72 169.07,98.72 v1(168.7,99.09)
  BOTTOM w0.076: CPU1.J9 v1(168.7,99.09)
  BOTTOM w0.089: 192.6,23.58 192.6,23.66 192.61,23.67 192.61,25.06 192.99,25.43 194.81,25.43 195.14,25.1 UH1.B30
  BOTTOM w0.099: 192.6,23.58 192.6,22.57 192.16,22.13 191.86,22.13 191.86,22.13 191.81,22.13 v1(191.67,22.27)
DMI_CRX_PTX_P0: length 94.6
  IN1 w0.097: v1(188.35,29.24) 188.01,29.24 183.62,33.63 183.62,50.67 183.1,51.19 183.1,53.93 182.44,54.6 182.44,65.49 181.69,66.25 181.69,74.78 182.43,75.52 182.43,83.64 184.96,86.18 184.96,91.81 183.08,93.7 180.35,93.7 180.09,93.44 175.4,93.44 174.13,94.71 174.13,96.99 173.25,97.87 171.23,97.87 171.09,98.01 171.09,98.2 171.18,98.3 v1(171.36,98.3)
  BOTTOM w0.076: v1(171.36,98.3) 171.18,98.3 171.03,98.15 CPU1.D8
  BOTTOM w0.089: 193.35,27.72 193.36,27.72 193.37,27.71 193.43,27.71 193.48,27.65 194.16,26.97 194.78,26.97 194.93,27.13 195.17,27.13 195.19,27.1 195.25,27.1 195.37,26.99 195.37,26.83 195.25,26.71 UH1.B27
  BOTTOM w0.099: 193.35,27.72 189.68,27.72 188.35,29.05 v1(188.35,29.24)
DMI_CRX_PTX_P1: length 87.7
  IN1 w0.097: v1(170.71,97.51) 170.71,97.43 170.83,97.31 172.66,97.31 173.28,96.69 173.28,94.86 175.6,92.53 176.01,92.53 178.45,90.09 178.45,88.96 181.16,86.25 181.16,79.52 180.6,78.96 180.6,66.29 181.79,65.1 181.79,54.33 182.45,53.66 182.45,50.92 182.97,50.4 182.97,33.04 188.19,27.83 188.68,27.83 188.97,27.54 188.97,27.23 v1(189.18,27.02)
  BOTTOM w0.076: v1(170.71,97.51) 170.38,97.19 CPU1.E6
  BOTTOM w0.099: UH1.A28 194.79,26.36 194.79,26.45 194.65,26.59 194.5,26.59 194.46,26.54 194.46,26.45 194.37,26.36 194.24,26.36 194.04,26.57 193.59,26.57 193.43,26.73 191.9,26.73 191.62,26.45 189.08,26.45 188.98,26.55 188.98,26.82 v1(189.18,27.02)
DMI_CRX_PTX_P2: length 91.7
  IN1 w0.097: v1(171.36,96.72) 171.12,96.49 171.12,96.33 172.49,94.96 172.49,93.93 172.62,93.8 173.64,93.8 175.41,92.03 175.59,92.03 177.76,89.86 177.76,88.73 180.51,85.98 180.51,80.59 179.83,79.9 179.83,65.07 180.77,64.13 180.77,60.46 181.14,60.09 181.14,54.16 180.43,53.46 180.43,52.02 181.56,50.9 181.56,46.58 182.32,45.81 182.32,32.78 187.97,27.13 187.97,26.88 188.4,26.45 190.19,26.45 191.27,25.37 191.27,23.56 191.37,23.47 191.5,23.47 v1(191.73,23.69)
  BOTTOM w0.076: v1(171.36,96.72) 171.03,96.4 CPU1.D5
  BOTTOM w0.099: v1(191.73,23.69) 191.89,23.53 192.1,23.53 192.22,23.65 192.22,23.74 192.22,23.74 192.22,25.31 192.79,25.88 194.97,25.88 195.05,25.96 195.3,25.96 195.3,25.95 195.31,25.95 195.55,25.72 UH1.C29
DMI_CRX_PTX_P3: length 97.1
  IN1 w0.097: v1(191.67,21.68) 191.46,21.89 191.04,21.89 190.84,22.09 190.84,22.83 190.45,23.22 190.45,23.84 189.94,24.35 187.33,24.35 186.59,25.1 186.59,27.34 181.5,32.43 181.5,45.45 180.4,46.54 180.4,50.78 179.61,51.57 179.61,54.41 180.32,55.12 180.32,59.7 179.95,60.07 179.95,63.43 178.97,64.41 178.97,81.76 179.22,82.02 179.22,86.1 176.94,88.39 176.94,89.5 173.33,93.11 172.24,93.11 171.65,93.69 171.65,94.23 170,95.88 170,96.63 169.44,97.18 169.44,98.45 169.35,98.55 169.01,98.55 v1(168.76,98.3)
  BOTTOM w0.076: CPU1.J8 168.27,98.25 168.43,98.41 168.64,98.41 v1(168.76,98.3)
  BOTTOM w0.089: UH1.A30 194.76,25.01 194.71,24.97 194.6,24.97 194.5,25.07 194.5,25.2 194.44,25.25 193.06,25.25 192.79,24.98 192.79,23.58
  BOTTOM w0.099: v1(191.67,21.68) 191.92,21.94 192.24,21.94 192.79,22.49 192.79,23.58
DMI_CTX_PRX_N0: length 96.7
  IN1 w0.097: v1(176.41,96.87) 176.51,96.87 176.6,96.77 176.6,96.56 176.91,96.25 184.02,96.25 187.39,92.87 187.39,75.58 184.97,73.16 184.97,71.45 184.22,70.7 184.22,67.71 184.97,66.96 184.97,56.49 186.05,55.42 186.05,37.11 189.53,33.63 189.53,32.9 192.02,30.42 192.74,30.42 195.12,28.05 199.07,28.05 199.55,27.56 199.55,26.6 199.32,26.37 v1(199.21,26.37)
  BOTTOM w0.076: 174.78,98.14 174.32,98.14 174.07,98.39 173.45,98.39 173.28,98.21 172.73,98.21 172.62,98.1 172.62,97.86 172.69,97.79 172.87,97.79 CPU1.A8
  BOTTOM w0.099: UH1.L27 199.22,26.37 v1(199.21,26.37) ; v1(176.41,96.87) 176.5,96.87 176.61,96.98 176.61,97.02 176.8,97.21 176.8,97.45 176.11,98.14 174.78,98.14
DMI_CTX_PRX_N1: length 93.4
  IN1 w0.097: v1(196.99,27.41) 196.91,27.49 196.63,27.49 196.02,26.87 195.37,26.87 192.47,29.77 191.75,29.77 188.88,32.63 188.88,33.36 185.4,36.84 185.4,55.15 184.32,56.22 184.32,66.41 183.57,67.17 183.57,70.97 184.32,71.72 184.32,73.54 186.74,75.96 186.74,92.6 183.75,95.6 175.36,95.6 174.89,96.07 174.89,96.7 v1(174.66,96.93)
  BOTTOM w0.076: CPU1.B6 172.33,96.96 172.29,96.91 172.01,96.91 171.96,96.97 171.96,97.12 171.98,97.14 171.98,97.31 172.09,97.42 174.08,97.42 174.09,97.43 174.15,97.43 174.17,97.42 174.17,97.42
  BOTTOM w0.099: 174.17,97.42 174.7,97.42 174.83,97.29 174.83,97.1 v1(174.66,96.93) ; UH1.E24 v1(196.99,27.41)
DMI_CTX_PRX_N2: length 94.4
  IN1 w0.097: v1(176.38,94.96) 176.66,95.04 177.1,94.6 178.34,94.6 178.56,94.82 183.6,94.82 186.09,92.33 186.09,77.08 183.15,74.13 183.15,71.53 182.92,71.3 182.92,66.77 183.57,66.12 183.57,56.06 184.75,54.88 184.75,34.34 190.49,28.61 191.78,28.61 194.75,25.64 197.17,25.64 197.42,25.89 197.42,26.04 v1(197.75,26.37)
  BOTTOM w0.076: CPU1.A5 173.12,96.22 173.33,96.22 173.4,96.28 173.4,96.37 173.24,96.52 173.24,96.57 173.28,96.61 173.43,96.61 173.46,96.59 173.48,96.59
  BOTTOM w0.099: UH1.G27 v1(197.75,26.37) ; v1(176.38,94.96) 176.48,94.86 176.6,94.86 176.76,95.02 176.76,95.42 175.95,96.23 174.32,96.23 173.97,96.59 173.48,96.59
DMI_CTX_PRX_N3: length 98.4
  IN1 w0.097: v1(174.64,94.96) 174.87,94.74 174.87,94.46 175.09,94.23 175.92,94.23 176.34,93.82 178.49,93.82 178.85,94.17 183.27,94.17 185.44,92.01 185.44,77.7 182.16,74.42 182.16,66.61 182.92,65.85 182.92,54.79 183.58,54.13 183.58,51.38 184.1,50.87 184.1,34.07 190.31,27.86 191.2,27.86 194.68,24.38 196.37,24.38 196.49,24.5 199.48,24.5 199.7,24.72 199.7,24.99 199.81,25.1 v1(199.97,25.1)
  BOTTOM w0.076: CPU1.B4 171.95,95.68 171.81,95.68 171.7,95.57 171.7,95.39 171.81,95.28 172.15,95.28 172.22,95.34 172.41,95.34 172.48,95.42 172.48,95.8 172.56,95.87 173.48,95.87 173.52,95.83 173.54,95.83
  BOTTOM w0.099: v1(199.97,25.1) 199.68,25.39 UH1.L29 ; 173.54,95.83 173.62,95.83 173.98,95.47 174.69,95.47 174.76,95.4 174.76,95.08 v1(174.64,94.96)
DMI_CTX_PRX_P0: length 96.7
  IN1 w0.097: v1(176.99,96.87) 176.87,96.87 176.78,96.77 176.78,96.63 176.99,96.42 184.09,96.42 187.57,92.94 187.57,75.51 185.15,73.09 185.15,71.38 184.4,70.63 184.4,67.78 185.15,67.03 185.15,56.57 186.22,55.49 186.22,37.18 189.7,33.7 189.7,32.98 192.09,30.59 192.82,30.59 195.19,28.22 199.14,28.22 199.73,27.64 199.73,26.51 v1(199.85,26.38)
  BOTTOM w0.076: CPU1.B8 172.39,97.96 172.39,98.15 172.43,98.18 172.65,98.41 173.2,98.41 173.37,98.58 174.15,98.58 174.42,98.32 174.76,98.32
  BOTTOM w0.099: v1(199.85,26.38) 200.3,26.83 UH1.N27 ; v1(176.99,96.87) 176.99,97.53 176.19,98.33 174.77,98.33 174.76,98.32
DMI_CTX_PRX_P1: length 94
  IN1 w0.097: v1(175.25,96.93) 175.06,96.75 175.06,96.15 175.43,95.77 183.82,95.77 186.92,92.67 186.92,75.89 184.5,73.47 184.5,71.65 183.74,70.9 183.74,67.24 184.5,66.49 184.5,56.3 185.57,55.22 185.57,36.91 189.05,33.43 189.05,32.71 191.82,29.94 192.55,29.94 195.44,27.05 195.95,27.05 196.68,27.78 197.15,27.78 197.51,27.41 v1(197.75,27.41)
  BOTTOM w0.076: 174.17,97.61 174.03,97.61 174.01,97.59 171.99,97.59 171.79,97.39 171.79,97.22 CPU1.C6
  BOTTOM w0.099: UH1.G24 v1(197.75,27.41) ; 174.17,97.61 174.78,97.61 175.08,97.32 175.08,97.1 v1(175.25,96.93)
DMI_CTX_PRX_P2: length 93.8
  IN1 w0.097: v1(196.99,26.37) 197.25,26.11 197.25,25.96 197.1,25.81 194.82,25.81 191.85,28.78 190.56,28.78 184.92,34.41 184.92,54.95 183.74,56.13 183.74,66.19 183.09,66.84 183.09,71.23 183.32,71.45 183.32,74.06 186.26,77 186.26,92.4 183.67,95 178.49,95 178.27,94.77 177.17,94.77 176.98,94.96 176.98,95.07 177.07,95.17 v1(177.17,95.17)
  BOTTOM w0.076: 173.48,96.83 173.46,96.83 173.43,96.8 172.98,96.8 172.85,96.67 172.51,96.33 CPU1.B5
  BOTTOM w0.099: v1(177.17,95.17) 177,95.33 177,95.45 176.03,96.43 174.48,96.43 174.07,96.83 173.48,96.83 ; UH1.E26 v1(196.99,26.37)
DMI_CTX_PRX_P3: length 97.8
  IN1 w0.097: v1(199.21,25.1) 199.4,25.1 199.53,24.98 199.53,24.79 199.41,24.67 196.41,24.67 196.3,24.55 194.75,24.55 191.27,28.04 190.38,28.04 184.27,34.14 184.27,50.94 183.76,51.46 183.76,54.2 183.09,54.87 183.09,65.92 182.34,66.68 182.34,74.35 185.61,77.62 185.61,92.08 183.35,94.35 178.78,94.35 178.42,93.99 176.41,93.99 176,94.4 175.16,94.4 175.04,94.53 175.04,94.78 v1(175.22,94.96)
  BOTTOM w0.076: CPU1.D4 171.8,95.95 172.35,95.95 172.45,96.05 173.5,96.05 173.52,96.08 173.54,96.08
  BOTTOM w0.099: 173.54,96.08 173.65,96.08 174.06,95.66 174.77,95.66 175,95.43 175,95.19 v1(175.22,94.96) ; UH1.K29 198.92,25.39 v1(199.21,25.1)
DMIC_CLK1_R: length 2.5
  BOTTOM w0.099: UA1.53 33.62,34.76 33.62,34.76 33.62,35.19 33.52,35.29 33.25,35.29 33.16,35.39 33.16,35.67 33.25,35.77 LA6.2
DMIC_DATA1_R: length 2.8
  BOTTOM w0.099: RA19.2 35.33,35.7 35.33,35.02 35.06,34.74 34.13,34.74 34.02,34.63 UA1.54
DP_AUXN_C: length 5.1
  BOTTOM w0.107: UV3.5 229.1,156.56 229.2,156.46 229.68,156.46 229.83,156.31 v3(229.83,156.09) 229.83,155.49 229.61,155.26 228.97,155.26 228.76,155.47 228.76,155.94 228.61,156.09 CV25.1
DP_AUXP_C: length 5.1
  BOTTOM w0.107: UV3.2 231.05,156.76 230.74,156.46 230.2,156.46 230.06,156.32 230.06,155.82 230.05,155.8 230.05,155.4 229.69,155.03 v3(229.09,155.03) 228.89,155.03 228.66,155.26 228.23,155.26 CV24.1
DP_CBL_DET: length 28
  IN4 w0.097: v1(232.8,168.74) 229.55,168.74 227.38,166.57 227.38,161.22 228.77,159.83 231.82,159.83 232.23,159.42 232.23,158.72 231.34,157.83 231.34,155.54 230.77,154.97 v1(230.58,154.97)
  BOTTOM w0.107: JDP.4 232.97,169.41 232.8,169.24 v1(232.8,168.74) ; UV3.1 231.7,156.11 RV17.1 231.85,155.73 231.09,154.97 v1(230.58,154.97)
DP_HPD_GPU: length 133.5
  TOP w0.107: UX1.4 226.87,160.84 227.11,161.08 228.35,161.08 228.86,160.57 v1(228.86,159.42) 229.3,159.42 RX5.2
  IN2 w0.091: v1(208.42,85.25) 206.29,85.25 205.19,86.35 205.19,90.68 204.84,91.02 204.84,97.32 203.68,98.48 203.68,110.79 203.35,111.12 203.35,120.07 201.37,122.05 201.37,144.19 205.39,148.21 211.01,148.21 211.98,149.18 215.31,149.18 216.4,150.27 218.45,150.27 219.15,150.97 225.64,150.97 227.41,152.74 227.41,157.97 228.86,159.42 228.86,159.42 v1(228.86,159.42)
  IN3 w0.091: v1(213.62,88.74) 213.12,88.74 212.47,88.1 212.47,86.99 210.98,85.5 208.67,85.5 v1(208.42,85.25)
  IN4 w0.089: 215.65,85.23 216.47,84.4 220.13,84.4 220.6,84.87 224.33,84.87 225.84,83.35 228.24,83.35 229.62,84.74 v1(229.62,84.75)
  IN4 w0.097: v1(213.62,88.74) 214.31,88.05 214.31,86.57 215.65,85.23
  BOTTOM w0.135: v1(229.62,84.75) 229.77,84.75 UG1.AU29
DP_HPD_PCH: length 197.2
  TOP w0.107: v1(226.58,162.97) 225.13,162.97 224.29,162.14 UX1.1 223.53,162.14 223.27,161.88 RX4.1
  IN2 w0.091: v1(204.95,79.48) 204.75,79.68 204.75,90.5 204.41,90.84 204.41,97.14 203.24,98.3 203.24,110.6 202.91,110.94 202.91,119.89 200.93,121.87 200.93,146.12 203.86,149.05 210.75,149.05 211.32,149.62 215.12,149.62 216.96,151.45 225.48,151.45 226.88,152.85 226.88,158.16 226.37,158.67 226.37,162.76 v1(226.58,162.97)
  IN3 w0.089: v1(211.78,17.75) 209.17,17.75 208.15,18.78 206.52,18.78 205.58,19.72 205.32,19.72 204.9,20.14 204.9,21.14 204.7,21.34 203.98,21.34 203.61,20.97 203.04,20.97 202.13,21.88 201.85,21.88 201.53,22.2 201.53,23.3 200.72,24.12 200.72,26.56 200.02,27.26 200.02,32.53 200.33,32.84 200.34,32.84 200.55,33.05 200.55,33.75 200.41,33.88 200.41,38.52 200.09,38.84 199.01,38.84 198.3,39.55 198.3,42.08
  IN3 w0.091: 198.3,42.08 198.3,48.15 194.03,52.42 194.03,53.07 193.33,53.77 193.33,68.81 197.31,72.78 198,72.78 198.27,73.06 199.28,73.06 200.57,74.35 200.57,76.99 201.06,77.48 203.16,77.48 204.95,79.27 v1(204.95,79.48)
  BOTTOM w0.089: UH1.AT44 212,17.97 v1(211.78,17.75)
  BOTTOM w0.107: QX2.3 227.83,165.66 226.58,164.41 v1(226.58,162.97)
DPSNK_RBIAS: length 2
  TOP w0.089: UT1.Y18 v1(183.26,161.2)
  BOTTOM w0.107: RT19.1 183.88,161.83 v1(183.26,161.2) 183.26,160.95 v2(183.52,160.69)
DPSRC_RBIAS: length 1.4
  TOP w0.102: v1(178.7,163.81) UT1.N6
  BOTTOM w0.127: v1(178.7,163.81) 178.6,163.81 RT5.1
DRAIN: length 1.4
  TOP w0.089: v1(239.22,88.75) 238.89,88.42 TV9.1
  BOTTOM w0.089: UG1.AM20 238.77,89.2 v1(239.22,88.75)
DRAM_RST#_AB: length 88.6
  TOP w0.107: RG63.2 255.55,117.82 v1(256.3,118.58)
  TOP w0.135: RG65.1 255.46,113.05 255.55,113.13 RG63.2
  IN3 w0.089: 257.01,120.36 256.3,119.66 v1(256.3,118.58) ; v1(248.27,137.2) 248.71,137.64 249.69,137.64 250.83,138.78 254.58,138.78 255.79,139.99 257.63,139.99 258.46,139.16
  IN3 w0.091: 257.01,120.36 260.25,123.6 260.25,137.37 258.46,139.16
  IN4 w0.1: v1(248.27,137.2) 248.17,137.2 247.77,136.8 242.67,136.8 v1(242.27,137.2) ; v1(220.27,137.2) 219.9,136.83 215.44,136.83 214.3,137.97 v1(214.3,137.97)
  IN4 w0.119: v1(242.27,137.2) 241.85,137.62 241.85,142.16 241.61,142.4 239.76,142.4 239.44,142.08 237.37,142.08 237.18,141.89 237.18,137.06 236.94,136.81 224.61,136.81 224.48,136.68 223.78,136.68 223.66,136.81 220.61,136.81 220.27,137.15 v1(220.27,137.2)
  BOTTOM w0.089: UG13.J2 214.3,137.97 v1(214.3,137.97) ; UG16.J2 v1(248.27,137.2) ; UG15.J2 242.67,137.6 v1(242.27,137.2) ; UG14.J2 v1(220.27,137.2)
DRAM_RST#_CD: length 60.8
  TOP w0.089: RG81.1 RG80.2 ; 267.64,89 274.24,89 274.63,88.61 v1(274.92,88.61)
  TOP w0.107: 267.64,89 265.98,90.66 259.09,90.66 258.28,91.47 255.96,91.47 RG80.2
  IN3 w0.1: v1(274.92,110.61) 275.32,110.21 275.32,100.04 274.18,98.9 v1(273.76,98.9)
  IN4 w0.089: 273.95,98.71 274.56,98.1 274.56,94.06 275.34,93.28 275.34,89.04 v1(274.92,88.61)
  IN4 w0.097: v1(273.76,98.9) 273.95,98.71
  IN4 w0.1: v1(274.92,116.61) 275.54,116 275.54,111.23 v1(274.92,110.61) ; v1(274.92,88.61) 275.32,88.21 UG20.J2 v1(274.92,82.61)
  BOTTOM w0.089: UG17.J2 v1(274.92,116.61) ; UG18.J2 v1(274.92,110.61) ; UG20.J2 v1(274.92,82.61) ; UG19.J2 v1(274.92,88.61)
DRAM_RST#_RA: length 33.8
  TOP w0.089: v1(245.25,110.03) 245.69,110.47 248.1,110.47 v2(249.35,111.72) 250.03,112.4 RG620.1
  IN3 w0.089: v1(228.62,102.18) 228.19,102.61 228.19,105.98 228.49,106.28 242.93,106.28 243.38,106.72 243.38,107.58 243.83,108.03 245.36,108.03 245.65,108.32 245.65,109.62 v1(245.25,110.03)
  BOTTOM w0.089: v1(228.62,102.18) 229.02,101.78 UG1.W30
DRAM_RST#_RB: length 13.3
  TOP w0.089: RG68.2 253.71,110.28 253.25,109.81 v2(247.53,109.81) ; RG68.2 253.71,112.18 RG620.2 ; RG68.2 RG66.2
  TOP w0.1: v1(245.22,108.45) 245.22,108.73 246.17,109.68 247.01,109.68 247.14,109.81 v2(247.53,109.81)
  BOTTOM w0.1: v1(245.22,108.45) 245.07,108.45 UG1.M14
DRAM_RST#_RC: length 3.1
  TOP w0.089: v2(248.56,107.13) 248.09,107.6 RG621.1 247.54,107.6 246.92,106.98 v1(246.74,106.98)
  BOTTOM w0.089: v1(246.74,106.98) 246.22,106.45 UG1.P12
DRAM_RST#_RD: length 37.5
  TOP w0.089: v1(244.29,107.18) 244.29,107.48 244.81,108.01 245.89,108.01 246.3,107.6 RG621.2 ; RG82.2 252.16,92.71 v2(251.99,92.54) 251.45,92 RG85.2 251.05,91.12 250.77,90.84 249.72,90.84 249.47,90.58
  TOP w0.1: v1(245.82,90.33) 245.94,90.33 246.47,89.8 249.24,89.8 249.47,90.03 249.47,90.58
  IN3 w0.089: v1(244.29,107.18) 244.34,107.13 244.34,106.32 244.06,106.05 244.06,105.55 244.55,105.06 244.55,93.76 246.27,92.03 246.27,90.84 245.82,90.38 v1(245.82,90.33)
  IN3 w0.1: v1(240.42,90.35) 240.82,89.95 244.2,89.95 244.95,90.7 245.45,90.7 v1(245.82,90.33)
  BOTTOM w0.135: v1(240.42,90.35) 240.27,90.35 UG1.AK19
DRVON: length 154.2
  TOP w0.254: v1(192.1,61.47) 192.89,62.26 192.89,75.14 191.72,76.31 191.72,84.61 193.05,85.95 193.05,88.31 v2(195.05,90.3) 195.63,90.88 199.7,90.88 200.42,91.6 v1(200.61,91.6)
  IN1 w0.254: v1(266.84,52.91) 265.96,52.04 257.91,52.04 257.59,52.36 249.4,52.36 247.82,53.94 v1(246.76,53.94) 246.76,53.37 245.88,52.48 240.76,52.48 239.3,53.94 v1(238.2,53.94) 238.2,53.05 237.5,52.36 232.33,52.36 230.74,53.94 v1(229.62,53.94)
  IN4 w0.254: v1(229.62,53.94) 229.62,53.64 229.37,53.38 223.08,53.38 221.53,54.94 v1(220.93,54.94) 215.18,54.94 209.95,60.17 208.48,60.17 207.91,60.74 206.28,60.74 205.6,61.42 197.42,61.42 196.15,62.69 194.3,62.69 193.08,61.47 v1(192.1,61.47) ; v1(266.84,52.91) 266.79,52.91 266.26,53.44 266.26,55.02 266.77,55.53 269.49,55.53 269.9,55.12 269.9,52.41 270.58,51.72 279.47,51.72 280.74,52.99 280.74,55.59 281.69,56.55 v1(282.08,56.55)
  BOTTOM w0.203: v1(282.08,56.55) 282.2,56.55 282.41,56.34 PU8201.32 ; PU6102.2 247.19,54.3 246.83,53.94 v1(246.76,53.94) ; v1(266.84,52.91) 266.9,52.91 267.26,53.28 PU6400.2 ; v1(229.62,53.94) 229.69,53.94 230.05,54.31 PU6202.2 ; PU6201.2 238.63,54.31 238.26,53.94 v1(238.2,53.94) ; v1(220.93,54.94) 221,54.94 221.36,55.3 PU6301.2
  BOTTOM w0.254: v1(200.61,91.6) 200.61,91.62 200.86,91.87 DG1.2
EAPD#: length 9.6
  TOP w0.107: v1(33.22,34.89) 33.29,34.81 v2(33.29,34.39) 33.63,34.04 RA21.2 34.22,34.07 RA22.1 34.69,34.77 34.71,34.75 35.13,34.75 35.36,34.98 35.36,38.93 DA3.2
  BOTTOM w0.107: UA1.52 v1(33.22,34.89)
EC_AC_BAT#: length 210.9
  TOP w0.107: v1(334.61,42.07) 334.23,42.45 UE6.9
  IN2 w0.091: v1(212.74,117.51) 212.48,117.25 211.98,117.25 210.86,116.14 210.86,114.41 209.23,112.78 209.23,91.76 210.55,90.44 211.41,90.44 211.72,90.13 211.72,89.5 210.19,87.98 210.19,84.71 209.75,84.26 209.75,75.6 206.65,72.5 206.65,69.62 207.21,69.06 209.88,69.06 211.8,67.13 223.12,67.13 223.58,67.6 223.62,67.64 223.76,67.64 223.91,67.79 249.94,67.79 250.13,67.6 263.79,67.6 264.57,68.38 274.97,68.38 279.57,63.78 280.38,63.78 280.79,63.37 280.79,48.29 282.04,47.04 288.25,47.04 288.83,47.62 292.23,47.62 292.93,48.32 297.93,48.32 298.98,49.36 309.59,49.36 309.83,49.6 317.33,49.6 318.65,48.28 330.47,48.28 333.88,44.87 333.88,42.8 v1(334.61,42.07)
  BOTTOM w0.107: v1(212.74,117.51) 213.03,117.8 UG4.2 212.95,118.49 RG40.2 212.05,119.75 v2(212.01,119.79)
EC_ESB_CLK: length 64.7
  TOP w0.107: v1(329.51,40.61) 329.51,40.2 329.78,39.93 329.93,39.93 330.04,40.04 UE6.1 ; UE5.17 299.14,25.29 298.43,25.99 v2(298.43,33.1) 298.43,34.07 298.05,34.45 298.05,39.34 299.45,40.73 299.45,42.48 300.26,43.3 300.26,44.95 300.91,45.6 302.78,45.6 RE642.2 302.88,46.15 302.99,46.26 304.36,46.26 305.7,47.59 v1(305.89,47.59) 306.33,47.59 307.05,48.31 UE10.1
  IN1 w0.097: v1(305.89,47.59) 305.48,47.59 305.32,47.75 305.32,48.15 305.48,48.31 306.12,48.31 307.18,47.25 327.44,47.25 329.64,45.05 329.64,40.71 329.54,40.61 v1(329.51,40.61)
EC_ESB_DAT: length 65.8
  TOP w0.107: RE643.2 301.63,46.83 301.49,46.68 301.49,46.47 v1(301.51,46.45) 301.43,46.45 300.03,45.05 300.03,43.4 299.02,42.39 299.02,40.64 297.82,39.44 297.82,34.21 298.1,33.93 v2(298.1,31.76) 298.1,31.57 298.2,31.47 298.2,25.74 298.74,25.2 UE5.18 ; UE6.4 331.54,40.17 v1(331.92,39.79) ; UE10.4 v1(308.55,47.66)
  IN1 w0.097: v1(331.92,39.79) 331.41,39.79 329.86,41.34 329.86,45.15 327.53,47.48 308.73,47.48 v1(308.55,47.66) 308.37,47.48 307.28,47.48 306.21,48.55 305.25,48.55 303.16,46.45 v1(301.51,46.45)
EC_MUTE#: length 327.2
  TOP w0.107: UE10.11 v1(311.21,51.58) ; DA3.3 v1(35.79,38.83)
  IN2 w0.091: v1(35.79,38.83) 35.79,43.94 37.93,46.08 49.16,46.08 49.87,45.37 52.28,45.37 53.8,46.88 55.99,46.88 56.01,46.9 57.11,46.9 57.91,46.1 91.53,46.1 92.24,45.39 93.11,45.39 93.84,44.66 97.98,44.66 98.19,44.45 105.69,44.45 109.29,40.84 110.69,40.84 112.84,38.69 134.61,38.69 138.61,34.69 154.76,34.69 156.25,36.18 173.25,36.18 174.05,35.38 178.14,35.38 184.18,41.41 197.85,41.41 198.88,42.44 202.44,42.44 202.82,42.06 204.75,42.06 205.31,42.62 207.22,42.62 207.72,43.12 212.25,43.12 212.84,42.53 213.54,42.53 213.79,42.78 214.13,42.78 214.31,42.59 222.1,42.59 222.81,41.88 226.77,41.88 228.65,40 256.82,40 257.6,40.78 261.94,40.78 271.61,31.12 273.11,31.12 273.62,30.61 280.94,30.61 285.38,26.17 290.63,26.17 295.1,21.7 296.94,21.7 297.8,22.55 299.37,22.55 v1(299.6,22.32)
  BOTTOM w0.107: v1(299.6,22.32) 300.96,22.32 303.85,25.21 303.85,27.1 306.38,29.63 306.38,41.55 v2(310.43,45.59) 310.88,46.04 310.88,51.25 v1(311.21,51.58)
EC_ON: length 276.4
  TOP w0.107: UE5.112 304.59,15.81 303.83,15.05 300.77,15.05 300.53,15.29 300.53,17.26 299.72,18.07 299.72,21.11 v1(299.92,21.3) ; v1(59.36,45.34) 59.36,45.76 59.23,45.89 PD100.2
  IN2 w0.091: v1(299.92,21.3) 299.74,21.48 294.76,21.48 293.94,22.3 293.17,23.07 291.46,23.07 289.33,25.19 286.59,25.19 285.82,25.95 285.29,25.95 280.85,30.4 273.53,30.4 273.02,30.9 271.52,30.9 261.85,40.57 257.69,40.57 256.91,39.78 242,39.78 241.22,39 240.05,39 239.48,39.56 228.78,39.56 226.68,41.66 222.72,41.66 222.01,42.37 216.34,42.37 215.51,41.54 214.34,41.54 214.03,41.23 213.83,41.23 212.16,42.9 207.81,42.9 207.31,42.4 205.4,42.4 204.87,41.86 204.69,41.86 204.67,41.88 202.9,41.88 202.89,41.86 202.71,41.86 202.35,42.22 199.14,42.22 198.11,41.19 184.27,41.19 178.23,35.16 173.96,35.16 173.16,35.96 156.34,35.96 154.85,34.47 138.52,34.47 134.52,38.47 112.75,38.47 110.59,40.63 109.2,40.63 105.6,44.23 98.1,44.23 97.89,44.44 93.73,44.44 93.01,45.17 92.1,45.17 91.39,45.88 90.24,45.88 90.21,45.85 59.57,45.85 59.36,45.64 v1(59.36,45.34)
  BOTTOM w0.107: v2(59.66,45.88) 59.66,45.64 v1(59.36,45.34)
EC_RSMRST#: length 136.3
  TOP w0.089: RH88.2 213.06,35.87 v1(213.77,35.17)
  TOP w0.107: v1(302.96,12.93) 304.88,11.01 UE5.100
  IN3 w0.091: v1(225.72,32.74) 225.72,32.26 226.52,31.46 226.52,25.35 228.55,23.32 229.68,23.32 230.12,22.87 232.58,22.87 232.77,22.68 239.87,22.68 240.55,22 245.34,22 245.66,22.32 250.61,22.32 252.84,24.56 257.15,24.56 258.67,26.08 262.34,26.08 265.63,29.37 269.9,29.37 270.14,29.61 274.5,29.61 275.2,30.31 281.19,30.31 283.54,27.96 290.7,27.96 293.89,24.78 301.31,24.78 303.86,22.22 303.86,13.83 v1(302.96,12.93)
  IN4 w0.097: v1(213.77,35.17) 214.17,34.77 215.59,34.77 216.61,33.75 219.45,33.75 220.64,32.56 223.34,32.56 224.5,33.72 225.28,33.72 225.72,33.29 v1(225.72,32.74)
  BOTTOM w0.089: v1(213.77,35.17) 214.27,34.67 UH1.BA11
  BOTTOM w0.107: DE2.2 222.03,41.65 222.03,41.52 224.39,39.16 v2(224.39,34.49) 224.39,32.87 224.94,32.32 225.3,32.32 v1(225.72,32.74)
EC_RTCRST: length 32.1
  TOP w0.107: UE5.34 292.66,21.81 292.88,22.04 292.88,22.59 290.36,25.11 290.36,25.8 288.08,28.07 288.08,37.38 287.55,37.92 287.55,39.39 287.66,39.5 v2(289.18,39.5) 293.63,39.5 294.21,40.08 QE5.2 294.21,43.36 293.75,43.82 RE650.1
EC_RX: length 73.4
  TOP w0.107: v1(294.84,10.37) 294.39,10.81 294.39,12.99 294.7,13.3 294.7,17.83 294.22,18.31 294.22,22.21 293.54,22.9 UE5.31 293.54,24.79 294.4,25.65 294.4,27.29 292.03,29.66 292.03,32.44 v2(290.85,33.62) 289.15,35.33 v1(289.15,37.46)
  IN1 w0.097: v1(289.15,37.46) 290.36,37.46 290.74,37.85 296.21,37.85 299.62,41.26 299.62,42.28 301.41,44.07 306.04,44.07 307.27,42.85 v1(309.57,42.85)
  BOTTOM w0.107: JWLAN.32 310.07,42.35 v1(309.57,42.85) ; v1(294.84,10.37) 294.66,10.19 292.11,10.19 290.93,9.02 286.41,9.02 285.22,7.83 283.68,7.83 283.22,8.29 283.22,10.95 283.71,11.44 JEC.7
EC_SCI#: length 114.8
  TOP w0.089: RH521.2 206.92,22.05 208.05,22.05 208.16,21.94 v2(210.32,21.94) 211.4,21.94 211.65,22.19 211.65,23.15 212.16,23.66 212.16,24.25 212.61,24.69 212.61,26.18 v1(212.75,26.31)
  TOP w0.107: UE5.20 297.94,21.51 297.48,21.06 297.48,14.34 v1(297.03,13.89)
  IN2 w0.091: v1(297.03,13.89) 296.84,14.07 295.09,14.07 294.72,14.43 292.05,14.43 291.35,15.13 278.12,15.13 274.17,19.08 272.27,19.08 271.32,20.02 269.46,20.02 268.03,18.59 265.56,18.59 263.92,16.94 262.78,16.94 262,16.16 255.98,16.16 255.33,16.81 231.47,16.81 231.07,17.21 228.74,17.21 226.7,19.25 226.7,20.19 222.16,24.73 217.24,24.73 216.29,25.69 213.37,25.69 v1(212.75,26.31)
  BOTTOM w0.089: v1(212.75,26.31) 212.88,26.18 UH1.AV29
EC_SMB_CK1: length 286
  TOP w0.107: PR721.1 52.61,21.43 52.28,21.43 v1(52.14,21.29) ; RE90.4 298.2,6.81 297.94,7.08 UE5.77 297.94,9.06 298.01,9.13 298.01,9.19 298.01,9.2 298.01,9.55 297.84,9.72 297.84,9.94 v1(297.65,10.13) ; PR19.2 82.18,13.04 82.18,13.56 82.3,13.68 83.27,13.68 83.51,13.93 83.51,14.1 PD2.2 83.51,14.86 v3(83.51,16.03) 83.51,16.85 83.83,17.16 83.83,17.91 v1(83.98,18.07)
  IN1 w0.097: v1(297.65,10.13) 297.8,10.28 297.8,11.02 297.46,11.36 296.34,11.36 295.3,12.4 293.52,12.4 292.28,13.65 278.27,13.65 277.99,13.93 275.9,13.93 274.49,12.51 265.18,12.51 264.65,11.98 241.38,11.98 240.16,10.76 233.9,10.76 232.78,9.64 226.13,9.64 225.36,8.87 214.2,8.87 213.86,8.53 193.41,8.53 192.73,9.2 186.67,9.2 178.28,17.59 178.28,19.43 177.36,20.35 176.92,20.35 176.76,20.19 176.76,20.08 v1(176.93,19.91)
  IN4 w0.097: v1(52.14,21.29) 52.32,21.47 53.22,21.47 53.7,21 53.7,15.24 56.34,12.6 72.27,12.6 74.25,14.58 82.15,14.58 83.73,16.16 83.73,17.82 v1(83.98,18.07) 83.8,18.25 83.8,18.41 83.9,18.51 91.77,18.51 97.73,12.55 104.26,12.55 104.59,12.21 109.94,12.21 114.2,16.48 135.07,16.48 137.7,19.11 176.44,19.11 176.76,19.43 176.76,19.74 v1(176.93,19.91)
EC_SMB_CK2: length 472.5
  TOP w0.107: v1(211.78,122.78) 212.25,122.31 212.25,121.48 211.9,121.13 205.29,121.13 204.28,120.11 201.3,120.11 v1(201.12,120.29) 200.99,120.15 197.91,120.15 197.34,120.73 192.97,120.73 v1(192.79,120.9) ; v1(298.39,20.09) 298.47,20.18 298.72,20.18 298.82,20.07 298.82,9.25 298.74,9.17 UE5.79 298.74,7.28 299.2,6.81 RE90.2
  IN1 w0.097: v1(182.39,26.32) 182.64,26.32 183.11,25.85 183.11,20.83 183.36,20.58 183.36,17.77 185.59,15.53 189.25,15.53 192.97,11.81 197.93,11.81 198.06,11.94 203.56,11.94 203.81,11.69 205.25,11.69 v1(205.66,12.09) 205.85,12.28 205.98,12.28 206.27,12 213.84,12 214.09,12.25 230.11,12.25 231.22,13.37 238.52,13.37 240.42,15.27 241.98,15.27 242.96,16.25 245.22,16.25 246.36,15.11 258.32,15.11 259.77,16.57 259.77,18.97 262.64,21.84 271.56,21.84 272.21,22.49 279.44,22.49 281.65,20.27 298.21,20.27 v1(298.39,20.09)
  IN3 w0.091: v1(140.77,157.36) 140.6,157.53 140.6,158.27 140.95,158.62 143.23,158.62 146,161.39 146,163.12 145.62,163.5 145.62,166.47 149.49,170.34 149.49,172.31 151.43,174.25 159.57,174.25 160.08,173.74 160.08,172.92 159.54,172.39 159.54,171.02 159.96,170.61 160.57,170.61 161.91,169.27 161.91,167.83 164.45,165.29 164.45,161.49 166.48,159.45 167.74,159.45 168.38,158.81 168.38,158.37 169.65,157.1 170.21,157.1 171.33,155.99 172.09,155.99 172.56,156.45 173.34,156.45 173.47,156.33 175.29,156.33 175.38,156.42 175.86,156.42 176.27,156 179.62,156 181.23,154.4 187.72,154.4 194.03,148.08 194.03,121.49 193.25,120.72 192.98,120.72 v1(192.79,120.9) 192.61,120.72 190.76,120.72 189.34,119.3 189.34,111.41 190.52,110.24 191.04,110.24 194.85,106.43 197.28,106.43 198.35,105.35 198.35,100.07 200.54,97.89 200.54,95.65 198.65,93.76 194.95,93.76 194.35,94.36 191.92,94.36 186.13,88.56 186.13,74.64 185.43,73.94 185.43,73.12 184.26,71.95 184.26,63.05 185.9,61.41 185.9,30.47 183.83,28.4 182.55,28.4 182.04,27.89 182.04,26.98 182.39,26.63 v1(182.39,26.32)
  BOTTOM w0.107: v1(140.77,157.36) 140.6,157.18 140.6,156.86 140.07,156.33 137.45,156.33 137.3,156.18 UM8.50 ; U2407.10 185.19,46.41 185.33,46.27 185.33,44.63 183.78,43.08 183.78,32.3 181.56,30.08 181.56,27.32 182.38,26.5 182.39,26.5 v1(182.39,26.32) ; QG1.3 212.63,121.88 212.38,122.14 212.38,122.18 v1(211.78,122.78) ; v1(201.12,120.29) 200.98,120.14 200.83,120.14 200.57,120.4 200.57,122.05 200.78,122.26 v3(200.78,122.97) 200.78,145.05 204.34,148.61 204.34,149.78 205.25,150.68 205.25,151.89 RT60.1 ; v1(205.66,12.09) 206.61,13.05 209.42,13.05 209.67,13.29 209.67,13.37 209.99,13.69 210.77,13.69 211.27,14.19 211.27,15.21 211,15.48 QH5.1
EC_SMB_DA1: length 286.4
  TOP w0.107: v1(52.14,21.88) 52.35,21.67 52.57,21.67 PR720.1 ; v1(298.23,10.13) 298.07,9.97 298.07,9.82 298.25,9.64 298.25,9.2 298.34,9.1 UE5.78 298.34,7.12 298.7,6.76 RE90.3 ; PR21.2 81.94,13.09 81.94,13.65 82.21,13.92 83.17,13.92 83.28,14.02 83.28,14.1 PD2.3 83.28,14.86 83.28,16.95 83.6,17.26 83.6,17.87 v1(83.4,18.07)
  IN1 w0.097: v1(176.35,19.91) 176.54,20.1 176.54,20.28 176.83,20.58 177.45,20.58 178.51,19.52 178.51,17.69 186.77,9.43 192.83,9.43 193.5,8.75 213.77,8.75 214.1,9.09 225.26,9.09 226.04,9.87 232.69,9.87 233.81,10.98 240.07,10.98 241.29,12.2 264.55,12.2 265.08,12.73 274.39,12.73 275.81,14.15 278.08,14.15 278.36,13.87 292.37,13.87 293.62,12.63 295.39,12.63 296.43,11.58 297.55,11.58 298.02,11.11 298.02,10.34 v1(298.23,10.13)
  IN4 w0.097: v1(176.35,19.91) 176.54,19.72 176.54,19.53 176.35,19.34 137.61,19.34 134.98,16.7 114.11,16.7 109.84,12.43 104.69,12.43 104.35,12.77 97.82,12.77 91.86,18.73 83.81,18.73 83.58,18.51 83.58,18.25 v1(83.4,18.07) 83.51,17.95 83.51,16.26 82.06,14.81 74.16,14.81 72.18,12.83 56.43,12.83 53.92,15.34 53.92,21.09 53.31,21.7 52.32,21.7 v1(52.14,21.88)
EC_SMB_DA2: length 472.8
  TOP w0.107: v1(212.98,124.17) 212.48,123.67 212.48,121.38 211.99,120.89 205.39,120.89 204.37,119.88 201.3,119.88 v1(201.12,119.7) 200.91,119.92 197.81,119.92 197.24,120.49 192.97,120.49 v1(192.79,120.32) ; v1(298.39,20.68) 298.65,20.41 298.81,20.41 299.06,20.17 299.06,9.25 299.14,9.17 UE5.80 299.14,8.18 299.14,7.21 299.7,6.65 RE90.1
  IN1 w0.097: v1(182.8,26.73) 182.8,26.48 183.34,25.94 183.34,20.92 183.58,20.68 183.58,17.86 185.68,15.75 189.34,15.75 193.06,12.03 197.84,12.03 197.97,12.16 203.65,12.16 203.9,11.91 204.87,11.91 v1(205.05,12.09) 205.46,12.51 206.08,12.51 206.36,12.22 213.75,12.22 214,12.47 230.01,12.47 231.13,13.59 238.42,13.59 240.33,15.5 241.89,15.5 242.87,16.47 245.31,16.47 246.45,15.34 258.23,15.34 259.55,16.66 259.55,19.06 262.55,22.06 271.46,22.06 272.11,22.71 279.53,22.71 281.74,20.5 298.21,20.5 v1(298.39,20.68)
  IN3 w0.091: v1(140.19,157.36) 140.38,157.55 140.38,158.36 140.86,158.84 143.14,158.84 145.78,161.48 145.78,163.03 145.4,163.41 145.4,166.56 149.27,170.43 149.27,172.4 151.34,174.47 159.66,174.47 160.3,173.83 160.3,172.83 159.76,172.29 159.76,171.11 160.05,170.83 160.66,170.83 162.12,169.36 162.12,167.92 164.66,165.38 164.66,161.58 166.57,159.67 167.83,159.67 168.6,158.9 168.6,158.46 169.74,157.32 170.3,157.32 171.42,156.21 172,156.21 172.47,156.67 173.43,156.67 173.56,156.54 175.2,156.54 175.29,156.64 175.95,156.64 176.36,156.22 179.71,156.22 181.32,154.61 187.81,154.61 194.25,148.17 194.25,121.4 193.34,120.5 192.98,120.5 v1(192.79,120.32) 192.61,120.5 190.85,120.5 189.56,119.21 189.56,111.5 190.61,110.45 191.13,110.45 194.94,106.65 197.37,106.65 198.57,105.44 198.57,100.16 200.76,97.98 200.76,95.56 198.74,93.54 194.86,93.54 194.26,94.14 192.01,94.14 186.34,88.47 186.34,74.54 185.65,73.85 185.65,73.03 184.48,71.86 184.48,63.14 186.11,61.5 186.11,30.38 183.92,28.18 182.64,28.18 182.25,27.8 182.25,27.07 182.6,26.73 v1(182.8,26.73)
  BOTTOM w0.107: v1(212.98,124.17) 213.44,124.17 213.93,123.67 QG1.6 ; v1(201.12,119.7) 200.92,119.91 200.73,119.91 200.33,120.31 200.33,122.15 200.54,122.36 200.54,145.14 204.11,148.71 204.11,149.88 205.01,150.78 205.01,151.99 RT59.1 ; v1(205.05,12.09) 205.46,12.51 205.72,12.51 206.49,13.28 209.33,13.28 209.43,13.39 209.43,13.53 208.79,14.18 QH5.4 ; U2407.9 185.69,46.41 185.56,46.27 185.56,44.54 184.01,42.99 184.01,32.21 181.79,29.98 181.79,27.42 182.48,26.73 v1(182.8,26.73) ; v1(140.19,157.36) 140.36,157.18 140.36,156.96 139.97,156.57 137.56,156.57 137.52,156.61 137.5,156.61 137.43,156.68 UM8.49
