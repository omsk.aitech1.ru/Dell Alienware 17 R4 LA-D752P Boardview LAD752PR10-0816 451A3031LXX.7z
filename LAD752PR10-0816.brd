# Allegro board LAD752PR10-0816.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
FBC_D25: length 24.2
  IN4 w0.089: v1(253.27,107) 253.72,106.55
  IN4 w0.119: v1(268.52,118.21) 268.52,117.95 268.14,117.57 268.14,116.85 267.72,116.42 267.72,112.93 264.37,109.58 261.02,109.58 257.99,106.55 253.72,106.55
  BOTTOM w0.089: v1(268.52,118.21) 268.92,117.81 UG17.U4 ; UG1.P4 253.27,106.85 v1(253.27,107)
FBC_D26: length 29.9
  IN4 w0.089: 250.67,106.6 v1(249.87,105.8)
  IN4 w0.119: 250.67,106.6 252.62,106.6 253.35,105.87 259.18,105.87 261.88,108.58 265.15,108.58 269.06,112.48 269.06,115.55 268.92,115.68 268.92,117.81 v1(269.32,118.21)
  BOTTOM w0.089: UG17.T4 269.72,117.81 v1(269.32,118.21) ; v1(249.87,105.8) 249.87,105.65 UG1.R8
FBC_D27: length 28.2
  IN4 w0.119: v1(269.32,116.61) 269.7,116.24 269.7,115.46 269.53,115.29 269.53,112.52 268.94,111.93 268.94,110.5 268.68,110.24 268.36,110.24 268.1,109.97 268.1,109.66 267.88,109.44 267.53,109.44 266.24,108.15 262.13,108.15 259.43,105.45 256.77,105.45 256.64,105.58 253.19,105.58 252.57,106.2 251.87,106.2 v1(251.47,105.8)
  BOTTOM w0.089: UG17.T2 269.72,116.21 v1(269.32,116.61) ; v1(251.47,105.8) 251.47,105.65 UG1.R6
FBC_D28: length 34
  IN4 w0.089: 251.19,105.12 v1(250.67,104.6)
  IN4 w0.119: v1(271.72,116.61) 272.1,116.24 272.1,112.32 271.34,111.57 271.34,110.5 271.03,110.19 270.77,110.19 270.5,109.92 270.5,108.86 270.28,108.64 270.01,108.64 269.7,108.32 269.7,108.06 269.48,107.84 268.77,107.84 268.17,107.24 268.17,106.34 267.64,105.81 263.21,105.81 260.5,103.11 258.1,103.11 257.14,104.07 255.51,104.07 254.96,104.62 252.84,104.62 252.33,105.12 251.19,105.12
  BOTTOM w0.089: UG1.U7 250.67,104.45 v1(250.67,104.6) ; UG17.N2 v1(271.72,116.61)
FBC_D29: length 33.3
  IN4 w0.089: 252.04,104.3 251.74,104.6 v1(251.47,104.6)
  IN4 w0.119: 252.04,104.3 254.64,104.3 255.13,103.82 256.97,103.82 258.1,102.69 260.68,102.69 263.38,105.39 267.83,105.39 271.34,108.9 271.34,110.01 271.57,110.24 271.88,110.24 272.14,110.5 272.14,111.57 272.57,112 272.57,115.24 272.9,115.57 272.9,116.24 v1(272.52,116.61)
  BOTTOM w0.089: UG17.M2 v1(272.52,116.61) ; v1(251.47,104.6) 251.47,104.45 UG1.U6
FBC_D30: length 37.6
  IN4 w0.089: 250.25,103.78 v1(249.87,103.4)
  IN4 w0.119: v1(272.52,118.21) 272.52,117.95 273.7,116.77 273.7,112.32 272.94,111.57 272.94,110.5 272.1,109.66 272.1,108.86 271.88,108.64 271.43,108.64 267.76,104.96 263.56,104.96 260.86,102.26 258.1,102.26 257.02,103.35 254.76,103.35 254.33,103.78 250.25,103.78
  BOTTOM w0.089: UG17.N4 272.12,117.81 v1(272.52,118.21) ; v1(249.87,103.4) 249.87,103.25 UG1.V8
FBC_D31: length 37.9
  IN4 w0.089: v1(250.67,103.4) 251.05,103.02
  IN4 w0.119: 251.05,103.02 255.96,103.02 257.15,101.84 261.03,101.84 263.21,104.01 267.17,104.01 271.26,108.11 271.71,108.11 272.23,108.64 272.68,108.64 272.9,108.86 272.9,109.66 273.74,110.5 273.74,111.57 274.62,112.44 274.62,115.58 274.5,115.7 274.5,116.77 274.28,116.99 274.01,116.99 273.74,117.26 273.74,117.79 v1(273.32,118.21)
  BOTTOM w0.089: UG17.M4 272.92,117.81 v1(273.32,118.21) ; v1(250.67,103.4) 250.67,103.25 UG1.V7
FBC_D32: length 31.1
  IN1 w0.119: v1(260.67,99.67) 260.59,99.75 260.59,101.22 263.38,104.01 265.91,104.01 267.79,105.89 276.98,105.89 277.74,105.13 277.74,104.6 v1(278.12,104.21)
  BOTTOM w0.089: UG18.N11 v1(278.12,104.21)
  BOTTOM w0.135: UG1.AA4 253.37,98.65 256.92,98.65 v2(257.53,99.26) 257.85,99.58 260.45,99.58 260.54,99.67 v1(260.67,99.67)
FBC_D33: length 28.2
  IN1 w0.119: v1(278.12,102.61) 277.15,103.58 277.06,103.58 276.79,103.85 275.1,103.85 275.08,103.84 268.21,103.84 266.84,102.46 264.55,102.46 263.11,101.02 v1(262.05,101.02)
  BOTTOM w0.089: UG1.AC2 255.1,97.52 ; UG18.M13 277.72,102.21 v1(278.12,102.61)
  BOTTOM w0.135: 255.1,97.52 257.03,97.52 258.05,98.54 v2(259.79,98.54) 260.88,98.54 262.05,99.71 v1(262.05,101.02)
FBC_D34: length 26.9
  IN1 w0.119: v1(261.51,100.61) 261.51,101.47 263.58,103.54 266.26,103.54 268.23,105.51 276.03,105.51 v1(277.32,104.21)
  BOTTOM w0.089: UG18.M11 v1(277.32,104.21) ; 256.91,98.1 255.62,98.1 UG1.AC1
  BOTTOM w0.135: 256.91,98.1 257.87,99.06 260.66,99.06 261.51,99.91 v1(261.51,100.61)
FBC_D35: length 30.1
  IN1 w0.119: v1(278.92,102.61) 278.5,103.04 278.5,103.66 278.33,103.84 277.17,103.84 276.94,104.06 276.94,104.23 276.56,104.62 268.04,104.62 266.49,103.06 264.08,103.06 v1(262.97,101.94)
  BOTTOM w0.089: UG18.N13 278.52,102.21 v1(278.92,102.61) ; 257.21,97 255.72,97 UG1.AD1
  BOTTOM w0.135: 257.21,97 v2(257.61,97.4) 258.23,98.02 261.09,98.02 263.42,100.35 v2(263.42,100.95) 263.42,101.49 v1(262.97,101.94)
FBC_D36: length 35.7
  IN1 w0.119: v1(281.32,104.21) 281.71,103.82 281.71,101.46 281.06,100.81 276.04,100.81 275.85,101 273.66,101 v1(272.42,99.76)
  BOTTOM w0.089: UG1.AE3 254.47,94.85 ; UG18.T11 280.92,103.81 v1(281.32,104.21)
  BOTTOM w0.135: v1(272.42,99.76) 272.37,99.76 271.85,99.24 263.78,99.24 261.52,96.99 258.53,96.99 258.37,96.83 258.37,95.26 257.81,94.7 256.12,94.7 255.97,94.85 254.47,94.85
FBC_D37: length 32
  IN1 w0.119: v1(271.12,99.76) 272.67,101.31 275.98,101.31 276.23,101.06 280.47,101.06 280.92,101.52 280.92,102.21 v1(281.32,102.61)
  BOTTOM w0.089: v1(281.32,102.61) 280.92,102.21 UG18.T13 ; UG1.AE2 255.07,95.15
  BOTTOM w0.135: 255.07,95.15 257.62,95.15 258.05,95.59 258.05,97.08 258.47,97.5 261.31,97.5 263.57,99.76 v1(271.12,99.76)
FBC_D38: length 35.5
  IN1 w0.119: v1(282.12,104.21) 282.77,103.56 282.77,100.79 281.75,99.76 v1(274.47,99.76)
  BOTTOM w0.089: UG1.AF2 255.2,93.82 ; v1(282.12,104.21) 281.72,103.81 UG18.U11
  BOTTOM w0.135: 255.2,93.82 258.33,93.82 260.46,95.95 261.95,95.95 263.95,97.95 v2(266.9,97.95) 267.75,97.95 267.96,98.16 272.3,98.16 273.47,99.34 274.05,99.34 v1(274.47,99.76)
FBC_D39: length 31.8
  IN1 w0.119: v1(273.17,99.76) 274.09,100.68 275.34,100.68 275.47,100.56 281.4,100.56 282.28,101.44 282.28,101.44 282.5,101.66 282.5,102.27 282.16,102.61 v1(282.12,102.61)
  BOTTOM w0.089: UG18.U13 281.72,102.21 v1(282.12,102.61) ; UG1.AF1 258.02,94.4
  BOTTOM w0.135: 258.02,94.4 260.08,96.47 261.74,96.47 264.07,98.81 272.15,98.81 273.1,99.76 v1(273.17,99.76)
FBC_D40: length 38.5
  IN1 w0.119: v1(279.64,113.52) 280.22,112.93 281.14,112.93 282.5,111.57 282.5,109.39 v1(282.12,109.01)
  BOTTOM w0.089: UG18.U4 v1(282.12,109.01) ; 254.01,104.75 253.57,104.75 UG1.U4
  BOTTOM w0.135: v1(279.64,113.52) 279.61,113.52 278.67,114.46 275.59,114.46 275.44,114.31 267.26,114.31 258.37,105.43 257.68,105.43 257.25,105 256.67,105 256.42,104.75 254.01,104.75
FBC_D41: length 35.4
  IN1 w0.119: v1(278.19,113.47) 278.19,112.8 278.31,112.68 280.59,112.68 281.74,111.52 281.74,111.08 282.12,110.7 v1(282.12,110.61)
  BOTTOM w0.089: UG18.U2 v1(282.12,110.61) ; 254.52,104.45 254.17,104.45 UG1.U3
  BOTTOM w0.135: 254.52,104.45 257.42,104.45 257.88,104.91 258.48,104.91 267.44,113.87 275.63,113.87 275.94,114.19 277.35,114.19 278.08,113.47 v1(278.19,113.47)
FBC_D42: length 34.4
  IN1 w0.119: v1(277.52,113.4) 277.52,112.79 278.02,112.29 280.17,112.29 280.94,111.52 280.94,111.26 281.17,111.03 281.44,111.03 281.7,110.77 281.7,109.39 v1(281.32,109.01)
  BOTTOM w0.089: UG18.T4 v1(281.32,109.01)
  BOTTOM w0.135: UG1.U1 257.7,104 258.09,104.39 258.58,104.39 v2(260.73,106.54) 267.62,113.43 275.81,113.43 276.13,113.75 277.17,113.75 v1(277.52,113.4)
FBC_D43: length 32.9
  IN1 w0.119: v1(276.29,113.29) 277.54,112.04 279.63,112.04 280.1,111.57 280.1,111.3 280.36,111.04 280.67,111.04 281.1,110.61 v1(281.32,110.61)
  BOTTOM w0.089: UG18.T2 v1(281.32,110.61) ; 255.8,103.55 255.37,103.55 UG1.V2
  BOTTOM w0.135: v1(276.29,113.29) 275.43,112.43 267.35,112.43 258.8,103.87 v2(258.58,103.87) 258.29,103.87 257.97,103.55 255.8,103.55
FBC_D44: length 27.8
  IN1 w0.119: v1(267.72,109.81) 268.11,110.2 277.71,110.2 v1(278.12,110.61)
  BOTTOM w0.089: UG18.M2 v1(278.12,110.61) ; UG1.W2 255.07,102.05
  BOTTOM w0.135: 255.07,102.05 257.5,102.05 257.67,102.23 259.48,102.23 v2(264.54,107.29) 267.06,109.81 v1(267.72,109.81)
FBC_D45: length 29
  IN1 w0.119: v1(277.32,109.01) 276.93,109.4 268.11,109.4 v1(267.72,109.01)
  BOTTOM w0.089: UG1.Y4 253.57,101.15 ; UG18.M4 v1(277.32,109.01)
  BOTTOM w0.135: v1(267.72,109.01) 267,109.01 259.69,101.71 256.93,101.71 256.37,101.15 253.57,101.15
FBC_D46: length 30.2
  IN1 w0.089: v1(278.92,110.61) 278.5,110.19 278.5,108.08 277.72,107.3 276.6,107.3 276.09,107.81 274.52,107.81 v1(274.12,108.21)
  BOTTOM w0.089: UG18.N2 v1(278.92,110.61)
  BOTTOM w0.135: UG1.Y1 258.77,100.4 v2(258.91,100.54) 259.04,100.67 260.12,100.67 267.14,107.69 273.6,107.69 v1(274.12,108.21)
FBC_D47: length 28.6
  IN1 w0.137: v1(269.32,108.21) 269.71,108.6 277.76,108.6 278.12,108.96 v1(278.12,109.01)
  BOTTOM w0.089: UG18.N4 v1(278.12,109.01) ; UG1.Y3 254.17,100.85
  BOTTOM w0.135: v1(269.32,108.21) 266.93,108.21 v2(262.45,103.73) 259.91,101.19 257.06,101.19 256.72,100.85 254.17,100.85
FBC_D48: length 31.7
  IN3 w0.089: v1(253.27,103.4) 253.64,103.77
  IN3 w0.112: 253.64,103.77 255.45,103.77 257.33,105.65 257.33,105.9 258.01,106.58 258.01,107.79 258.73,108.51 258.73,108.67 264.28,114.23 272.15,114.23 273.72,112.65 273.72,109.41 v1(273.32,109.01)
  BOTTOM w0.089: v1(253.27,103.4) 253.27,103.25 UG1.V4
  BOTTOM w0.109: UG18.F4 v1(273.32,109.01)
FBC_D49: length 31.7
  IN3 w0.089: 252.76,103.01 v1(252.37,103.4)
  IN3 w0.112: 252.76,103.01 255.07,103.01 257.58,105.52 257.58,105.8 258.26,106.49 258.26,107.54 264.48,113.76 271.96,113.76 272.92,112.79 272.92,109.41 v1(272.52,109.01)
  BOTTOM w0.089: UG1.V5 252.37,103.25 v1(252.37,103.4) ; UG18.E4 v1(272.52,109.01)
FBC_D50: length 29.8
  IN3 w0.089: v1(251.47,102.2) 251.92,102.65
  IN3 w0.112: v1(272.52,110.61) 272.12,111.01 272.12,112.73 271.56,113.29 264.74,113.29 258.53,107.08 258.53,107.01 258.53,107.01 258.53,106.4 257.82,105.7 257.82,105.25 255.22,102.65 251.92,102.65
  BOTTOM w0.089: v1(251.47,102.2) 251.47,102.05 UG1.W6 ; UG18.F2 v1(272.52,110.61)
FBC_D51: length 27
  IN3 w0.089: 255.15,102.2 v1(252.37,102.2)
  IN3 w0.112: v1(271.72,110.61) 271.72,110.81 271.32,111.21 271.32,112.45 270.95,112.82 265.45,112.82 258.73,106.1 258.73,106.07 258.26,105.61 258.26,105.32 255.15,102.2
  BOTTOM w0.089: UG1.W5 252.37,102.05 v1(252.37,102.2) ; UG18.E2 v1(271.72,110.61)
FBC_D52: length 23
  IN3 w0.089: 251.87,100.6 v1(251.47,101)
  IN3 w0.112: v1(268.52,110.61) 268.15,110.24 268.15,109.71 267.88,109.44 267.62,109.44 267.17,108.99 265.14,108.99 258.29,102.14 257.56,102.14 256.32,100.9 253.12,100.9 252.82,100.6 251.87,100.6
  BOTTOM w0.089: v1(251.47,101) 251.47,100.85 UG1.Y6 ; UG18.A2 v1(268.52,110.61)
FBC_D53: length 25.3
  IN3 w0.089: v1(250.67,101) 251.47,100.2
  IN3 w0.112: v1(269.32,110.61) 268.92,110.21 268.92,109.61 268.72,109.41 268.39,109.41 268.15,109.17 268.15,108.63 268.04,108.52 265.33,108.52 258.62,101.81 257.62,101.81 256.36,100.55 253.27,100.55 252.92,100.2 251.47,100.2
  BOTTOM w0.089: v1(250.67,101) 250.67,100.85 UG1.Y7 ; UG18.B2 v1(269.32,110.61)
FBC_D54: length 26.7
  IN3 w0.089: 249.7,100.37 v1(249.07,101)
  IN3 w0.112: 249.7,100.37 250.79,100.37 251.08,100.08 251.08,99.59 251.27,99.4 256.1,99.4 257.67,100.97 259.11,100.97 265.72,107.59 268.17,107.59 269.32,108.74 v1(269.32,109.01)
  BOTTOM w0.089: v1(249.07,101) 249.07,100.85 UG1.Y9 ; UG18.B4 v1(269.32,109.01)
FBC_D55: length 21.6
  IN3 w0.089: v1(252.37,99.8) 253.42,99.8
  IN3 w0.112: v1(268.52,109.01) 268.52,108.46 268.11,108.05 265.52,108.05 258.91,101.44 257.63,101.44 256.39,100.2 253.82,100.2 253.42,99.8
  BOTTOM w0.089: UG18.A4 v1(268.52,109.01) ; v1(252.37,99.8) 252.37,99.65 UG1.AA5
FBC_D56: length 28.4
  IN3 w0.089: v1(250.67,97.4) 251.71,98.44
  IN3 w0.112: 251.71,98.44 257.41,98.44 258.05,99.08 259.38,99.08 264.28,103.98 266.02,103.98 267.74,105.7 272.37,105.7 272.92,105.14 272.92,104.61 v1(273.32,104.21)
  BOTTOM w0.089: v1(273.32,104.21) 272.92,103.81 UG18.F11 ; UG1.AC7 250.67,97.55 v1(250.67,97.4)
FBC_D57: length 25.5
  IN3 w0.089: 253.09,98.12 v1(252.37,97.4)
  IN3 w0.112: v1(272.52,104.21) 271.35,105.39 268.09,105.39 266.22,103.51 264.95,103.51 263.65,102.21 263.65,102.03 260.23,98.61 258.24,98.61 257.68,98.05 254.57,98.05 254.5,98.12 253.09,98.12
  BOTTOM w0.089: v1(272.52,104.21) 272.12,103.81 UG18.E11 ; v1(252.37,97.4) 252.37,97.55 UG1.AC5
FBC_D58: length 20.7
  IN3 w0.089: v1(253.27,97.4) 253.67,97.8
  IN3 w0.112: v1(269.32,104.21) 268.95,104.59 267.96,104.59 266.41,103.04 265.15,103.04 264.12,102.01 264.12,101.84 260.42,98.14 258.43,98.14 257.99,97.7 254.57,97.7 254.47,97.8 253.67,97.8
  BOTTOM w0.089: v1(253.27,97.4) 253.27,97.55 UG1.AC4 ; UG18.B11 269.72,103.81 v1(269.32,104.21)
FBC_D59: length 24.2
  IN3 w0.089: 249.87,97 v1(249.07,96.2)
  IN3 w0.112: 249.87,97 254.37,97 254.72,97.35 258.4,97.35 258.73,97.68 260.62,97.68 264.58,101.64 264.58,101.82 265.34,102.58 266.61,102.58 268.24,104.21 v1(268.52,104.21)
  BOTTOM w0.089: UG1.AD9 249.07,96.35 v1(249.07,96.2) ; v1(268.52,104.21) 268.92,103.81 UG18.A11
FBC_D60: length 26.5
  IN3 w0.089: 250.67,95.8 v1(249.87,95)
  IN3 w0.112: 250.67,95.8 253.72,95.8 254.45,95.07 259.72,95.07 260.23,94.56 262.44,94.56 262.88,95.01 262.88,96.41 266.58,100.11 268.06,100.11 268.89,100.94 268.89,102.24 v1(268.52,102.61)
  BOTTOM w0.089: UG18.A13 268.92,102.21 v1(268.52,102.61) ; UG1.AE8 249.87,95.15 v1(249.87,95)
FBC_D61: length 26.3
  IN3 w0.089: v1(251.47,95) 251.87,95.4
  IN3 w0.112: v1(269.32,102.61) 269.72,102.21 269.72,100.81 268.55,99.64 266.77,99.64 264.79,97.66 264.79,95.46 263.42,94.1 254.82,94.1 253.52,95.4 251.87,95.4
  BOTTOM w0.089: v1(269.32,102.61) 269.72,102.21 UG18.B13 ; UG1.AE6 251.47,95.15 v1(251.47,95)
FBC_D62: length 26.7
  IN3 w0.089: 252.8,94.57 v1(252.37,95)
  IN3 w0.112: v1(271.72,102.61) 271.32,102.21 271.32,101.26 269.23,99.17 267.17,99.17 265.26,97.26 265.26,95.27 263.62,93.63 254.64,93.63 253.69,94.57 252.8,94.57
  BOTTOM w0.089: UG18.E13 v1(271.72,102.61) ; UG1.AE5 252.37,95.15 v1(252.37,95)
FBC_D63: length 31.8
  IN3 w0.089: v1(248.27,93.8) 248.67,94.2
  IN3 w0.112: 248.67,94.2 253.47,94.2 254.42,93.25 258.52,93.25 258.55,93.21 263.79,93.21 263.83,93.25 263.9,93.25 265.73,95.08 265.73,97.14 267.29,98.7 269.46,98.7 272.12,101.36 272.12,102.21 v1(272.52,102.61)
  BOTTOM w0.089: v1(248.27,93.8) 248.27,93.95 UG1.AF10 ; UG18.F13 v1(272.52,102.61)
FBC_DBI0#: length 29.9
  IN1 w0.089: 257.43,114.62 257.01,114.2 v1(255.97,114.2)
  IN1 w0.119: 257.43,114.62 258.57,115.76 259.62,115.76 266,122.14 266.1,122.14 268.19,124.22 271.15,124.22 271.34,124.42 271.34,124.77 271.58,125 279.06,125 279.46,124.61 v1(279.72,124.61)
  BOTTOM w0.089: UG17.D13 v1(279.72,124.61) ; UG1.E1 255.97,114.05 v1(255.97,114.2)
FBC_DBI1#: length 30.5
  IN1 w0.089: v1(257.09,108.53) 258.33,108.53
  IN1 w0.119: 258.33,108.53 260.54,110.74 262.57,110.74 266.89,115.05 272.29,115.05 272.94,115.7 272.94,115.99 273.16,116.21 279.32,116.21 v1(279.72,116.61)
  BOTTOM w0.089: UG1.M3 254.17,108.05 ; v1(279.72,116.61) 279.32,116.21 UG17.D2
  BOTTOM w0.135: v1(257.09,108.53) 256.62,108.05 254.17,108.05
FBC_DBI2#: length 32.7
  IN4 w0.089: v1(249.07,109.4) 249.89,110.22
  IN4 w0.119: v1(270.92,124.61) 270.92,124.54 270.51,124.13 270.51,123.65 270.28,123.42 268.39,123.42 268.14,123.18 268.14,122.22 267.91,121.99 266.77,121.99 264.54,119.76 264.54,118.55 263.6,117.61 263.6,116.54 261.39,114.33 259.85,114.33 259.29,113.76 258.65,113.76 257.28,112.4 257.28,112.08 255.91,110.71 255.91,110.12 255.43,109.63 253.63,109.63 253.04,110.22 249.89,110.22
  BOTTOM w0.089: UG1.L9 249.07,109.25 v1(249.07,109.4) ; UG17.P13 v1(270.92,124.61)
FBC_DBI3#: length 34.2
  IN4 w0.089: 249.87,105.4 v1(249.07,104.6)
  IN4 w0.119: v1(270.92,116.61) 271.34,116.19 271.34,112.37 270.54,111.57 270.54,110.5 270.23,110.19 269.96,110.19 269.7,109.92 269.7,108.86 269.43,108.59 269.17,108.59 267.92,107.34 267.92,106.81 267.59,106.49 262.92,106.49 260.22,103.79 258.1,103.79 257.57,104.32 255.83,104.32 255.15,105 252.81,105 252.41,105.4 249.87,105.4
  BOTTOM w0.089: v1(249.07,104.6) 249.07,104.45 UG1.U9 ; UG17.P2 271.32,116.21
  BOTTOM w0.13: 271.32,116.21 v1(270.92,116.61)
FBC_DBI4#: length 30.9
  IN1 w0.089: 258.05,96.13 v1(257.52,95.6)
  IN1 w0.119: 258.05,96.13 259.75,96.13 264.56,100.93 266.27,100.93 268.37,103.03 276.74,103.03 276.9,102.87 276.9,102.5 277.19,102.21 279.32,102.21 v1(279.72,102.61)
  BOTTOM w0.089: UG1.AD3 254.17,96.35 ; v1(279.72,102.61) 279.32,102.21 UG18.P13
  BOTTOM w0.135: 254.17,96.35 256.77,96.35 v1(257.52,95.6)
FBC_DBI5#: length 30.6
  IN1 w0.089: 257.76,103.34 v1(256.97,102.55)
  IN1 w0.119: 257.76,103.34 261.01,106.59 263.96,106.59 268.38,111 279.06,111 279.46,110.61 v1(279.72,110.61)
  BOTTOM w0.089: UG1.W3 254.45,102.33 ; UG18.P2 v1(279.72,110.61)
  BOTTOM w0.119: v1(256.97,102.55) 256.39,102.55 256.17,102.33 254.45,102.33
FBC_DBI6#: length 27.6
  IN3 w0.089: v1(249.87,102.2) 250.26,101.81
  IN3 w0.112: 250.26,101.81 255.15,101.81 257.74,104.39 258,104.39 265.39,111.79 270.41,111.79 270.52,111.67 270.52,111.21 270.92,110.81 v1(270.92,110.61)
  BOTTOM w0.089: UG18.D2 v1(270.92,110.61)
  BOTTOM w0.135: v1(249.87,102.2) 249.87,102.05 UG1.W8
FBC_DBI7#: length 26.8
  IN3 w0.089: v1(250.67,96.2) 251.15,96.68
  IN3 w0.112: 251.15,96.68 254.65,96.68 254.98,97.01 260.94,97.01 265.83,101.9 267.12,101.9 267.79,102.57 267.79,103.21 268.39,103.81 271.12,103.81 271.32,103.61 271.32,103.01 v1(270.92,102.61)
  BOTTOM w0.089: v1(250.67,96.2) 250.67,96.35 UG1.AD7 ; UG18.D13 v1(270.92,102.61)
FBC_EDC0: length 32.8
  IN1 w0.089: 255.57,114.7 v1(255.07,114.2)
  IN1 w0.119: 255.57,114.7 256.7,114.7 257.1,115.1 257.1,115.57 258.2,116.67 259.24,116.67 267.12,124.55 267.29,124.55 267.74,125 270.38,125 270.5,125.12 270.5,125.52 270.76,125.79 279.08,125.79 279.3,125.57 279.3,125.3 279.59,125.01 279.86,125.01 280.26,124.61 v1(280.52,124.61)
  BOTTOM w0.089: UG17.C13 v1(280.52,124.61) ; UG1.E2 255.07,114.05 v1(255.07,114.2)
FBC_EDC1: length 29.6
  IN1 w0.089: 256.87,107.6 v1(256.17,107.6)
  IN1 w0.119: v1(280.52,116.61) 280.52,116.51 280.12,116.11 280.12,115.66 279.88,115.41 273.01,115.41 271.74,114.15 267.26,114.15 262.95,109.83 260.92,109.83 258.69,107.6 256.87,107.6
  BOTTOM w0.089: UG17.C2 280.12,116.21 v1(280.52,116.61)
  BOTTOM w0.135: v1(256.17,107.6) UG1.M1
FBC_EDC2: length 27.3
  IN4 w0.119: v1(270.12,124.61) 269.72,124.21 268.39,124.21 267.89,123.72 267.89,123.28 267.89,123.28 267.89,123.2 267.59,122.89 266.39,122.89 263.64,120.14 263.64,118.93 262.69,117.98 262.69,116.92 261.01,115.24 259.48,115.24 258.91,114.67 258.22,114.67 257.81,114.26 257.29,114.26 257.03,114 257.03,112.27 255.58,110.82 255.58,110.37 255.34,110.14 253.73,110.14 v1(253.27,110.6)
  BOTTOM w0.089: v1(253.27,110.6) 253.27,110.45 UG1.J4 ; UG17.R13 v1(270.12,124.61)
FBC_EDC3: length 29.8
  IN4 w0.119: v1(270.12,116.61) 270.5,116.24 270.5,115.2 270.36,115.06 270.36,114.09 270.51,113.94 270.51,112.17 270.33,111.98 269.88,111.98 269.74,111.83 269.74,110.49 269.43,110.19 269.17,110.19 268.9,109.92 268.9,108.86 268.68,108.64 267.9,108.64 267.34,108.08 267.34,107.61 267.05,107.32 262.47,107.32 259.77,104.62 258.13,104.62 257.69,105.06 257.06,105.06 256.68,104.68 256.1,104.68 255.53,105.25 252.92,105.25 v1(252.37,105.8)
  BOTTOM w0.089: UG1.R5 252.37,105.65 v1(252.37,105.8) ; UG17.R2 270.52,116.21
  BOTTOM w0.13: 270.52,116.21 v1(270.12,116.61)
FBC_EDC4: length 33.6
  IN1 w0.089: v1(256.87,95.6) 257.25,95.22
  IN1 w0.119: v1(280.52,102.61) 280.14,102.24 280.14,101.54 279.98,101.38 277.05,101.38 276.93,101.5 276.93,101.95 276.65,102.23 268.51,102.23 268.47,102.19 268.36,102.19 268.14,101.97 268.14,101.63 266.62,100.1 264.9,100.1 260.02,95.22 257.25,95.22
  BOTTOM w0.089: UG1.AD4 253.57,96.05 ; v1(280.52,102.61) 280.12,102.21 UG18.R13
  BOTTOM w0.135: 253.57,96.05 256.42,96.05 v1(256.87,95.6)
FBC_EDC5: length 30.4
  IN1 w0.119: v1(280.52,110.61) 280.26,110.61 279.88,110.99 279.61,110.99 279.34,111.26 279.34,111.52 279.08,111.79 276.94,111.79 276.35,112.39 v1(276.3,112.39)
  BOTTOM w0.089: UG1.V1 255.77,103.05 256.17,103.05 ; UG18.R2 v1(280.52,110.61)
  BOTTOM w0.135: v1(276.3,112.39) 276.08,112.16 268.25,112.16 259.14,103.05 256.17,103.05
FBC_EDC6: length 27
  IN3 w0.089: 249.87,101.4 v1(249.07,102.2)
  IN3 w0.112: 249.87,101.4 252.62,101.4 252.77,101.25 255.09,101.25 256.76,102.92 257.8,102.92 264.76,109.89 266.79,109.89 267.92,111.01 269.72,111.01 v1(270.12,110.61)
  BOTTOM w0.089: UG18.C2 v1(270.12,110.61)
  BOTTOM w0.135: UG1.W9 249.07,102.05 v1(249.07,102.2)
FBC_EDC7: length 24.1
  IN3 w0.089: 253.87,96.2 v1(251.47,96.2)
  IN3 w0.112: v1(270.12,102.61) 270.12,102.81 269.93,103.01 268.36,103.01 268.15,102.8 268.15,101.42 267.73,101.01 266.21,101.01 261.31,96.11 259.98,96.11 259.84,95.97 254.1,95.97 253.87,96.2
  BOTTOM w0.089: UG18.C13 v1(270.12,102.61) ; v1(251.47,96.2) 251.47,96.35 UG1.AD6
FBC_MA0_H: length 35.4
  TOP w0.089: v1(249.87,97.4) 250.32,97.85
  TOP w0.135: v1(276.52,109.01) 276.27,109.01 274.45,107.2 264.23,107.2 258.32,101.29 258.13,101.29 257.75,101.67 257.56,101.67 257.27,101.38 257.27,101.19 257.65,100.81 257.65,100.62 257.37,100.34 257.17,100.34 256.8,100.72 256.61,100.72 256.32,100.43 256.32,100.24 256.7,99.86 256.7,99.67 254.88,97.85 250.32,97.85
  BOTTOM w0.089: UG1.AC8 249.87,97.55 v1(249.87,97.4) ; UG18.K4 v1(276.52,109.01)
FBC_MA0_L: length 42.2
  IN3 w0.089: v1(245.87,103.4) 246.32,103.85 247.21,103.85 247.47,104.11 248.17,104.11 248.55,104.49 248.55,104.82 248.83,105.1 249.28,105.1 249.32,105.14 249.39,105.14 249.69,105.44 250.13,105.44 250.24,105.55 250.24,105.89 250.52,106.16 250.98,106.16 251.46,106.64 253.55,106.64 253.81,106.89 253.81,108.48 255.82,110.49 255.82,111 256.89,112.07 256.89,112.41 257.22,112.74
  IN3 w0.112: 257.22,112.74 257.22,113.41 263.44,119.63 267.64,119.63 267.81,119.81 275.84,119.81 276.11,119.54 276.11,118.6 v1(275.72,118.21)
  BOTTOM w0.089: UG1.V13 v1(245.87,103.4) ; UG17.H4 v1(275.72,118.21)
FBC_MA1_H: length 37.1
  TOP w0.089: 246.77,97 245.97,96.2 v1(245.87,96.2)
  TOP w0.135: v1(276.52,108.21) 275.96,108.21 274.42,106.68 264.44,106.68 254.63,96.87 252.5,96.87 252.37,97 246.77,97
  BOTTOM w0.089: UG1.AD13 245.87,96.35 v1(245.87,96.2) ; UG18.K5 v1(276.52,108.21)
FBC_MA1_L: length 41.2
  IN3 w0.089: v1(248.02,104.6) 248.73,105.32 249.19,105.32 249.5,105.63 249.5,106.01 249.75,106.27 250.26,106.27 250.52,106.52 250.9,106.52 251.11,106.73 251.11,107.3 251.24,107.44 252.99,107.44 253.53,107.98 253.53,108.52 255.6,110.59 255.6,111.16 256.67,112.23 256.67,112.5 256.71,112.55 256.71,112.61 256.96,112.86 256.96,113.36 256.97,113.37
  IN3 w0.112: v1(276.52,118.21) 276.52,119.7 276.18,120.05 273.73,120.05 273.62,120.16 273.62,120.32 273.51,120.43 273.29,120.43 273.17,120.32 273.17,120.16 273.06,120.05 272.84,120.05 272.73,120.16 272.73,120.32 272.61,120.43 272.39,120.43 272.28,120.32 272.28,120.16 272.17,120.05 271.94,120.05 271.83,120.16 271.83,120.32 271.72,120.43 271.5,120.43 271.39,120.32 271.39,120.16 271.27,120.05 267.61,120.05 263.27,120.05 256.97,113.75 256.97,113.37
  BOTTOM w0.089: UG1.U10 248.02,104.2 v1(248.02,104.6) ; UG17.H5 v1(276.52,118.21)
FBC_MA2_H: length 35.6
  TOP w0.089: 248.79,95.68 v1(248.27,96.2)
  TOP w0.135: v1(274.92,104.21) 274.52,104.61 274.52,105.26 274.38,105.4 v2(269.31,105.4) 265.01,105.4 259.56,99.95 259.56,99.75 260.07,99.25 260.07,99.06 257.53,96.52 256.14,96.52 255.29,95.68 252.67,95.68 252.53,95.81 252.53,95.91 252.4,96.04 252.13,96.04 252,95.91 252,95.81 251.86,95.68 248.79,95.68
  BOTTOM w0.089: UG18.K11 275.72,104.21 v1(274.92,104.21) ; v1(248.27,96.2) 248.27,96.35 UG1.AD10
FBC_MA2_L: length 49.3
  IN3 w0.089: 245.44,105.03 v1(245.87,104.6)
  IN3 w0.112: 245.44,105.03 245.44,106.33 245.75,106.65 245.75,108.06 246.56,108.87 246.57,108.87 246.79,109.1 246.79,109.1 250.6,112.91 250.6,114.06 251.07,114.52 251.22,114.52 252.17,115.47 252.47,115.47 252.79,115.79 252.79,115.92 253.18,116.3 253.18,116.81 253.54,117.18 254.48,117.18 254.75,117.45 254.75,117.9 254.97,118.12 256.38,118.12 256.77,118.52 256.77,119.19 261.25,123.67 262.61,123.67 265.15,126.2 276.26,126.2 276.89,125.57 276.89,125.31 277.22,124.99 277.48,124.99 277.69,124.77 277.69,124.19 v1(276.52,123.01)
  BOTTOM w0.089: UG17.H11 v1(276.52,123.01) ; UG1.U13 245.87,104.45 v1(245.87,104.6)
FBC_MA3_H: length 36.4
  TOP w0.089: 247.09,96.62 v1(246.67,96.2)
  TOP w0.135: 247.09,96.62 251.6,96.62 251.61,96.6 253.07,96.6 253.21,96.47 253.21,96.08 253.34,95.94 253.6,95.94 253.74,96.08 253.74,96.23 253.87,96.36 254.14,96.36 254.28,96.23 254.28,96.08 254.41,95.94 254.94,95.94 265.23,106.24 v2(272.93,106.24) 274.57,106.24 275.72,105.09 v1(275.72,105.01)
  BOTTOM w0.089: v1(246.67,96.2) 246.67,96.35 UG1.AD12 ; UG18.K10 v1(275.72,105.01)
FBC_MA3_L: length 47.5
  IN3 w0.089: 246.24,105.03 v1(246.67,104.6)
  IN3 w0.112: 246.24,105.03 246.24,107.09 247.1,107.95 247.1,108.43 247.6,108.93 247.67,108.93 250.85,112.1 250.85,113.15 252.42,114.73 252.58,114.73 253.27,115.43 253.27,116.05 253.57,116.35 253.99,116.35 254.82,117.17 255.37,117.17 256.03,117.83 256.43,117.83 257.01,118.42 257.01,118.77 261.49,123.25 262.78,123.25 264.49,124.96 265.16,124.96 265.98,125.79 275.54,125.79 276.28,125.04 276.62,125.04 276.89,124.77 276.89,124.46 276.62,124.19 276.37,124.19 276.15,123.97 276.15,122.59 v1(276.52,122.21)
  BOTTOM w0.089: v1(246.67,104.6) 246.67,104.45 UG1.U12 ; UG17.H10 v1(276.52,122.21)
FBC_MA4_H: length 36.1
  TOP w0.089: 248.2,94.27 v1(247.47,95)
  TOP w0.135: 248.2,94.27 253.95,94.27 254.14,94.46 254.4,94.46 254.54,94.33 254.54,93.96 254.67,93.82 254.94,93.82 255.08,93.96 255.08,94.33 255.21,94.46 258.46,94.46 258.6,94.33 258.6,94.15 258.73,94.01 259,94.01 259.14,94.15 259.14,94.33 259.27,94.46 259.84,94.46 266.7,101.31 v2(272.68,101.31) 274.27,101.31 274.52,101.57 274.52,103.82 v1(274.12,104.21)
  BOTTOM w0.089: UG1.AE11 247.47,95.15 v1(247.47,95) ; UG18.H11 v1(274.12,104.21)
FBC_MA4_L: length 42.4
  IN3 w0.089: 248.29,106.62 v1(247.47,105.8)
  IN3 w0.112: 248.29,106.62 248.29,107.39 248.72,107.81 248.72,108.16 249.38,108.82 251.48,108.82 252,109.34 252,109.55 252.9,110.45 252.9,111.95 253.8,112.85 253.8,113.3 254.54,114.05 254.54,114.2 254.92,114.57 255.27,114.57 256.54,115.85 256.54,116.36 262.19,122 266.67,122 267.3,122.64 267.78,122.64 267.89,122.53 267.89,121.9 268,121.79 268.23,121.79 268.34,121.9 268.34,122.53 268.45,122.64 269.16,122.64 269.27,122.53 269.27,122.19 269.38,122.08 269.61,122.08 269.72,122.19 269.72,122.53 269.83,122.64 270.49,122.64 270.61,122.53 270.61,121.94 270.72,121.82 270.94,121.82 271.05,121.94 271.05,122.53 271.17,122.64 271.39,122.64 271.5,122.53 271.5,122.05 271.61,121.94 271.84,121.94 271.95,122.05 271.95,122.48 272.06,122.59 274.01,122.59 274.12,122.7 v1(274.12,123.01)
  BOTTOM w0.089: UG1.R11 247.47,105.65 v1(247.47,105.8) ; UG17.K11 v1(274.12,123.01)
FBC_MA5_H: length 36.4
  TOP w0.089: 247.08,95.41 v1(246.67,95)
  TOP w0.135: 247.08,95.41 255.41,95.41 256.25,96.26 257.89,96.26 258.84,97.21 259.03,97.21 259.55,96.68 259.74,96.68 260.03,96.97 260.03,97.16 259.51,97.68 259.51,97.87 259.79,98.16 259.98,98.16 260.5,97.64 260.7,97.64 260.98,97.92 260.98,98.11 260.46,98.63 260.46,98.83 266.25,104.61 v2(270.96,104.61) 273.72,104.61 v1(274.12,105.01)
  BOTTOM w0.089: UG1.AE12 246.67,95.15 v1(246.67,95) ; UG18.H10 v1(274.12,105.01)
FBC_MA5_L: length 40.8
  IN3 w0.089: v1(249.07,105.8) 248.97,105.7 248.81,105.7 248.64,105.87
  IN3 w0.112: v1(274.12,122.21) 274.12,121.49 274.01,121.38 273.41,121.38 273.3,121.49 273.3,121.71 273.18,121.83 272.96,121.83 272.85,121.71 272.85,121.49 272.74,121.38 272.51,121.38 272.4,121.49 272.4,121.71 272.29,121.83 272.07,121.83 271.95,121.71 271.95,121.49 271.84,121.38 271.6,121.38 271.49,121.49 271.49,121.58 271.38,121.69 271.16,121.69 271.04,121.58 271.04,121.48 270.93,121.37 270.71,121.37 270.6,121.48 270.6,121.58 270.49,121.69 270.26,121.69 270.15,121.58 270.15,121.48 270.04,121.37 269.82,121.37 269.7,121.48 269.7,121.58 269.59,121.69 269.37,121.69 269.26,121.58 269.26,121.48 269.15,121.37 268.92,121.37 268.81,121.48 268.81,121.58 268.7,121.69 268.47,121.69 268.36,121.58 268.36,121.48 268.25,121.37 268.01,121.37 267.64,121.74 267.22,121.74 267.06,121.59 262.63,121.59 255.6,114.55 255.6,112.81 254.96,112.17 253.87,112.17 253.75,112.06 253.75,110 252.33,108.57 250.52,108.57 250.24,108.3 250.24,108.05 249.93,107.73 249.27,107.73 248.64,107.1 248.64,105.87
  BOTTOM w0.089: UG17.K10 v1(274.12,122.21) ; v1(249.07,105.8) 249.07,105.65 UG1.R9
FBC_MA6_H: length 36.7
  TOP w0.089: 246.34,97.88 v1(245.87,97.4)
  TOP w0.135: 246.34,97.88 247.39,97.88 248.42,98.9 252.73,98.9 255.07,101.23 255.07,102.35 256.59,103.88 257.99,103.88 263.53,109.41 266.53,109.41 266.67,109.28 266.67,109.2 266.8,109.06 267.07,109.06 267.2,109.2 267.2,109.28 267.34,109.41 272.11,109.41 272.24,109.55 272.24,109.82 272.38,109.96 272.64,109.96 272.78,109.82 272.78,109.55 272.91,109.41 273.99,109.41 274.12,109.28 v1(274.12,109.01)
  BOTTOM w0.089: UG1.AC13 245.87,97.55 v1(245.87,97.4) ; UG18.H5 v1(274.12,109.01)
FBC_MA6_L: length 42.8
  IN3 w0.089: v1(245.07,102.2) 245.07,102.47 245.56,102.97 248.03,102.97 248.38,103.31 248.38,103.43 248.8,103.85 249.15,103.85 249.43,104.14 250.72,104.14 251.09,104.51 251.09,105 251.39,105.3 253.82,105.3 254.99,106.47 254.99,109.04 256.26,110.31 256.26,110.75 257.32,111.81 257.32,111.82
  IN3 w0.112: v1(274.12,118.21) 274.12,117.95 274.01,117.84 268.37,117.84 267.72,118.49 267.06,118.49 266.95,118.38 266.95,118.16 266.84,118.05 266.62,118.05 266.51,118.16 266.51,118.38 266.39,118.49 266.17,118.49 266.06,118.38 266.06,118.16 265.95,118.05 265.72,118.05 265.61,118.16 265.61,118.38 265.5,118.49 265.28,118.49 265.16,118.38 265.16,118.16 265.05,118.05 264.83,118.05 264.72,118.16 264.72,118.38 264.61,118.49 264.38,118.49 264.27,118.38 264.27,118.16 264.16,118.05 263.94,118.05 263.82,118.16 263.82,118.38 263.71,118.49 263.47,118.49 260.02,115.03 260.02,115.03 257.88,112.89 257.88,112.37 257.32,111.82
  BOTTOM w0.089: UG17.K5 274.12,118.21 v1(274.12,118.21) ; UG1.W14 245.07,102.05 v1(245.07,102.2)
FBC_MA7_H: length 36.1
  TOP w0.089: v1(247.47,97.4) 248.62,98.55
  TOP w0.135: 248.62,98.55 253.48,98.55 254.68,99.76 254.68,100.32 255.01,100.65 255.2,100.65 255.32,100.53 255.51,100.53 255.7,100.72 255.7,100.91 255.34,101.27 255.34,101.46 257.12,103.24 258.13,103.24 263.5,108.61 270.51,108.61 270.64,108.48 270.64,108.05 270.78,107.92 271.04,107.92 271.18,108.05 271.18,108.48 271.31,108.61 274.52,108.61 v1(274.92,109.01)
  BOTTOM w0.089: v1(247.47,97.4) 247.47,97.55 UG1.AC11 ; UG18.H4 v1(274.92,109.01)
FBC_MA7_L: length 43.2
  TOP w0.089: v1(247.95,103.4) 247.95,103.1 248.08,102.97
  TOP w0.135: 248.08,102.97 250.95,102.97 251.09,103.1 251.09,103.24 251.09,103.24 251.09,103.79 251.47,104.17 252.04,104.17 255.08,107.22 256.33,107.22 257.56,108.45 257.56,108.69 262.19,113.31 263.91,113.31 264.11,113.51 264.11,115.34 264.24,115.48 264.56,115.48 264.7,115.34 264.7,114.4 264.83,114.26 265.1,114.26 265.24,114.4 265.24,115.36 265.37,115.49 265.64,115.49 265.78,115.36 265.78,114.4 265.91,114.26 266.18,114.26 266.31,114.4 266.31,115.36 266.45,115.49 266.72,115.49 266.85,115.36 266.85,114.4 266.99,114.26 267.26,114.26 267.39,114.4 267.39,115.29 267.53,115.43 v2(267.79,115.43) 271.08,115.43 271.34,115.68 271.34,115.97 271.56,116.2 271.85,116.2 272.14,116.48 272.14,116.77 273.16,117.8 274.25,117.8 274.67,118.21 v1(274.92,118.21)
  BOTTOM w0.089: UG1.V10 247.95,102.93 v1(247.95,103.4) ; UG17.K4 274.52,117.81 v1(274.92,118.21)
FBC_MA8_H: length 36.3
  TOP w0.089: v1(248.27,97.4) 248.27,97.82 248.56,98.12
  TOP w0.135: v1(274.92,108.21) 274.92,108.04 274.34,107.47 269.32,107.47 268.69,108.1 263.61,108.1 260.5,104.99 260.5,104.79 260.75,104.54 260.75,104.35 260.47,104.06 260.28,104.06 260.02,104.32 259.83,104.32 259.55,104.03 259.55,103.84 259.8,103.59 259.8,103.4 259.52,103.11 259.33,103.11 259.07,103.37 258.88,103.37 255.58,100.07 255.58,99.77 255.33,99.51 255.33,99.32 255.55,99.1 255.55,98.9 255.27,98.62 255.08,98.62 254.85,98.85 254.66,98.85 v2(254.46,98.64) 253.93,98.12 248.56,98.12
  BOTTOM w0.089: UG18.J5 v1(274.92,108.21) ; v1(248.27,97.4) 248.27,97.55 UG1.AC10
FBC_MA8_L: length 43.5
  IN3 w0.089: v1(247.4,103.4) 247.4,103.47 247.79,103.85 248.42,103.85 248.74,104.17 249.15,104.17 249.43,104.45 249.43,104.86 249.78,105.22 250.22,105.22 250.44,105.44 250.83,105.44 251.03,105.64 251.03,105.87 251.1,105.94 251.11,105.94 251.11,105.95 251.58,106.42 254.2,106.42 254.54,106.76 254.54,108.91 256.04,110.4 256.04,110.84 257.11,111.91 257.11,112.3 257.43,112.62
  IN3 w0.112: 257.43,112.62 257.46,112.65 257.46,113.06 259.84,115.45 263.61,119.22 263.85,119.22 263.96,119.1 263.96,119.02 264.08,118.9 264.3,118.9 264.41,119.02 264.41,119.1 264.52,119.22 264.75,119.22 264.86,119.1 264.86,119.02 264.97,118.9 265.19,118.9 265.3,119.02 265.3,119.1 265.42,119.22 265.64,119.22 265.75,119.1 265.75,119.02 265.86,118.9 266.09,118.9 266.2,119.02 266.2,119.1 266.31,119.22 266.53,119.22 266.65,119.1 266.65,119.02 266.76,118.9 266.98,118.9 267.09,119.02 267.09,119.1 267.2,119.22 267.64,119.22 267.99,119.56 270.52,119.56 270.63,119.45 270.63,118.7 270.74,118.59 270.96,118.59 271.08,118.7 271.08,119.45 271.19,119.56 271.41,119.56 271.52,119.45 271.52,118.7 271.63,118.59 271.86,118.59 271.97,118.7 271.97,119.45 272.08,119.56 274.98,119.56 275.11,119.43 275.11,119.2 v1(274.92,119.01)
  BOTTOM w0.089: UG17.J5 v1(274.92,119.01) ; UG1.V11 247.4,103.18 v1(247.4,103.4)
FBC_RAS#_H: length 37.9
  TOP w0.089: v1(248.27,101) 248.77,101.51
  TOP w0.135: 248.77,101.51 251.32,101.51 251.99,102.17 251.99,102.36 252.75,103.13 252.75,103.43 255.67,106.34 256.46,106.34 260.95,110.83 261.79,110.83 263.2,112.24 271.41,112.24 v2(272.07,112.9) 273.19,114.02 275.15,114.02 275.85,113.32 275.85,111.54 276.52,110.87 v1(276.52,110.61)
  BOTTOM w0.089: v1(248.27,101) 248.27,100.85 UG1.Y10 ; UG18.L3 v1(276.52,110.61)
FBC_RAS#_L: length 46.3
  IN3 w0.089: v1(246.67,101) 246.67,101.35 246.76,101.44 248.23,101.44 248.67,101.89 248.67,102.48 248.78,102.58 251.47,102.58 251.91,103.03 251.91,103.54 252.48,104.11 254.14,104.11 257.78,107.75 257.78,107.94 258.06,108.22 258.06,108.84
  IN3 w0.112: 258.06,108.84 258.06,109.78 259.13,110.84 259.13,112.37 261.78,115.02 267.51,115.02 267.92,115.44 268.16,115.44 268.27,115.33 268.27,114.89 268.38,114.78 268.61,114.78 268.72,114.89 268.72,115.33 268.83,115.44 269.05,115.44 269.17,115.33 269.17,114.89 269.28,114.78 269.5,114.78 269.61,114.89 269.61,115.33 269.72,115.44 269.95,115.44 270.09,115.3 270.09,114.89 270.2,114.78 270.39,114.78 270.51,114.89 270.51,115.33 270.62,115.44 270.84,115.44 270.95,115.33 270.95,114.89 271.07,114.78 271.29,114.78 271.4,114.89 271.4,115.33 271.51,115.44 271.74,115.44 271.85,115.33 271.85,114.89 271.96,114.78 272.18,114.78 272.29,114.89 272.29,115.33 272.41,115.44 273.45,115.44 273.56,115.33 273.56,115.21 273.67,115.09 273.9,115.09 274.01,115.21 274.01,115.33 274.12,115.44 275.62,115.44 276.52,116.34 v1(276.52,116.61)
  BOTTOM w0.089: v1(246.67,101) 246.67,100.85 UG1.Y12 ; UG17.G3 276.92,117.01 v1(276.52,116.61)
FBC_WCK0: length 32
  IN1 w0.089: v1(255.07,111.8) 255.07,111.42 255.21,111.28
  IN1 w0.119: 255.21,111.28 256.19,111.28 256.51,111.6 258.47,111.6 259.7,112.83 261.15,112.83 266.85,118.53 267.66,118.53 267.92,118.78 267.92,119.48 268.61,120.17 278.84,120.17 279.66,119.35 279.66,118.27 v1(279.72,118.21)
  BOTTOM w0.089: v1(279.72,118.21) 279.32,117.81 UG17.D4 ; v1(255.07,111.8) 255.07,111.65 UG1.H1
FBC_WCK0_N: length 32.4
  IN1 w0.089: v1(255.07,110.6) 254.95,110.6 254.8,110.75 254.8,110.99 254.88,111.08
  IN1 w0.119: v1(278.92,118.21) 279.19,118.21 279.45,118.48 279.45,119.26 278.75,119.97 268.7,119.97 268.12,119.39 268.12,118.69 267.75,118.32 267.64,118.32 267.64,118.31 266.93,118.31 261.24,112.62 259.79,112.62 258.56,111.39 256.59,111.39 256.27,111.08 254.88,111.08
  BOTTOM w0.089: v1(278.92,118.21) 279.32,118.61 UG17.D5
  BOTTOM w0.135: v1(255.07,110.6) 255.07,110.45 UG1.J2
FBC_WCK1: length 33.9
  IN4 w0.089: 258.31,108.28 258.28,108.28 257.16,107.17 255.46,107.17 255.04,107.58 251.29,107.58 251.16,107.71 251.16,107.89 v1(251.47,108.2)
  IN4 w0.119: v1(271.72,118.21) 271.47,118.46 271.47,119.16 270.96,119.67 268.19,119.67 267.66,119.14 267.66,117.63 267.46,117.43 267.45,117.43 266.38,116.36 266.38,115.94 266.62,115.69 267.01,115.69 267.13,115.57 267.13,115.24 266.98,115.1 266.62,115.1 266.38,114.85 266.38,113.6 263.6,110.82 261,110.82 260.48,110.3 260.32,110.3 259.89,110.73 259.54,110.73 259.17,110.35 259.17,110.01 259.52,109.66 259.52,109.49 258.31,108.28
  BOTTOM w0.089: v1(271.72,118.21) 271.32,117.81 UG17.P4 ; UG1.M6 251.47,108.05 v1(251.47,108.2)
FBC_WCK1_N: length 33.9
  IN4 w0.089: v1(250.67,108.2) 250.98,107.89 250.98,107.64 251.21,107.4 254.97,107.4 255.38,106.99 257.23,106.99 257.84,107.6 258.34,108.09 258.45,108.09 258.49,108.13 258.51,108.13 258.52,108.13 258.52,108.14
  IN4 w0.119: v1(270.92,118.21) 271.26,118.55 271.26,119.07 270.88,119.46 268.28,119.46 267.87,119.05 267.87,117.55 267.79,117.47 267.79,117.46 267.54,117.22 267.54,117.22 266.59,116.27 266.59,116.02 266.71,115.9 267.1,115.9 267.34,115.66 267.34,115.16 267.07,114.88 266.71,114.88 266.59,114.77 266.59,113.52 263.68,110.61 261.09,110.61 260.57,110.09 260.23,110.09 259.8,110.52 259.63,110.52 259.38,110.26 259.38,110.09 259.75,109.72 259.75,109.36 259.1,108.72 259.1,108.72 258.52,108.14
  BOTTOM w0.089: v1(250.67,108.2) 250.67,108.05 UG1.M7 ; UG17.P5 271.32,118.61 v1(270.92,118.21)
FBC_WCK2: length 30.5
  IN1 w0.089: v1(255.97,99.8) 255.62,100.15
  IN1 w0.119: 255.62,100.15 255.62,100.48 256.15,101 257.88,101 262.24,105.35 266.15,105.35 267.32,106.52 267.64,106.52 267.64,106.52 278.5,106.52 279.36,107.39 279.36,108.65 v1(279.72,109.01)
  BOTTOM w0.089: UG1.AA1 255.97,99.65 v1(255.97,99.8) ; UG18.P4 v1(279.72,109.01)
FBC_WCK2_N: length 30.5
  IN1 w0.089: v1(255.07,99.8) 255.42,100.15
  IN1 w0.119: 255.42,100.15 255.42,100.56 256.06,101.21 257.8,101.21 258.58,101.99 258.58,101.99 262.15,105.56 266.07,105.56 267.23,106.73 278.41,106.73 279.15,107.47 279.15,108.78 v1(278.92,109.01)
  BOTTOM w0.089: UG18.P5 v1(278.92,109.01) ; v1(255.07,99.8) 255.07,99.65 UG1.AA2
FBC_WCK3: length 28
  IN3 w0.089: v1(250.67,99.8) 250.36,99.49 250.36,99.25 250.52,99.09 256.54,99.09 257.32,99.87 257.32,99.89 257.43,100 257.49,100 257.5,100.01 257.51,100.01
  IN3 w0.112: 257.51,100.01 259.09,100.01 263.15,104.07 265.99,106.91 267.63,106.91 267.64,106.91 270.4,106.91 271.22,107.73 271.22,108.71 v1(270.92,109.01)
  BOTTOM w0.089: v1(250.67,99.8) 250.67,99.65 UG1.AA7 ; UG18.D4 v1(270.92,109.01)
FBC_WCK3_N: length 28.6
  IN3 w0.089: 257.51,99.81 256.62,98.91 250.44,98.91 250.18,99.17 250.18,99.49 v1(249.87,99.8)
  IN3 w0.112: 257.51,99.81 258.73,99.81 259.02,99.81 259.03,99.81 259.17,99.81 266.07,106.71 270.49,106.71 271.42,107.65 271.42,108.71 v1(271.72,109.01)
  BOTTOM w0.089: UG1.AA8 249.87,99.65 v1(249.87,99.8) ; UG18.D5 271.32,108.61 v1(271.72,109.01)
FBC_WE#_H: length 37.2
  TOP w0.089: 249.49,94.58 v1(249.07,95)
  TOP w0.135: 249.49,94.58 253.75,94.58 254.07,94.9 259.66,94.9 259.85,95.09 259.85,95.28 259.5,95.63 259.5,95.82 259.78,96.1 259.97,96.1 260.32,95.75 260.51,95.75 260.8,96.04 260.8,96.23 260.45,96.58 260.45,96.77 260.73,97.05 260.92,97.05 261.27,96.7 261.46,96.7 261.75,96.99 261.75,97.18 261.4,97.53 261.4,97.72 261.69,98.01 261.88,98.01 262.23,97.66 262.42,97.66 262.7,97.94 262.7,98.13 262.35,98.48 262.35,98.67 262.64,98.96 262.83,98.96 263.18,98.61 263.37,98.61 263.65,98.89 263.65,99.08 263.3,99.43 263.3,99.62 263.59,99.91 263.78,99.91 264.13,99.56 264.32,99.56 264.61,99.85 264.61,100.04 264.26,100.39 264.26,100.58 264.54,100.86 264.73,100.86 265.08,100.51 265.27,100.51 266.98,102.23 273.73,102.23 v1(274.12,102.61)
  BOTTOM w0.089: UG1.AE9 249.07,95.15 v1(249.07,95) ; UG18.G12 v1(274.12,102.61)
FBC_WE#_L: length 45.6
  IN3 w0.089: 247.09,105.95 246.94,105.8 v1(246.67,105.8)
  IN3 w0.112: 247.09,105.95 247.09,106.47 247.25,106.63 247.62,106.63 247.84,106.85 247.84,107.28 248.48,107.92 248.48,108.26 249.5,109.28 249.5,109.55 249.72,109.77 251.32,109.77 252,110.45 252,111.95 252.87,112.82 252.87,113.13 253.8,114.06 253.8,114.35 254.28,114.84 255.19,114.84 255.8,115.44 255.8,116.2 262.02,122.42 263.71,122.42 265.36,124.08 265.82,124.08 265.93,123.96 265.93,123.14 266.04,123.03 266.27,123.03 266.38,123.14 266.38,123.96 266.49,124.08 266.71,124.08 266.83,123.96 266.83,123.14 266.94,123.03 267.16,123.03 267.27,123.14 267.27,123.96 267.38,124.08 267.64,124.08 267.76,124.19 272.09,124.19 272.21,124.08 272.21,123.52 272.32,123.41 272.54,123.41 272.65,123.52 272.65,124.08 272.77,124.19 272.99,124.19 273.1,124.08 273.1,123.52 273.21,123.41 273.44,123.41 273.55,123.52 273.55,124.08 273.66,124.19 273.97,124.19 274.12,124.34 v1(274.12,124.61)
  BOTTOM w0.089: UG1.R12 246.67,105.65 v1(246.67,105.8) ; UG17.L12 273.72,124.21 v1(274.12,124.61)
FBD_ABI#_H: length 49.6
  IN3 w0.089: v1(245.22,85.55) 245.59,85.18 245.59,80.65
  IN3 w0.112: v1(274.92,81.81) 275.34,82.24 275.34,82.84 275.15,83.03 268.2,83.03 267.9,82.73 267.9,80.6 265.98,78.68 265.64,78.68 265.53,78.56 265.53,78.32 265.41,78.21 265.19,78.21 265.08,78.32 265.08,78.56 264.97,78.68 264.74,78.68 264.63,78.56 264.63,78.32 264.52,78.21 264.3,78.21 264.18,78.32 264.18,78.56 264.07,78.68 252.16,78.68 252.07,78.76 251.51,78.76 251.31,78.56 251.31,77.43 251.2,77.32 250.9,77.32 250.79,77.43 250.79,78.41 250.67,78.52 250.45,78.52 250.34,78.41 250.34,77.43 250.23,77.32 250,77.32 249.89,77.43 249.89,78.41 249.78,78.52 249.56,78.52 249.44,78.41 249.44,77.43 249.33,77.32 247.8,77.32 247.09,78.03 246.78,78.03 245.84,78.98 245.84,79.71 245.59,79.95 245.59,80.65
  BOTTOM w0.089: v1(245.22,85.55) 245.07,85.55 UG1.AT14 ; UG20.J4 v1(274.92,81.81)
FBD_ABI#_L: length 35
  IN3 w0.089: 249.38,84.72 248.82,85.28 v1(248.82,85.55)
  IN3 w0.112: 249.38,84.72 255.98,84.72 256.59,84.11 265.38,84.11 267.5,86.23 267.99,86.23 268.1,86.34 268.1,86.72 268.21,86.84 268.44,86.84 268.55,86.72 268.55,86.34 268.66,86.23 268.88,86.23 269,86.34 269,86.72 269.11,86.84 269.33,86.84 269.44,86.72 269.44,86.34 269.56,86.23 269.78,86.23 269.89,86.34 269.89,86.72 270,86.84 270.23,86.84 270.34,86.72 270.34,86.34 270.45,86.23 270.67,86.23 270.78,86.34 270.78,86.72 270.9,86.84 271.12,86.84 271.23,86.72 271.23,86.34 271.34,86.23 271.58,86.23 272.89,87.54 272.89,88.77 273.11,88.99 274.64,88.99 274.92,89.27 v1(274.92,89.41)
  BOTTOM w0.089: v1(248.82,85.55) 248.67,85.55 UG1.AT9 ; UG19.J4 275.32,89.81 v1(274.92,89.41)
FBD_CAS#_H: length 55.3
  IN3 w0.089: v1(244.04,88.68) 244.09,88.68 244.82,87.95 244.82,80.23 245.21,79.85
  IN3 w0.112: v1(274.12,82.61) 274.12,82.44 273.87,82.19 273.57,82.19 273.45,82.07 273.45,81.61 273.34,81.5 273.12,81.5 273.01,81.61 273.01,82.07 272.89,82.19 268.37,82.19 268.15,81.97 268.15,80.25 265.69,77.79 257.24,77.79 257.13,77.68 257.13,77.02 257.02,76.91 256.79,76.91 256.68,77.02 256.68,77.68 256.57,77.79 256.35,77.79 256.23,77.68 256.23,77.02 256.12,76.91 255.9,76.91 255.79,77.02 255.79,77.68 255.67,77.79 255.45,77.79 255.34,77.68 255.34,77.02 255.23,76.91 255,76.91 254.89,77.02 254.89,77.68 254.78,77.79 254.56,77.79 254.45,77.68 254.45,77.02 254.33,76.91 254.11,76.91 254,77.02 254,77.68 253.89,77.79 253.66,77.79 253.55,77.68 253.55,77.02 253.44,76.91 253.22,76.91 253.1,77.02 253.1,77.68 252.99,77.79 252.77,77.79 252.66,77.68 252.66,77.02 252.55,76.91 252.32,76.91 252.21,77.02 252.21,77.68 252.1,77.79 251.88,77.79 251.76,77.68 251.76,77.02 251.65,76.91 247.76,76.91 246.87,77.79 246.68,77.79 245.59,78.88 245.59,79.6 245.35,79.85 245.21,79.85
  BOTTOM w0.089: UG1.AM15 243.87,88.75 243.97,88.75 v1(244.04,88.68) ; v1(274.12,82.61) 273.72,82.21 UG20.G3
FBD_CAS#_L: length 35.6
  IN3 w0.089: 247.99,85.98 v1(247.62,86.35)
  IN3 w0.112: v1(274.12,88.61) 273.69,88.19 273.69,87.39 273.58,87.28 273.22,87.28 271.7,85.76 267.7,85.76 265.63,83.69 265.23,83.69 265.12,83.58 265.12,83.47 265.01,83.36 264.78,83.36 264.67,83.47 264.67,83.58 264.56,83.69 264.33,83.69 264.22,83.58 264.22,83.47 264.11,83.36 263.89,83.36 263.78,83.47 263.78,83.58 263.66,83.69 263.44,83.69 263.33,83.58 263.33,83.47 263.22,83.36 262.99,83.36 262.88,83.47 262.88,83.58 262.77,83.69 262.55,83.69 262.43,83.58 262.43,83.47 262.32,83.36 262.1,83.36 261.99,83.47 261.99,83.58 261.88,83.69 261.65,83.69 261.54,83.58 261.54,83.47 261.43,83.36 261.21,83.36 261.09,83.47 261.09,83.58 260.98,83.69 260.76,83.69 260.65,83.58 260.65,83.47 260.53,83.36 260.31,83.36 260.2,83.47 260.2,83.58 260.09,83.69 259.86,83.69 259.75,83.58 259.75,83.47 259.64,83.36 259.42,83.36 259.31,83.47 259.31,83.58 259.19,83.69 258.97,83.69 258.86,83.58 258.86,83.47 258.75,83.36 258.52,83.36 258.41,83.47 258.41,83.58 258.3,83.69 252.32,83.69 251.54,84.47 250.49,84.47 250.4,84.38 248.21,84.38 247.99,84.6 247.99,85.98
  BOTTOM w0.089: UG19.L3 v1(274.12,88.61) ; UG1.AR11 247.47,86.35 v1(247.62,86.35)
FBD_CKE_H: length 53.3
  IN3 w0.089: v1(245.22,87.15) 245.83,86.54 245.83,81.33 246.28,80.88
  IN3 w0.112: v1(275.72,81.81) 275.83,81.92 275.83,83.03 275.08,83.79 268.37,83.79 266.42,81.84 266.42,79.7 265.81,79.09 264.03,79.09 263.91,79.2 263.91,79.81 263.8,79.93 263.58,79.93 263.47,79.81 263.47,79.2 263.36,79.09 263.13,79.09 263.02,79.2 263.02,79.81 262.91,79.93 262.68,79.93 262.57,79.81 262.57,79.2 262.46,79.09 262.24,79.09 262.13,79.2 262.13,79.81 262.01,79.93 261.79,79.93 261.68,79.81 261.68,79.2 261.57,79.09 261.34,79.09 261.23,79.2 261.23,79.81 261.12,79.93 260.9,79.93 260.78,79.81 260.78,79.2 260.67,79.09 260.45,79.09 260.34,79.2 260.34,79.81 260.23,79.93 260,79.93 259.89,79.81 259.89,79.2 259.78,79.09 259.56,79.09 259.44,79.2 259.44,79.81 259.33,79.93 259.11,79.93 259,79.81 259,79.2 258.88,79.09 258.66,79.09 258.55,79.2 258.55,79.81 258.44,79.93 258.21,79.93 258.1,79.81 258.1,79.2 257.99,79.09 257.77,79.09 257.66,79.2 257.66,79.81 257.54,79.93 253.17,79.93 253.12,79.98 247.32,79.98 246.42,80.88 246.28,80.88
  BOTTOM w0.089: UG1.AP14 245.07,87.15 v1(245.22,87.15) ; UG20.J3 v1(275.72,81.81)
FBD_CKE_L: length 36.1
  IN3 w0.089: 247.17,86.4 v1(246.42,87.15)
  IN3 w0.112: 247.17,86.4 247.17,84.55 247.37,84.35 247.82,84.35 248.72,83.45 256.25,83.45 256.76,82.94 265.54,82.94 267.89,85.29 271.9,85.29 273.62,87.02 274.65,87.02 275.7,88.07 275.7,88.6 v1(275.72,88.61)
  BOTTOM w0.089: v1(246.42,87.15) 246.27,87.15 UG1.AP12 ; UG19.J3 v1(275.72,88.61)
FBD_CLK0: length 39.6
  TOP w0.089: v1(275.72,95.81) 275.33,96.2 v3(275.33,97.21) 275.33,97.75 275.84,98.25 RG74.1
  IN3 w0.089: v1(246.67,91.4) 246.98,91.71 246.98,91.96 247.21,92.2 254.94,92.2 255.53,91.6 257.37,91.6 257.46,91.52 258.64,91.52 258.65,91.52 258.7,91.52 258.72,91.54 258.73,91.54
  IN3 w0.112: 258.73,91.54 264.08,91.54 267.5,94.95 267.5,94.96 267.84,95.3 267.84,97.56 268.37,98.09 274.35,98.09 275.42,97.02 275.42,96.12 v1(275.72,95.81)
  BOTTOM w0.089: v1(246.67,91.4) 246.67,91.55 UG1.AJ12
  BOTTOM w0.099: UG19.J12 v1(275.72,95.81)
FBD_CLK0#: length 38.6
  TOP w0.089: v1(274.92,95.81) 275.15,96.05 275.15,96.96 275.15,96.97 275.15,97.46 275.15,97.46 275.15,98.13 RG75.1
  IN3 w0.089: 258.73,91.34 257.38,91.34 257.3,91.42 255.46,91.42 254.86,92.02 247.29,92.02 247.16,91.89 247.16,91.71 v1(247.47,91.4)
  IN3 w0.112: 258.73,91.34 264.16,91.34 267.64,94.81 268.04,95.22 268.04,97.47 268.45,97.89 274.27,97.89 275.22,96.93 275.22,96.11 v1(274.92,95.81)
  BOTTOM w0.089: v1(247.47,91.4) 247.47,91.55 UG1.AJ11
  BOTTOM w0.099: UG19.J11 v1(274.92,95.81)
FBD_CLK1: length 55.3
  TOP w0.135: RG76.1 275.87,75.41 v1(275.72,75.41)
  IN3 w0.089: 240,88.58 240.25,88.58 v1(240.42,88.75)
  IN3 w0.112: v1(275.72,75.41) 275.55,75.24 275.55,74.98 275.22,74.64 275.22,73.82 273.67,72.27 271.66,72.27 270.6,71.21 268.22,71.21 267.64,71.78 245.42,71.78 240.63,76.57 240.62,76.57 240.62,76.57 240.48,76.71 240.48,78.3 239.72,79.06 239.72,88.3 240,88.58
  BOTTOM w0.089: v1(275.72,75.41) 275.32,75.01 UG20.J12 ; UG1.AM19 240.27,88.75 v1(240.42,88.75)
FBD_CLK1#: length 55.2
  TOP w0.135: v1(274.92,75.41) 275.01,75.41 RG77.1
  IN3 w0.089: 240.08,88.38 240.46,88.38 240.55,88.29 240.55,88.08 240.42,87.95 v1(240.42,87.92)
  IN3 w0.112: 240.08,88.38 239.92,88.22 239.92,79.14 240.68,78.38 240.68,76.79 245.5,71.98 267.72,71.98 268.3,71.41 270.52,71.41 271.58,72.47 273.58,72.47 275.02,73.9 275.02,74.73 275.35,75.06 275.35,75.39 275.21,75.53 275.03,75.53 v1(274.92,75.41)
  BOTTOM w0.089: UG1.AN19 240.27,87.95 240.39,87.95 v1(240.42,87.92) ; v1(274.92,75.41) 275.32,75.81 UG20.J11
FBD_CS#_H: length 54.1
  IN3 w0.089: 238.62,86.55 v1(239.22,87.15)
  IN3 w0.112: v1(276.52,74.61) 276.15,74.24 276.15,73.54 273.14,70.54 254.49,70.54 254.2,70.83 245.41,70.83 239.81,76.43 239.81,77.44 238.62,78.63 238.62,86.55
  BOTTOM w0.089: UG1.AP20 239.07,87.15 v1(239.22,87.15) ; v1(276.52,74.61) 276.92,75.01 UG20.L12
FBD_CS#_L: length 36.4
  IN3 w0.089: v1(246.67,92.7) 246.69,92.7 246.95,92.96 255.71,92.96
  IN3 w0.112: v1(276.52,96.61) 276.12,97.01 276.12,97.66 275.33,98.46 268.34,98.46 267.92,98.03 267.62,98.03 266.97,97.39 266.97,95.37 263.8,92.21 256.47,92.21 255.71,92.96
  BOTTOM w0.089: UG1.AG12 246.67,92.75 v1(246.67,92.7) ; UG19.G12 v1(276.52,96.61)
FBD_D0: length 26.9
  IN4 w0.089: v1(250.67,93.8) 251.05,94.18
  IN4 w0.119: 251.05,94.18 253.79,94.18 253.82,94.2 257.64,98.03 261.72,98.03 263.03,99.34 270.33,99.34 272.52,97.15 v1(272.52,96.61)
  BOTTOM w0.089: v1(250.67,93.8) 250.67,93.95 UG1.AF7 ; UG19.M13 v1(272.52,96.61)
FBD_D1: length 22.7
  IN4 w0.089: v1(252.37,93.8) 252.77,93.4
  IN4 w0.119: v1(269.32,96.61) 268.92,97.01 268.92,98.26 268.79,98.39 263.42,98.39 262.11,97.08 258.41,97.08 257.95,96.62 257.95,95.49 256.85,94.39 255.41,94.39 254.41,93.4 252.77,93.4
  BOTTOM w0.089: UG1.AF5 252.37,93.95 v1(252.37,93.8) ; UG19.T13 v1(269.32,96.61)
FBD_D2: length 23.1
  IN4 w0.089: 253.89,93.8 v1(253.27,93.8)
  IN4 w0.119: v1(271.72,96.61) 271.32,97.01 271.32,97.55 270.01,98.86 263.22,98.86 261.92,97.55 257.64,97.55 253.89,93.8
  BOTTOM w0.089: UG1.AF4 253.27,93.95 v1(253.27,93.8) ; UG19.N13 v1(271.72,96.61)
FBD_D3: length 21.5
  IN4 w0.089: 251.87,93 v1(251.47,92.6)
  IN4 w0.119: 251.87,93 254.58,93 255.53,93.95 256.8,93.95 258.26,95.41 258.26,96.3 258.57,96.6 262.62,96.6 263.51,97.49 268.02,97.49 268.14,97.37 268.14,96.99 v1(268.52,96.61)
  BOTTOM w0.089: UG19.U13 v1(268.52,96.61) ; v1(251.47,92.6) 251.47,92.75 UG1.AG6
