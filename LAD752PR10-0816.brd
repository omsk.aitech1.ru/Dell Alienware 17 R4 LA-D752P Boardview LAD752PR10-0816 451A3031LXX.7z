# Allegro board LAD752PR10-0816.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
GND on TOP (solid shape): 181.3,162.08 181.4,162.08 181.42,162.05 181.47,162.02 181.54,161.93 181.6,161.9 181.62,161.84 181.66,161.71 181.74,161.61 181.77,161.53 181.74,161.45 181.65,161.07 182,160.88 182.03,160.87 182.05,160.84 182.06,160.8 182.08,160.77 182.09,160.73 182.08,160.69 182.08,160.16 182,160.08 181.83,160.08 181.77,160.14 181.77,160.34 181.78,160.35 181.78,160.62 181.65,160.7 181.5,160.74 181.43,160.77 181.41,160.85 181.39,161.02 181.3,161.17 181.29,161.21 181.3,161.24 181.41,161.54 181.29,161.84 181.12,162 181.23,162.08
GND on TOP (solid shape): 181.27,162.08 181.3,162.08 181.4,162.08 181.54,161.93 181.6,161.9 181.62,161.84 181.66,161.71 181.74,161.61 181.77,161.53 181.74,161.45 181.65,161.08 181.98,160.88 182,160.88 182.05,160.84 182.08,160.77 182.09,160.7 182.04,160.64 182.01,160.61 181.97,160.58 181.9,160.55 181.83,160.58 181.68,160.69 181.5,160.74 181.43,160.77 181.41,160.85 181.39,161.02 181.31,161.17 181.3,161.17 181.29,161.21 181.3,161.24 181.31,161.25 181.41,161.55 181.29,161.84 181.16,161.96 181.15,162 181.17,162.04 181.22,162.07
GND on TOP (solid shape): 239.06,91.76 239.06,91.53 239.43,91.15 240.38,91.15 240.42,91.11 240.42,90.67 240.37,90.66 240.11,90.43 240.22,90.1 240.26,90.03 240.23,89.95 240.1,89.82 239.39,89.82 239.38,89.83 239.12,89.85 238.93,89.68 238.92,89.66 238.32,89.66 238.31,89.68 238.02,89.87 237.73,89.68 237.72,89.66 237.29,89.66 236.67,89.03 236.59,88.97 236.54,88.9 236.48,88.84 236.48,88.52 236.41,88.45 236.05,88.45 236,88.5 236,89.54 235.97,89.56 235.97,89.58 235.84,89.71 235.84,90.31 235.88,90.35 236.5,90.35 236.51,90.3 236.78,90.03 237.11,90.23 237.12,90.24 237.72,90.24 237.73,90.21 238.02,90.03 238.31,90.21 238.32,90.24 238.84,90.24 239.05,90.45 239.05,91.22 238.91,91.37 238.65,91.37 238.62,91.41 238.62,91.78 238.64,91.81 239.02,91.81
GND on TOP (solid shape): outline of 135 points within 267.41,82.96 273.08,86.52
GND on TOP (solid shape): 227.67,183.95 228.23,183.71 228.47,183.15 228.47,182.65 228.82,181.8 229.67,181.45 230.47,181.45 230.47,175.69 231.07,174.99 231.85,175.49 238.3,175.49 239.08,174.99 239.68,175.69 239.68,181.45 240.47,181.45 241.24,181.72 241.65,182.42 241.67,182.42 241.67,182.62 241.91,183.17 242.47,183.4 244.71,183.4 244.71,175.58 244.55,175.42 244.23,175.42 244.04,175.23 244.04,173.58 240.99,170.53 240.29,170.53 239.98,170.85 239.98,172.37 240.23,172.63 240.23,174.28 239.76,174.74 239.64,174.74 238.77,174.55 238.02,175.03 232.13,175.03 231.54,174.59 230.8,174.59 230.13,174.59 229.75,174.21 229.75,172.82 230.2,172.37 230.2,170.59 229.82,170.21 228.29,170.21 227.08,171.42 223.47,171.42 223.08,171.8 223.08,172.12 223.11,172.14 223.11,174.43 223,174.53 222.92,174.64 222.04,174.64 222.04,175.1 223.2,175.1 223.97,174.6 224.57,175.3 224.57,183.95
GND on TOP (solid shape): 176.75,166.86 176.82,166.83 176.85,166.76 176.89,166.61 177.01,166.51 177.04,166.5 177.04,166.31 177.01,166.3 176.85,166.08 177.01,165.86 177.04,165.85 177.04,165.66 177.01,165.65 176.85,165.43 177.01,165.21 177.04,165.2 177.04,165.01 177.01,165 176.85,164.78 177.01,164.56 177.04,164.55 177.04,164.36 177.01,164.35 176.85,164.13 177.01,163.91 177.04,163.9 177.04,163.71 177.01,163.7 176.85,163.48 177.01,163.26 177.04,163.25 177.04,163.06 177.01,163.05 176.91,162.98 176.86,162.88 176.85,162.83 176.82,162.76 176.75,162.74 176.34,162.74 176.28,162.8 176.28,163.09 176.37,163.17 176.39,163.17 176.61,163.41 176.37,163.63 176.31,163.66 176.28,163.73 176.28,164.01 176.37,164.09 176.39,164.09 176.61,164.33 176.37,164.55 176.31,164.58 176.28,164.65 176.28,164.93 176.37,165.01 176.39,165.01 176.61,165.25 176.37,165.47 176.31,165.5 176.28,165.57 176.28,165.85 176.37,165.93 176.39,165.93 176.61,166.17 176.37,166.39 176.31,166.42 176.28,166.49 176.28,166.75 176.39,166.85 176.42,166.85 176.45,166.86
GND on TOP (solid shape): outline of 115 points within 16.02,0.2 338.22,183.4
GND on TOP (solid shape): outline of 241 points within 0.2,34.2 211.24,185.55
GND on TOP (solid shape): outline of 1402 points within 177.59,160.04 186.2,169.55
GND on BOTTOM (solid shape): 15.06,49.88 15.06,47.09 14.74,46.77 11.69,46.77 11.12,47.34 11.12,49.88 11.5,50.26 14.68,50.26
GND on BOTTOM (solid shape): 39.7,50.71 39.7,48.7 39.57,48.58 38.59,48.58 38.36,48.8 38.36,50.77 38.55,50.96 39.44,50.96
GND on BOTTOM (solid shape): 67.38,5.62 67.38,4.29 67.26,4.17 64.71,4.17 64.59,4.29 64.59,5.62 64.78,5.81 67.19,5.81
GND on BOTTOM (solid shape): 121.16,106.52 121.16,104.37 120.97,104.18 119.96,104.18 119.83,104.3 119.83,106.52 119.96,106.65 121.04,106.65
GND on BOTTOM (solid shape): 125.86,106.52 125.86,104.3 125.74,104.18 124.66,104.18 124.53,104.3 124.53,106.46 124.72,106.65 125.74,106.65
GND on BOTTOM (solid shape): 162.97,128.28 162.97,124.93 162.87,124.83 160.44,124.83 160.36,124.9 160.36,128.29 160.5,128.42 162.83,128.42
GND on BOTTOM (solid shape): 220.13,62.05 220.13,58.27 219.91,58.06 216.9,58.06 216.65,58.31 216.65,61.7 217.23,62.27 219.9,62.27
GND on BOTTOM (solid shape): 223.47,73.76 223.47,70.33 223.15,70.01 219.85,70.01 219.46,70.39 219.46,73.76 219.66,73.95 223.27,73.95
GND on BOTTOM (solid shape): 255.47,71.66 255.47,69.69 254.77,68.99 250.01,68.99 249.85,69.15 249.85,71.69 250.2,72.04 255.09,72.04
GND on BOTTOM (solid shape): 257.63,38.58 257.63,36.61 257.31,36.29 254.26,36.29 253.79,36.77 253.79,38.93 254.39,39.53 256.68,39.53
GND on BOTTOM (solid shape): 264.67,88.02 264.67,84.59 263.77,83.69 260.34,83.69 260.12,83.91 260.12,87.83 260.71,88.42 264.26,88.42
GND on BOTTOM (solid shape): 268.74,45.88 268.74,42.77 268.23,42.26 265.88,42.26 265.22,42.93 265.22,45.85 265.69,46.32 268.3,46.32
GND on BOTTOM (solid shape): 264.91,29.2 264.91,28.67 264.72,28.48 261.37,28.48 261.24,28.6 261.24,29.29 261.38,29.43 264.69,29.43
GND on BOTTOM (solid shape): 90.18,50.01 90.18,46.77 89.99,46.58 88.15,46.58 87.83,46.9 87.83,49.88 88.08,50.13 90.05,50.13
GND on BOTTOM (solid shape): 148.83,12.17 148.83,4.27 148.73,4.17 147.1,4.17 147.01,4.26 147.01,12.15 147.16,12.3 148.7,12.3
GND on BOTTOM (solid shape): 221.14,18.63 221.14,17.65 221.04,17.55 219.58,17.55 219.36,17.77 219.36,18.64 219.62,18.9 220.87,18.9
GND on BOTTOM (solid shape): 257.69,154.34 257.69,152.11 257.35,151.77 254.39,151.77 254.34,151.82 254.34,154.62 254.45,154.73 257.3,154.73
GND on BOTTOM (solid shape): 262.42,61.11 262.42,58.07 261.4,57.06 256.55,57.06 255.32,58.29 255.32,61.03 255.52,61.23 259.42,61.23 259.75,61.56 261.96,61.56
GND on BOTTOM (solid shape): 309.3,10.2 309.3,8.32 309.16,8.19 306.83,8.19 305.83,9.19 305.83,9.89 305.4,10.32 305.4,11.02 305.56,11.19 308.31,11.19
GND on BOTTOM (solid shape): 129.14,110.73 129.26,110.61 129.26,104.92 129.12,104.78 127.76,104.78 127.52,105.03 127.52,106.34 128.46,107.29 128.46,110.64 128.56,110.73 129.14,110.73
GND on BOTTOM (solid shape): 162.28,170.19 162.28,167.54 162.7,167.12 162.7,166.29 162.58,166.18 161.12,166.18 161.12,167.85 160.74,168.23 160.74,169.79 161.27,170.32 162.14,170.32
GND on BOTTOM (solid shape): 171.14,127.67 172.86,127.67 172.92,127.6 172.92,125.06 172.67,124.81 169.81,124.81 168.98,125.64 168.98,127.98 169.36,128.37 170.44,128.37
GND on BOTTOM (solid shape): 43.44,30.7 43.44,26.45 43.19,26.19 41.41,26.19 41.22,26.38 41.22,27.85 40.9,28.16 40.52,28.16 40.33,28.35 40.33,30.77 40.59,31.02 43.13,31.02
GND on BOTTOM (solid shape): 119.09,106.99 119.09,105.81 118.97,105.69 117.98,105.69 117.88,105.79 117.88,107.03 117.94,107.1 118.99,107.1
GND on BOTTOM (solid shape): 146.57,127.41 146.57,124.37 145.52,123.32 143.49,123.32 143.23,123.57 143.23,127.44 143.52,127.73 146.25,127.73
GND on BOTTOM (solid shape): 269.12,60.48 269.12,57.82 268.93,57.63 265.12,57.63 264.93,57.82 264.93,60.48 265.06,60.61 268.99,60.61
GND on BOTTOM (solid shape): 57.37,11.13 57.37,11.12 57.45,11.04 57.45,9.4 57.26,9.21 56.04,9.21 55.92,9.33 55.92,11.07 56.14,11.29 57.2,11.29
GND on BOTTOM (solid shape): 156.61,161.47 156.61,159.04 156.34,158.77 152.66,158.77 152.17,158.27 143.17,158.27 142.38,159.06 142.38,161.92 142.5,162.03 156.04,162.03
GND on BOTTOM (solid shape): 183.59,141.7 183.4,141.51 181.36,141.51 181.3,141.57 181.3,141.7 181.36,141.76 182.22,141.76 182.29,141.83 182.29,142.49 182.44,142.65 183.59,142.65
GND on BOTTOM (solid shape): 238.87,36.75 238.87,35.67 238.66,35.46 237.38,35.46 237.29,35.54 237.29,35.96 237.17,36.09 236.57,36.09 236.52,36.13 236.52,36.74 236.62,36.84 238.78,36.84
GND on BOTTOM (solid shape): 247.4,29.18 247.4,25.06 247.29,24.95 247.05,24.95 247.05,24.95 239.68,24.95 239.62,25.01 239.62,28.89 240.55,29.81 246.77,29.81
GND on BOTTOM (solid shape): 267.42,19.54 267.42,18.33 266.81,17.72 266.81,16.88 266.29,16.36 264.4,16.36 264.26,16.5 264.26,16.9 264.88,17.52 264.88,20.36 264.92,20.4 266.56,20.4
GND on BOTTOM (solid shape): 264.23,78.33 264.23,74.84 263.91,74.52 253.12,74.52 252.8,74.84 252.8,76.23 253.18,76.61 254.52,76.61 255.34,77.44 256.61,77.44 256.93,77.76 256.93,78.58 257.82,79.47 263.09,79.47
GND on BOTTOM (solid shape): 143.45,146.34 143.43,146.31 142.37,146.31 141.83,145.77 140.91,145.77 140.85,145.83 140.85,145.96 140.98,146.09 141.71,146.09 142.05,146.43 142.05,147.36 142.12,147.42 143.45,147.42
GND on BOTTOM (solid shape): 151.78,146.36 151.76,146.34 150.7,146.34 150.16,145.79 149.24,145.79 149.18,145.86 149.18,145.98 149.31,146.11 150.04,146.11 150.39,146.45 150.39,147.38 150.45,147.44 151.78,147.44
GND on BOTTOM (solid shape): 159.47,143.1 159.44,143.08 158.39,143.08 157.84,142.53 156.93,142.53 156.86,142.59 156.86,142.72 156.99,142.85 157.73,142.85 158.07,143.19 158.07,144.12 158.13,144.18 159.47,144.18
GND on BOTTOM (solid shape): 167.8,143.05 167.77,143.02 166.72,143.02 166.17,142.48 165.26,142.48 165.19,142.54 165.19,142.67 165.32,142.8 166.06,142.8 166.4,143.14 166.4,144.07 166.46,144.13 167.8,144.13
GND on BOTTOM (solid shape): 176.14,143.08 176.12,143.05 175.06,143.05 174.52,142.5 173.6,142.5 173.54,142.57 173.54,142.69 173.66,142.82 174.4,142.82 174.74,143.16 174.74,144.09 174.81,144.15 176.14,144.15
GND on BOTTOM (solid shape): 92.4,42.82 92.4,41.81 92.48,41.72 92.48,41.46 92.35,41.33 91.51,41.33 91.43,41.41 91.43,41.67 91.56,41.81 91.99,41.81 92.15,41.97 92.15,42.83 92.23,42.9 92.32,42.9
GND on BOTTOM (solid shape): 156.84,115.42 156.84,115.23 156.46,114.85 156.46,114.22 156.8,113.88 156.8,113.63 156.67,113.5 155.91,113.5 155.78,113.63 155.78,113.92 156.02,114.15 156.02,114.98 156.4,115.36 156.4,115.42 156.53,115.55 156.72,115.55
GND on BOTTOM (solid shape): 190.02,94.32 190.13,94.3 190.24,94.32 190.24,94.32 191.22,94.32 191.47,94.08 191.47,93.38 191.25,93.16 189.84,93.16 189.62,93.38 189.62,94.06 189.89,94.32 190.01,94.32
GND on BOTTOM (solid shape): 265.58,7.19 265.47,6.5 265.58,5.81 265.58,3.2 258.56,3.2 258.56,10.01 265.58,10.01
GND on BOTTOM (solid shape): 149.73,115.46 149.73,115.27 149.35,114.9 149.35,114.15 149.29,114.09 149.03,114.09 148.91,114.22 148.91,114.85 148.53,115.23 148.53,115.42 148.65,115.55 148.84,115.55 148.99,115.41 149.26,115.41 149.42,115.57 149.61,115.57
GND on BOTTOM (solid shape): 229.12,58.18 229.12,54.11 228.87,53.86 227.85,53.86 227.73,53.99 227.73,54.37 227.44,54.65 222.59,54.65 222.53,54.72 222.53,57.16 223.67,57.16 223.67,56.54 224.46,56.54 224.46,57.15 227.33,57.15 228.55,58.37 228.93,58.37
GND on BOTTOM (solid shape): 263.9,23.89 263.9,23.22 264.03,23.08 264.49,23.08 264.62,22.95 264.62,21.06 264.57,21.01 263.67,21.01 263.65,20.99 263.6,20.99 263.41,20.8 263.22,20.8 263.04,20.97 263.04,23.91 263.22,24.09 263.7,24.09
GND on BOTTOM (solid shape): 24.2,47.47 24.2,44.04 24.65,43.59 24.65,42.58 24.42,42.35 22.71,42.35 22.11,41.75 21.22,41.75 21.09,41.88 21.09,44.23 21.19,44.32 21.5,44.32 22.04,44.86 22.04,47.4 22.3,47.66 24.01,47.66
GND on BOTTOM (solid shape): 76.02,50.58 76.02,48.96 75.7,48.64 75.7,40.16 75.57,40.04 67.45,40.04 67.32,40.16 67.32,50.45 67.64,50.77 75.83,50.77
GND on BOTTOM (solid shape): 118.12,120.3 118.12,116.81 118.56,116.36 118.56,115.8 118.37,115.61 117.61,115.61 117.48,115.73 117.48,116.81 117.48,116.81 117.48,119.98 117.48,119.98 117.48,120.11 117.29,120.3 117.29,120.68 117.36,120.75 117.67,120.75
GND on BOTTOM (solid shape): 139.55,115.38 139.74,115.38 139.95,115.58 140.11,115.58 140.27,115.42 140.27,115.23 139.89,114.85 139.89,114.22 139.76,114.09 139.51,114.09 139.44,114.15 139.44,114.86 139.06,115.25 139.06,115.44 139.2,115.58 139.35,115.58
GND on BOTTOM (solid shape): 141.9,115.38 142.09,115.38 142.3,115.58 142.46,115.58 142.62,115.42 142.62,115.23 142.24,114.85 142.24,114.22 142.11,114.09 141.86,114.09 141.79,114.15 141.79,114.86 141.41,115.25 141.41,115.44 141.55,115.58 141.7,115.58
GND on BOTTOM (solid shape): 144.31,115.38 144.51,115.38 144.71,115.58 144.87,115.58 145.03,115.42 145.03,115.23 144.65,114.85 144.65,114.22 144.52,114.09 144.27,114.09 144.21,114.15 144.21,114.86 143.82,115.25 143.82,115.44 143.96,115.58 144.11,115.58
GND on BOTTOM (solid shape): 146.66,115.38 146.86,115.38 147.06,115.58 147.22,115.58 147.38,115.42 147.38,115.23 147,114.85 147,114.22 146.87,114.09 146.62,114.09 146.56,114.15 146.56,114.86 146.17,115.25 146.17,115.44 146.31,115.58 146.46,115.58
GND on BOTTOM (solid shape): 148.01,145.83 148.01,145.31 148.66,144.66 148.66,139.28 148.34,138.97 146.5,138.97 146.03,139.45 146.03,143.7 145.77,143.96 142.09,143.96 142.09,145.1 142.91,145.1 142.91,145.99 147.85,145.99
GND on BOTTOM (solid shape): 152.07,115.44 152.07,115.25 151.7,114.87 151.7,114.15 151.64,114.09 151.38,114.09 151.26,114.22 151.26,114.85 150.87,115.23 150.87,115.42 151,115.55 151.19,115.55 151.34,115.41 151.59,115.41 151.77,115.58 151.94,115.58
GND on BOTTOM (solid shape): 237.82,57.18 237.82,53.12 237.56,52.86 236.55,52.86 236.42,52.99 236.42,53.37 236.1,53.69 231.29,53.69 231.24,53.74 231.24,56.14 231.25,56.15 232.37,56.15 232.37,55.54 233.15,55.54 233.15,56.15 236.03,56.15 237.24,57.37 237.63,57.37
GND on BOTTOM (solid shape): 246.39,57.18 246.39,53.12 246.13,52.86 245.12,52.86 244.99,52.99 244.99,53.37 244.67,53.69 239.82,53.69 239.81,53.7 239.81,56.14 239.81,56.15 240.94,56.15 240.94,55.54 241.72,55.54 241.72,56.15 244.59,56.15 245.82,57.37 246.2,57.37
GND on BOTTOM (solid shape): 251.15,50.82 251.15,50.26 251.35,50.06 255.97,50.06 256.16,49.88 256.16,48.23 255.77,47.84 251.53,47.84 250.52,48.85 250.52,50.83 250.56,50.88 251.09,50.88
GND on BOTTOM (solid shape): 254.96,57.18 254.96,55.45 255.47,54.94 255.47,53.83 255.32,53.68 248.44,53.68 248.38,53.74 248.38,56.1 248.43,56.15 249.5,56.15 249.5,55.54 250.29,55.54 250.29,56.15 253.17,56.15 254.38,57.37 254.77,57.37
GND on BOTTOM (solid shape): 99.26,44.67 99.26,43.09 98.81,42.64 98.81,41.69 98.94,41.56 98.94,41.56 99.04,41.47 99.04,40.39 99.1,40.32 99.95,40.32 100.08,40.19 100.08,38.13 99.83,37.88 98.32,37.88 98.12,38.08 98.12,44.55 98.43,44.86 99.07,44.86
GND on BOTTOM (solid shape): 79.24,19.32 79.84,19.32 80.07,19.1 80.07,18.02 80.21,17.88 81.29,17.88 81.73,17.43 81.73,10.57 81.48,10.32 75.07,10.32 74.94,10.45 74.94,17.24 74.94,17.24 74.94,18.9 75.36,19.32 79.24,19.32
GND on BOTTOM (solid shape): 186.31,141.13 186.31,139.67 186.06,139.42 184.79,139.42 184.6,139.61 182.25,139.61 182.06,139.42 182.06,137.83 181.94,137.7 181.68,137.7 181.56,137.83 181.56,138.59 181.11,139.03 181.11,140.31 181.24,140.43 183.01,140.43 183.01,141.26 186.19,141.26
GND on BOTTOM (solid shape): 195.42,18.38 195.42,18.32 195.42,18.09 195.27,17.95 195.27,16.51 195.11,16.35 194.87,16.35 194.58,16.64 194.58,18.25 194.65,18.33 195.04,18.33 195.2,18.48 195.32,18.48
GND on BOTTOM (solid shape): 234.07,50.83 234.07,50.26 234.2,50.13 237.5,50.13 237.53,50.1 238.69,50.1 238.89,49.9 238.89,48.6 238.2,47.91 233.63,47.91 233.24,48.3 233.24,50.15 233.37,50.29 233.37,50.83 233.43,50.9 234.01,50.9
GND on BOTTOM (solid shape): 242.64,50.83 242.64,50.26 242.77,50.13 246.07,50.13 246.1,50.1 247.26,50.1 247.46,49.9 247.46,48.6 246.77,47.91 242.2,47.91 241.81,48.3 241.81,50.15 241.94,50.29 241.94,50.83 242.01,50.9 242.58,50.9
GND on BOTTOM (solid shape): 273.8,166.52 274.22,166.52 274.34,166.47 274.69,166.12 275.61,166.12 275.67,166.11 275.77,166.01 275.77,165.31 275.63,165.17 273.66,165.17 273.47,165.36 272.07,165.36 271.86,165.58 271.86,167.24 272.1,167.48 272.84,167.48
GND on BOTTOM (solid shape): 9.57,66.3 1.27,66.3 1.27,72.1 1.51,72.66 2.07,72.9 9.57,72.9
GND on BOTTOM (solid shape): 172.36,142.54 172.36,142.26 172.46,142.16 172.59,142.16 172.63,142.14 172.85,141.92 172.91,141.92 173,141.82 173,137.48 172.82,137.29 170.67,137.29 170.37,137.59 170.37,140.41 170.12,140.67 166.43,140.67 166.43,141.81 167.26,141.81 167.26,142.7 172.2,142.7
GND on BOTTOM (solid shape): 198.72,185.08 198.8,185.03 198.87,184.97 200.3,183.7 200.67,183.48 201.1,183.4 202.04,183.4 205.72,183.4 205.72,176.7 198.72,176.7
GND on BOTTOM (solid shape): 179.79,142.21 179.97,142.21 180.16,142.02 180.16,140.62 180.48,140.3 180.67,140.3 180.79,140.18 180.79,138.95 181.35,138.4 181.35,135.59 180.86,135.1 179.21,135.1 178.98,135.33 178.98,140.18 178.46,140.69 174.78,140.69 174.78,141.84 175.6,141.84 175.6,142.72 179.27,142.72
GND on BOTTOM (solid shape): 87.45,33.62 87.45,32.99 87.19,32.73 87.19,28.35 87.58,27.97 88.65,27.97 88.7,27.93 88.7,27.38 88.65,27.34 87.19,27.34 86.37,28.16 81.48,28.16 81.29,28.35 81.29,31.53 81.86,32.1 83.7,32.1 84.15,32.54 84.15,33.43 84.59,33.88 87.19,33.88
GND on BOTTOM (solid shape): 91.99,45.94 91.99,45.09 92.14,44.94 92.51,44.94 92.57,45 92.57,45.94 92.62,45.99 92.74,45.99 92.78,45.96 92.78,44.99 92.91,44.87 93.49,44.87 93.52,44.84 93.52,43.16 93.49,43.13 91.82,43.13 91.76,43.2 91.76,44.93 91.75,44.94 91.75,45.92 91.84,46.01 91.92,46.01
GND on BOTTOM (solid shape): 225.38,51.83 225.38,51.26 225.5,51.13 225.51,51.13 225.51,49.97 225.83,49.65 228.8,49.65 229.04,49.89 229.04,50.9 229.24,51.1 229.99,51.1 230.2,50.9 230.2,48.11 229.59,47.5 225.26,47.5 224.47,48.29 224.47,50.62 224.49,50.62 224.49,51.09 224.68,51.28 224.68,51.83 224.74,51.89 225.31,51.89
GND on BOTTOM (solid shape): 158.48,115.4 158.67,115.4 158.7,115.42 158.75,115.42 158.88,115.55 159.07,115.55 159.19,115.42 159.19,115.23 158.81,114.85 158.81,114.22 159.21,113.82 159.21,113.63 159.08,113.5 158.32,113.5 158.19,113.63 158.19,114.09 158.37,114.27 158.37,114.83 157.97,115.22 157.97,115.44 158.11,115.58 158.3,115.58
GND on BOTTOM (solid shape): 260.04,25.72 260.04,22.85 260.49,22.41 260.49,22.02 257.16,18.69 254.66,18.69 254.39,18.96 254.39,20.44 254.96,21.01 254.96,22.32 255.47,22.83 255.47,23.27 255.6,23.4 256.12,23.4 256.31,23.59 256.31,24.4 256.04,24.67 256.04,25.56 256.29,25.81 257.57,25.81 257.83,26.08 259.68,26.08
GND on BOTTOM (solid shape): 275.03,56.15 275.03,55.21 275.15,55.09 276.68,55.09 277.12,54.64 277.12,53.12 277.76,52.48 277.76,51.98 277.69,51.91 277.12,51.91 276.74,52.29 275.23,52.29 274.77,51.83 273.76,51.83 273.63,51.96 273.63,52.34 273.31,52.66 268.49,52.66 268.45,52.7 268.45,55.1 268.47,55.12 269.58,55.12 269.58,54.51 270.36,54.51 270.36,55.12 273.24,55.12 274.46,56.34 274.84,56.34
GND on BOTTOM (solid shape): 182.57,164.69 182.66,164.69 182.72,164.62 182.72,163.58 182.68,163.54 182.32,163.54 182.27,163.58 182.27,164 182.18,164.1 181.64,164.1 181.58,164.04 181.58,163.89 181.49,163.8 181.11,163.8 181.1,163.81 181.1,164.21 181.14,164.24 181.49,164.24 181.68,164.43 181.68,164.62 181.75,164.69 182.57,164.69
GND on BOTTOM (solid shape): 277.82,49.69 277.82,48.48 277.38,48.04 275.69,48.04 275.65,48 274.27,47.64 273.07,46.88 270.47,46.88 270.15,47.2 270.15,49.09 270.16,49.1 274.69,49.1 275.34,49.75 277.76,49.75
GND on BOTTOM (solid shape): 57.6,24.15 57.6,23.65 57.73,23.53 58.94,23.53 59.38,23.97 59.89,23.97 59.95,23.91 59.95,22.38 59.7,22.13 58.94,22.13 58.75,21.94 58.75,21.05 58.24,20.54 55.63,20.54 55.44,20.73 55.44,21.5 55.89,21.94 55.89,22.96 55.7,23.15 55.38,23.15 54.99,23.54 54.99,24.2 55.04,24.25 57.5,24.25
GND on BOTTOM (solid shape): 186.72,176.7 179.72,176.7 179.72,183.6 180.55,183.6 180.87,183.45 181.22,183.4 183.27,183.4 184.34,183.4 184.77,183.48 185.14,183.7 186.57,184.97 186.64,185.03 186.72,185.08
GND on BOTTOM (solid shape): 163.1,115.51 163.14,115.47 163.19,115.42 163.29,115.42 163.45,115.42 163.57,115.55 163.77,115.55 163.89,115.42 163.89,115.23 163.51,114.85 163.51,113.61 163.4,113.5 163.08,113.5 162.98,113.6 162.98,113.78 162.98,114.93 162.7,115.21 162.7,115.48 162.82,115.6 163.01,115.6
GND on BOTTOM (solid shape): 161.57,115.45 161.57,115.26 161.16,114.85 161.16,114.15 161.37,113.95 161.5,113.95 161.62,113.82 161.62,113.63 161.56,113.57 160.67,113.57 160.61,113.63 160.61,114.11 160.72,114.22 160.72,114.85 160.34,115.23 160.34,115.42 160.46,115.55 160.65,115.55 160.78,115.42 160.93,115.42 161.07,115.42 161.23,115.58 161.44,115.58
GND on BOTTOM (solid shape): 122.69,121 122.69,119.6 122.5,119.42 121.99,119.42 121.73,119.16 121.73,117.7 122.15,117.28 122.15,117.28 122.15,116.4 121.73,115.99 121.73,114.46 122.62,113.57 122.62,113.28 122.75,113.16 123.37,113.16 123.41,113.12 123.41,112.57 123.28,112.45 121.66,112.45 121.48,112.62 121.42,112.68 121.42,115.86 120.97,116.3 120.97,119.35 121.1,119.48 121.1,119.48 121.1,120.94 121.23,121.07 122.62,121.07
GND on BOTTOM (solid shape): 164.03,142.59 164.03,142.59 164.14,142.47 164.14,142.29 164.1,142.15 164.14,142 164.15,141.99 164.31,141.88 164.5,141.89 164.78,141.89 165.01,141.66 165.01,137.64 164.84,137.47 162.04,137.47 161.91,137.6 161.91,140.6 161.79,140.72 158.1,140.72 158.1,141.86 158.93,141.86 158.93,142.75 163.87,142.75
GND on BOTTOM (solid shape): 214.63,74.91 214.63,74.13 214.5,74.01 214.5,74.01 212.99,72.5 212.99,69.5 212.86,69.37 211.39,69.37 211.31,69.38 211.23,69.37 210.85,69.37 210.51,69.72 210.51,72.27 209.55,73.23 208.03,73.23 207.89,73.37 207.89,74.19 208.06,74.36 209.61,74.36 210.03,74.79 210.16,74.79 210.16,74.78 210.83,74.78 210.89,74.72 210.89,73.99 211.02,73.87 212.08,73.87 212.3,74.09 212.3,74.89 212.39,74.97 214.57,74.97
GND on BOTTOM (solid shape): 37.65,20.48 37.72,20.45 37.75,20.39 38.11,20.06 38.46,20.39 38.47,20.41 38.53,20.48 39.06,20.48 39.32,20.23 39.32,17.81 38.97,17.46 37.06,17.46 36.97,17.37 34.74,17.37 34.49,17.62 34.49,20.16 34.81,20.48
GND on BOTTOM (solid shape): 173.55,174.72 173.55,173.45 173.36,173.26 173.14,173.26 173.13,173.27 172.98,173.3 172.83,173.27 172.82,173.26 172.51,173.26 172.5,173.27 172.35,173.3 172.2,173.27 172.19,173.26 171.87,173.26 171.86,173.27 171.71,173.3 171.56,173.27 171.55,173.26 169.93,173.26 169.74,173.45 169.74,174.66 170.19,175.1 173.17,175.1
GND on BOTTOM (solid shape): 32.93,46.31 32.93,38.82 32.51,38.4 31.55,38.4 31.29,38.51 31.03,38.4 30.92,38.4 30.65,38.51 30.39,38.4 30.15,38.4 29.8,38.74 29.8,42.31 29.97,42.48 29.97,43.91 29.96,43.92 29.96,46.46 30.16,46.67 31.03,46.67 31.25,46.88 32.36,46.88
GND on BOTTOM (solid shape): 179.26,171.18 179.25,171.15 179.23,171.01 179.26,170.89 179.27,170.88 179.27,170.34 179.04,170.11 178.93,170.11 178.87,170.06 178.87,168.5 179.09,168.28 179.7,168.28 179.78,168.36 179.78,168.47 179.88,168.57 180.16,168.57 180.29,168.45 180.29,167.55 180.16,167.42 180.01,167.42 179.9,167.42 179.76,167.56 179.76,167.57 179.65,167.67 179.27,167.67 178.82,168.12 178.57,168.12 178.44,168.24 178.44,168.88 178.25,169.07 178.25,170.72 178.82,171.29 179.14,171.29
GND on BOTTOM (solid shape): 154.46,115.45 154.46,115.2 154.4,115.14 154.36,115.06 154.35,115.05 154.13,114.83 154.13,114.33 153.92,114.12 153.64,114.12 153.4,114.36 153.4,114.99 153.34,115.05 153.33,115.07 153.29,115.14 153.22,115.2 153.19,115.22 153.19,115.41 153.33,115.55 153.6,115.55 153.66,115.48 153.72,115.44 153.91,115.42 154.06,115.53 154.11,115.58 154.34,115.58
GND on BOTTOM (solid shape): 216.1,18.82 216.1,18.44 216.2,18.34 217,18.34 217.11,18.23 216.76,17.71 217.28,18.06 217.76,17.58 217.76,17.41 217.63,17.28 216.26,17.28 215.83,17.71 215.83,17.89 215.73,17.98 215.73,18.87 215.8,18.94 215.98,18.94
GND on BOTTOM (solid shape): 196.24,20 196.24,19.39 196.04,19.19 196,19.2 195.78,19.19 195.6,19.05 195.57,19.03 195.52,18.99 195.46,19.01 195.3,19.17 194.93,19.17 194.92,19.15 194.8,19.03 194.7,19.03 194.63,19.09 194.63,19.32 194.66,19.37 194.72,19.39 194.79,19.39 194.87,19.41 195,19.58 194.96,19.79 194.96,19.95 195.14,20.13 196.1,20.13
GND on BOTTOM (solid shape): 154.98,100.79 154.98,100.56 154.78,100.35 154.76,100.35 154.7,100.34 154.64,100.31 154.63,100.31 154.56,100.31 154.54,100.28 154.54,100.18 154.54,100.18 154.52,100.1 154.54,100.02 154.54,100.01 154.54,99.96 154.56,99.94 154.56,99.7 154.46,99.59 154.27,99.59 154.24,99.56 154.23,99.56 154.09,99.48 154.02,99.35 154.01,99.33 153.97,99.29 153.76,99.29 153.68,99.38 153.68,99.6 153.68,99.61 153.72,99.77 153.68,99.93 153.68,99.94 153.68,100.14 154.23,100.7 154.42,100.7 154.61,100.89 154.88,100.89
GND on BOTTOM (solid shape): 16.58,31.97 16.58,30.58 14.75,28.74 1.27,28.74 1.27,30.1 1.51,30.66 2.07,30.9 11.68,30.9 12.45,30.4 13.05,31.1 13.05,31.85 13.37,32.16 16.39,32.16
GND on BOTTOM (solid shape): 156.28,145.68 156.28,143.31 156.25,143.27 156.22,143.23 156.16,143.16 156.16,143.12 156.13,143.05 156.05,143.02 155.77,142.74 156.05,142.46 156.08,142.46 156.28,142.26 156.28,142.13 156.73,141.68 156.73,138.97 156.73,138.97 156.73,137.83 156.6,137.7 154.57,137.7 154.36,137.91 154.36,142.04 154.11,142.28 154.11,142.6 154.19,142.68 154.19,143.79 154,143.98 150.42,143.98 150.42,145.12 151.25,145.12 151.25,146.01 155.94,146.01
GND on BOTTOM (solid shape): 93.29,25.81 93.29,24.8 93.8,24.29 97.57,24.29 97.69,24.16 97.69,21.48 97.64,21.44 93.81,21.44 93.69,21.56 89.99,21.56 89.8,21.75 89.8,23.01 92.97,23.01 92.98,22.95 92.99,22.9 93.01,22.85 93.03,22.8 93.07,22.76 93.11,22.73 93.15,22.7 93.2,22.67 93.25,22.66 93.3,22.65 93.36,22.65 93.41,22.66 93.46,22.67 93.51,22.7 93.55,22.73 93.59,22.76 93.62,22.8 93.65,22.85 93.67,22.9 93.68,22.95 93.69,23.01 93.68,23.06 93.67,23.11 93.65,23.16 93.62,23.21 93.59,23.25 93.55,23.28 93.51,23.31 93.46,23.34 93.41,23.35 93.36,23.36 93.3,23.36 93.25,23.35 93.2,23.34 93.15,23.31 93.11,23.28 93.07,23.25 93.03,23.21 93.01,23.16 92.99,23.11 92.98,23.06 92.97,23.01 89.8,23.01 89.8,25.69 90.12,26 93.1,26
GND on BOTTOM (solid shape): 216.2,40.27 216.2,39.95 215.91,39.65 215.84,39.6 215.78,39.52 215.76,39.41 215.78,39.31 215.84,39.23 215.92,39.16 216.04,39.15 216.1,39.12 216.12,39.07 216.13,38.98 216.13,38.94 215.97,38.78 215.44,38.78 215.42,38.79 215.25,38.96 215.25,39.14 215.12,39.26 214.38,39.26 214.31,39.33 214.31,39.58 215.23,40.5 215.97,40.5
GND on BOTTOM (solid shape): 262.45,164.88 262.45,162.78 262.26,162.59 261.67,162.59 261.37,162.88 260.35,162.88 260.25,162.78 257.49,162.78 257.44,162.83 257.44,164.52 260.26,164.52 260.26,164.47 260.27,164.42 260.28,164.37 260.3,164.32 260.33,164.27 260.37,164.24 260.41,164.2 260.46,164.18 260.51,164.16 260.56,164.14 260.61,164.14 260.67,164.14 260.72,164.16 260.77,164.18 260.81,164.2 260.86,164.24 260.89,164.27 260.92,164.32 260.94,164.37 260.96,164.42 260.97,164.47 260.97,164.52 260.96,164.58 260.94,164.63 260.92,164.68 260.89,164.72 260.86,164.76 260.81,164.79 260.77,164.82 260.72,164.84 260.67,164.85 260.61,164.85 260.56,164.85 260.51,164.84 260.46,164.82 260.41,164.79 260.37,164.76 260.33,164.72 260.3,164.68 260.28,164.63 260.27,164.58 260.26,164.52 257.44,164.52 257.44,165.07 257.5,165.13 260.04,165.13 260.3,165.39 261.95,165.39
GND on BOTTOM (solid shape): 243.4,71.98 243.4,69.37 243.09,69.06 242.93,69.06 242.71,69.14 242.48,69.06 242.29,69.06 242.07,69.14 241.85,69.06 241.66,69.06 241.44,69.14 241.21,69.06 241.02,69.06 240.8,69.14 240.58,69.06 240.39,69.06 240.17,69.14 239.94,69.06 239.78,69.06 239.63,69.22 239.63,71.76 239.98,72.1 243.28,72.1
GND on BOTTOM (solid shape): 233.43,71.98 233.43,69.37 233.2,69.14 233.18,69.14 233.06,69.11 232.96,69.06 232.77,69.06 232.55,69.14 232.32,69.06 232.13,69.06 231.91,69.14 231.69,69.06 231.5,69.06 231.28,69.14 231.05,69.06 230.86,69.06 230.65,69.14 230.43,69.07 230.42,69.06 230.28,69.06 230.27,69.07 230.1,69.13 229.93,69.11 229.9,69.1 229.73,69.27 229.72,69.29 229.7,69.39 229.66,69.47 229.66,71.76 230.01,72.1 233.31,72.1
GND on BOTTOM (solid shape): 9.57,47.5 1.31,47.5 1.6,47.9 2.07,48.05 2.27,48.05 3.12,48.4 3.47,49.25 3.47,51.75 3.12,52.6 2.27,52.95 2.07,52.95 1.51,53.19 1.27,53.75 1.27,54.3 9.57,54.3
GND on BOTTOM (solid shape): 36.4,12.86 36.65,12.86 37.02,12.48 37.02,11.51 36.99,11.48 36.79,11.48 36.37,11.49 36.41,11.07 36.46,10.99 36.43,10.91 36.35,10.84 36.35,9.03 36.08,8.75 36.08,8.49 36.01,8.18 36.27,8.01 36.29,8.01 36.64,7.66 36.68,7.66 37.16,7.18 37.16,6.33 37.15,6.32 36.46,6.32 36.2,6.57 34.3,6.57 34.17,6.7 33.28,6.7 32.97,6.38 31.44,6.38 31.38,6.45 31.38,6.7 31.25,6.83 30.49,6.83 30.11,7.21 29.35,7.21 29.28,7.27 29.28,7.91 29.35,7.97 30.11,7.97 30.17,8.03 30.17,9.3 29.92,9.56 29.54,9.56 29.41,9.68 29.41,10.71 29.62,10.93 30.2,10.93 32.14,12.87 36.39,12.87
GND on BOTTOM (solid shape): 266.72,71.49 268.53,71.49 268.87,71.69 268.83,72.19 268.92,72.25 270.64,72.25 270.74,72.19 270.71,72.08 270.13,71.5 270.09,71.5 270.09,70.68 270.85,70.68 270.85,71.13 271.7,71.99 271.7,72.25 272.54,72.25 272.63,72.19 272.62,72.09 272.56,71.97 272.54,71.85 272.54,70.68 273.3,70.68 273.3,71.85 273.28,71.97 273.22,72.09 273.21,72.19 273.3,72.25 276.38,72.25 276.59,72.04 276.59,69.86 276.22,69.49 265.34,69.49 265.22,69.61 265.22,72.17 265.3,72.25 265.96,72.25
GND on BOTTOM (solid shape): 195.95,39.65 196.17,39.65 196.3,39.52 196.3,39.27 196.55,39.01 196.55,38.82 196.43,38.7 196.17,38.7 196.05,38.57 196.05,38.11 195.88,37.94 195.73,37.71 195.9,37.49 195.92,37.47 195.93,37.45 195.95,37.28 196.03,37.13 196.05,37.07 196.01,37.01 195.95,36.96 195.91,36.89 195.89,36.87 195.87,36.86 195.66,36.85 195.48,36.73 195.47,36.72 195.42,36.72 195.37,36.75 195.32,36.76 195,37.09 194.97,37.17 194.91,37.24 194.89,37.3 194.91,37.36 194.94,37.39 194.97,37.42 194.99,37.65 194.81,37.81 194.74,37.81 194.59,37.96 194.59,39.33 194.38,39.55 194.38,40.41 194.53,40.56 195.04,40.56
GND on BOTTOM (solid shape): outline of 144 points within 102.69,47.78 106.82,54.07
GND on BOTTOM (solid shape): 227.67,183.95 228.23,183.71 228.47,183.15 228.47,182.65 228.82,181.8 229.67,181.45 230.47,181.45 230.47,175.69 231.07,174.99 231.85,175.49 238.3,175.49 239.08,174.99 239.68,175.69 239.68,181.45 240.47,181.45 241.24,181.72 241.65,182.42 241.67,182.42 241.67,182.62 241.91,183.17 242.47,183.4 244.71,183.4 244.71,175.58 244.55,175.42 244.23,175.42 244.04,175.23 244.04,173.58 240.99,170.53 240.29,170.53 239.98,170.85 239.98,172.37 240.23,172.63 240.23,174.28 239.76,174.74 239.64,174.74 238.77,174.55 238.02,175.03 232.13,175.03 231.54,174.59 230.8,174.59 230.13,174.59 229.75,174.21 229.75,172.82 230.2,172.37 230.2,170.59 229.82,170.21 228.29,170.21 227.08,171.42 223.47,171.42 223.08,171.8 223.08,172.12 223.11,172.14 223.11,174.43 223,174.53 222.92,174.64 222.04,174.64 222.04,175.1 223.2,175.1 223.97,174.6 224.57,175.3 224.57,183.95
GND on BOTTOM (solid shape): outline of 116 points within 198.88,160.15 202.41,164.31
GND on BOTTOM (solid shape): outline of 115 points within 16.02,0.2 338.22,183.4
GND on BOTTOM (solid shape): outline of 282 points within 0.2,34.2 211.24,185.55
GND on BOTTOM (solid shape): outline of 9579 points within 195.07,18.11 215.52,39.11
GND on IN1 (solid shape): 16.58,31.97 16.58,30.58 14.75,28.74 1.27,28.74 1.27,30.1 1.51,30.66 2.07,30.9 11.68,30.9 12.45,30.4 13.05,31.1 13.05,31.85 13.37,32.16 16.39,32.16
GND on IN1 (solid shape): 227.67,183.95 228.23,183.71 228.47,183.15 228.47,182.65 228.82,181.8 229.67,181.45 230.47,181.45 230.47,175.69 231.07,174.99 231.85,175.49 238.3,175.49 239.08,174.99 239.68,175.69 239.68,181.45 240.47,181.45 241.24,181.72 241.65,182.42 241.67,182.42 241.67,182.62 241.91,183.17 242.47,183.4 244.71,183.4 244.71,175.58 244.55,175.42 244.23,175.42 244.04,175.23 244.04,173.58 240.99,170.53 240.29,170.53 239.98,170.85 239.98,172.37 240.23,172.63 240.23,174.28 239.76,174.74 239.64,174.74 238.77,174.55 238.02,175.03 232.13,175.03 231.54,174.59 230.8,174.59 230.13,174.59 229.75,174.21 229.75,172.82 230.2,172.37 230.2,170.59 229.82,170.21 228.29,170.21 227.08,171.42 223.47,171.42 223.08,171.8 223.08,172.12 223.11,172.14 223.11,174.43 223,174.53 222.92,174.64 222.04,174.64 222.04,175.1 223.2,175.1 223.97,174.6 224.57,175.3 224.57,183.95
GND on IN1 (solid shape): outline of 115 points within 16.02,0.2 338.22,183.4
GND on IN1 (solid shape): outline of 243 points within 0.2,34.2 211.24,185.55
GND on IN2 (solid shape): 16.58,31.97 16.58,30.58 14.75,28.74 1.27,28.74 1.27,30.1 1.51,30.66 2.07,30.9 11.68,30.9 12.45,30.4 13.05,31.1 13.05,32.11 13.1,32.16 16.39,32.16
GND on IN2 (solid shape): 227.67,183.95 228.23,183.71 228.47,183.15 228.47,182.65 228.82,181.8 229.67,181.45 230.47,181.45 230.47,175.69 231.07,174.99 231.85,175.49 238.3,175.49 239.08,174.99 239.68,175.69 239.68,181.45 240.47,181.45 241.24,181.72 241.65,182.42 241.67,182.42 241.67,182.62 241.91,183.17 242.47,183.4 244.71,183.4 244.71,175.58 244.55,175.42 244.23,175.42 244.04,175.23 244.04,173.58 240.99,170.53 240.29,170.53 239.98,170.85 239.98,172.37 240.23,172.63 240.23,174.28 239.76,174.74 239.64,174.74 238.77,174.55 238.02,175.03 232.13,175.03 231.54,174.59 230.8,174.59 230.13,174.59 229.75,174.21 229.75,172.82 230.2,172.37 230.2,170.59 229.82,170.21 228.29,170.21 227.08,171.42 223.47,171.42 223.08,171.8 223.08,172.12 223.11,172.14 223.11,174.43 223,174.53 222.92,174.64 222.04,174.64 222.04,175.1 223.2,175.1 223.97,174.6 224.57,175.3 224.57,183.95
GND on IN2 (solid shape): outline of 115 points within 16.02,0.2 338.22,183.4
GND on IN2 (solid shape): outline of 237 points within 0.2,34.2 211.24,185.55
GND on IN3 (solid shape): 16.58,31.97 16.58,30.58 14.75,28.74 1.27,28.74 1.27,30.1 1.51,30.66 2.07,30.9 11.68,30.9 12.45,30.4 13.05,31.1 13.05,31.85 13.37,32.16 16.39,32.16
GND on IN3 (solid shape): 227.67,183.95 228.23,183.71 228.47,183.15 228.47,182.65 228.82,181.8 229.67,181.45 230.47,181.45 230.47,175.69 231.07,174.99 231.85,175.49 238.3,175.49 239.08,174.99 239.68,175.69 239.68,181.45 240.47,181.45 241.24,181.72 241.65,182.42 241.67,182.42 241.67,182.62 241.91,183.17 242.47,183.4 244.71,183.4 244.71,175.58 244.55,175.42 244.23,175.42 244.04,175.23 244.04,173.58 240.99,170.53 240.29,170.53 239.98,170.85 239.98,172.37 240.23,172.63 240.23,174.28 239.76,174.74 239.64,174.74 238.77,174.55 238.02,175.03 232.13,175.03 231.54,174.59 230.8,174.59 230.13,174.59 229.75,174.21 229.75,172.82 230.2,172.37 230.2,170.59 229.82,170.21 228.29,170.21 227.08,171.42 223.47,171.42 223.08,171.8 223.08,172.12 223.11,172.14 223.11,174.43 223,174.53 222.92,174.64 222.04,174.64 222.04,175.1 223.2,175.1 223.97,174.6 224.57,175.3 224.57,183.95
GND on IN3 (solid shape): outline of 115 points within 16.02,0.2 338.22,183.4
GND on IN3 (solid shape): outline of 251 points within 0.2,34.2 211.24,185.55
GND on IN4 (solid shape): 16.58,31.97 16.58,30.58 14.75,28.74 1.27,28.74 1.27,30.1 1.51,30.66 2.07,30.9 11.68,30.9 12.45,30.4 13.05,31.1 13.05,31.85 13.37,32.16 16.39,32.16
GND on IN4 (solid shape): 227.67,183.95 228.23,183.71 228.47,183.15 228.47,182.65 228.82,181.8 229.67,181.45 230.47,181.45 230.47,175.69 231.07,174.99 231.85,175.49 238.3,175.49 239.08,174.99 239.68,175.69 239.68,181.45 240.47,181.45 241.24,181.72 241.65,182.42 241.67,182.42 241.67,182.62 241.91,183.17 242.47,183.4 244.71,183.4 244.71,175.58 244.55,175.42 244.23,175.42 244.04,175.23 244.04,173.58 240.99,170.53 240.29,170.53 239.98,170.85 239.98,172.37 240.23,172.63 240.23,174.28 239.76,174.74 239.64,174.74 238.77,174.55 238.02,175.03 232.13,175.03 231.54,174.59 230.8,174.59 230.13,174.59 229.75,174.21 229.75,172.82 230.2,172.37 230.2,170.59 229.82,170.21 228.29,170.21 227.08,171.42 223.47,171.42 223.08,171.8 223.08,172.12 223.11,172.14 223.11,174.43 223,174.53 222.92,174.64 222.04,174.64 222.04,175.1 223.2,175.1 223.97,174.6 224.57,175.3 224.57,183.95
GND on IN4 (solid shape): outline of 115 points within 16.02,0.2 338.22,183.4
GND on IN4 (solid shape): outline of 242 points within 0.2,34.2 211.24,185.55
GND on GND1: outline of 292 points within 0.2,0.2 338.22,185.55 ; 1 cut-out
GND on GND2: outline of 292 points within 0.2,0.2 338.22,185.55 ; 3 cut-outs
GND on VCC: outline of 90 points within 141.32,169.96 244.81,185.55
GND on VCC: 33.45,21.11 33.35,21.22 33.35,25.66 33.2,25.81 33.15,25.81 33.15,27.55 33.21,27.61 33.21,27.82 33.06,27.97 29.83,27.97 29.66,28.14 29.66,32.88 29.77,32.99 30.72,32.99 30.87,33.14 30.87,33.35 30.74,33.47 30.74,34.85 30.81,34.92 30.81,35.13 30.11,35.82 30.11,38.09 31.29,39.28 37.43,39.28 40.46,36.25 40.46,27.06 37.47,24.08 37.47,22.43 36.16,21.11
GND on VCC: 283.83,141.26 271.77,153.32 254.42,153.32 254.42,156.91 257.77,160.26 257.77,160.26 258.2,160.69 258.2,162.66 258.07,162.78 257.5,162.78 257.37,162.91 257.37,166.66 257.72,167 261.21,167 261.5,167.29 261.5,173.63 261.51,173.63 262.21,174.23 261.72,175.01 261.72,183.4 265.42,183.4 265.98,183.16 266.22,182.6 266.22,175.1 266.57,174.25 267.42,173.9 280.88,173.9 282.92,173.9 283.48,173.66 283.72,173.1 283.72,170.7 283.74,170.46 283.81,170.24 285.62,165.9 285.61,165.89 276.07,165.89 274.14,163.97 274.14,161.98 274.86,161.26 281.59,161.26 284.23,158.61 284.23,141.26
GND on VCC: 1.27,28.73 1.27,30.1 1.51,30.66 2.07,30.9 11.68,30.9 12.45,30.4 13.05,31.1 13.05,44.7 12.45,45.4 11.68,44.9 2.07,44.9 1.51,45.14 1.27,45.7 1.27,47.25 1.51,47.81 2.07,48.05 2.27,48.05 3.12,48.4 3.47,49.25 3.47,51.75 3.15,52.57 2.36,52.95 2.27,52.95 2.06,52.95 1.5,53.19 1.27,53.75 1.27,54.55 0.54,54.64 0.2,55.3 0.2,65.3 0.54,65.96 1.27,66.05 1.27,68.51 1.27,72.1 1.51,72.66 2.07,72.9 11.74,72.9 12.43,72.76 13.01,72.37 16.84,68.54 17.23,67.96 17.37,67.27 17.37,59.5 18.01,57.94 19.57,57.3 19.57,32.29 19.53,32.29 17.66,30.43 17.66,29.28 17.11,28.73
GND on VCC: 112.26,37.24 111.38,38.12 111.38,77.07 119.33,85.02 119.33,85.93 119.31,85.94 119.31,96.59 124.24,96.59 128.5,100.84 153.48,100.84 167.83,100.78 167.83,98.83 170.11,96.55 170.11,93.69 179.07,84.74 179.01,37.49 179.01,37.24
GND on GND3: outline of 287 points within 0.2,0.2 338.22,185.55
GND on GND4: outline of 288 points within 0.2,0.2 338.22,185.55
GND on GND5: outline of 289 points within 0.2,0.2 338.22,185.55
GNDA on GND1, GND2, GND3, GND4, GND5: 2.07,0.2 1.51,0.44 1.27,1 1.27,4.25 1.51,4.81 2.07,5.05 14.37,5.05 15.07,5.65 14.57,6.42 14.57,11.63 15.07,12.4 14.37,13 2.07,13 1.51,13.24 1.27,13.8 1.27,16.95 1.51,17.51 2.07,17.75 14.37,17.75 15.07,18.35 14.57,19.12 14.57,24.33 15.07,25.1 14.37,25.7 2.07,25.7 1.51,25.94 1.27,26.5 1.27,28.23 17.32,28.23 18.17,29.07 18.17,30.22 19.74,31.78 21.83,31.78 27.42,37.37 29.43,37.37 29.6,37.2 29.6,35.61 30.45,34.77 30.49,34.77 30.49,33.5 29.56,33.5 29.16,33.09 29.16,27.93 29.62,27.46 32.9,27.46 32.9,25.72 32.84,25.66 32.84,21.6 31.38,20.14 31.38,17.98 31.08,17.69 29.37,17.69 28.86,17.18 27.84,17.18 27.02,16.35 23.99,16.35 23.82,16.52 23.82,18.87 23.36,19.34 21.81,19.34 21.22,18.74 21.22,15.95 21.11,15.84 20.67,15.84 17.98,13.15 17.98,3.76 17.18,2.95 16.1,2.95 15.5,2.36 15.5,0.2
GNDA on VCC: 2.24,1.17 2.24,4.08 14.37,4.08 15.92,5.12 15.54,6.94 15.54,11.11 15.92,12.93 14.37,13.97 2.24,13.97 2.24,16.78 14.37,16.78 15.92,17.82 15.54,19.64 15.54,23.81 15.92,25.63 14.37,26.67 2.24,26.67 2.24,28.23 17.32,28.23 18.17,29.07 18.17,30.22 19.74,31.78 21.83,31.78 27.42,37.37 29.43,37.37 29.6,37.2 29.6,35.61 30.45,34.77 30.49,34.77 30.49,33.5 29.56,33.5 29.16,33.09 29.16,27.93 29.62,27.46 32.9,27.46 32.9,25.72 32.84,25.66 32.84,21.6 31.38,20.14 31.38,17.98 31.08,17.69 29.37,17.69 28.86,17.18 27.84,17.18 27.02,16.35 23.99,16.35 23.82,16.52 23.82,18.87 23.36,19.34 21.81,19.34 21.22,18.74 21.22,15.95 21.11,15.84 20.67,15.84 17.98,13.15 17.98,3.76 17.18,2.95 16.1,2.95 15.5,2.36 15.5,1.17
VIN on TOP (solid shape): 76.15,40.35 76.15,39.4 77.1,38.45 77.1,33.37 76.4,32.67 74.01,32.67 73.42,32.08 69.96,32.08 69.67,32.37 69.67,33.75 69.86,33.94 70.49,33.94 70.81,34.26 70.81,39.21 69.86,40.16 69.86,40.8 70.11,41.05 75.45,41.05
VIN on BOTTOM (solid shape): 79.38,38.32 79.38,32.93 79.07,32.61 76.66,32.61 76.41,32.36 73.69,32.36 73.4,32.07 71.11,32.07 70.94,32.25 70.94,38.96 71.32,39.34 78.37,39.34
+EC_VCCA on TOP (solid shape): 288.18,26.35 288.18,25.23 288.05,25.1 286.61,25.1 286.14,25.57 286.14,26.38 286.27,26.51 288.02,26.51
+EC_VCCA on TOP (solid shape): 294.06,9.5 294.06,7.34 294,7.28 293.85,7.28 293.8,7.33 293.8,9.18 293.75,9.24 293.63,9.24 293.51,9.37 293.51,9.62 293.57,9.68 293.87,9.68
+FBD_VREFCL on IN4 (solid shape): 284.84,98.43 284.84,97.35 285.7,96.49 285.7,96.11 285.57,95.98 284.17,95.98 283.89,96.27 283.89,97.6 283.47,98.01 283.03,98.01 282.58,98.46 276.74,98.46 276.04,97.76 276.04,97.31 275.85,97.12 275.66,97.12 275.47,97.31 275.47,99.03 276.04,99.6 283.66,99.6
+HDMI_5V_OUT on BOTTOM (solid shape): 222.55,172.46 222.55,166.47 222.27,166.19 221.27,166.19 220.69,166.76 220.69,170.25 220.29,170.65 220.29,173.07 220.61,173.39 221.62,173.39
+INV_PWR_SRC on TOP (solid shape): 172.92,182.79 172.92,181.52 172.67,181.26 171.84,181.26 171.46,180.88 171.46,179.74 171.29,179.57 169.61,179.57 169.48,179.7 169.48,181.34 169.86,181.73 169.86,182.6 169.87,182.6 169.87,182.89 169.97,182.99 172.71,182.99
+INV_PWR_SRC on TOP (solid shape): outline of 373 points within 155.79,171.25 160.05,179.46
+INV_PWR_SRC on BOTTOM (solid shape): 159.76,171.71 159.76,171.05 159.92,170.89 160.11,170.89 160.21,170.87 160.32,170.89 160.48,170.89 160.6,170.77 160.6,169.5 160.48,169.38 156.82,169.38 156.68,169.52 156.68,170.78 156.74,170.83 156.96,171.15 156.76,171.48 156.76,171.89 157.13,172.25 159.21,172.25
+INV_PWR_SRC on IN1 (solid shape): outline of 2190 points within 151.71,171.35 172.66,183.03
+LAN_IO on TOP (solid shape): 260.18,163.16 261.16,163.16 261.29,163.04 261.29,162.12 261.08,161.91 259.89,161.91 259.09,162.72 259.09,163.36 259.22,163.49 259.85,163.49
+LAN_IO on TOP (solid shape): 259.15,161.07 259.15,159.99 258.2,159.04 257.95,159.04 257.44,159.54 257.44,159.8 258.45,160.81 258.45,161.07 258.58,161.2 259.03,161.2
+LAN_IO on TOP (solid shape): 245.39,165.08 244.93,164.62 244.33,164.62 244.13,164.68 243.94,164.62 243.79,164.62 243.65,164.49 242.52,164.49 242.45,164.55 242.45,165.21 242.51,165.26 243.28,165.26 243.47,165.45 243.47,165.89 243.61,166.04 244.43,166.04
+LAN_IO on BOTTOM (solid shape): 261.25,162.47 261.25,161.89 260.04,160.69 260.04,160.31 259.72,159.99 258.52,159.99 258.45,160.05 258.45,160.88 260.17,162.59 261.12,162.59
+LAN_IO on BOTTOM (solid shape): 233.24,158.02 233.24,157.79 233.24,157.75 233.24,157.17 233.24,157.16 233.21,157 233.24,156.85 233.24,156.84 233.24,156.75 233.56,156.43 234.32,156.43 234.39,156.36 234.39,155.54 234.26,155.42 234.2,155.42 233.82,155.8 233.05,155.8 232.04,156.81 232.04,157.89 232.29,158.15 233.12,158.15
+LAN_IO on BOTTOM (solid shape): 231.97,151.16 231.97,150.4 231.66,150.08 231.43,150.08 231.42,150.08 231.09,150.02 230.96,149.71 230.96,149.46 231.12,149.3 230.96,149.13 228.86,149.13 228.67,149.32 228.67,149.58 228.37,149.88 227.83,149.88 227.64,150.07 227.64,150.22 227.64,150.23 227.64,151.02 227.85,151.23 230.89,151.23 231.02,151.35 231.78,151.35
+LAN_IO on IN1 (solid shape): 244.07,166.88 244.07,164.91 243.82,164.67 241.45,164.67 241.26,164.87 241.26,166.91 241.55,167.21 243.74,167.21
+LAN_IO on IN1 (solid shape): 233.72,160.57 233.72,160.27 233.71,160.18 233.72,160.09 233.72,159.96 233.91,159.77 234.48,159.77 234.85,159.41 234.85,158.8 234.8,158.76 232.71,158.76 232.42,159.06 232.42,160.66 232.65,160.89 233.4,160.89
+LAN_IO on IN2 (solid shape): 239.66,153.38 239.66,153 238.77,152.11 238.77,151.04 238.26,150.53 235.97,150.53 235.4,149.96 232.74,149.96 232.7,149.99 232.7,150.08 231.89,150.89 231,150.89 230.82,151.08 230.82,151.35 230.85,151.43 231.2,151.55 231.31,151.81 231.33,151.85 231.37,151.86 231.91,151.86 232.37,151.4 232.38,151.38 232.47,151.2 232.66,151.1 232.67,151.1 232.86,150.91 234.13,150.91 234.58,151.35 237.75,151.35 238.07,151.67 238.07,153.07 238.58,153.58 239.47,153.58
+LAN_IO on IN4 (solid shape): outline of 408 points within 229.88,149.38 234.9,159.86
+LCDVDD on TOP (solid shape): 165.05,181.52 165.05,181.13 164.85,180.94 164.85,179.93 164.66,179.74 163.52,179.74 163.46,179.8 163.46,180.94 163.33,181.07 163.33,181.45 163.52,181.64 164.92,181.64
+LCDVDD on BOTTOM (solid shape): 164.19,170.78 164.27,170.79 165.65,170.79 165.84,170.6 165.84,168.14 165.58,167.88 164.33,167.88 164.11,167.66 164.11,167.03 164.13,167.01 164.13,166.32 163.89,166.08 163.23,166.08 162.97,166.33 162.97,167.03 162.54,167.46 162.54,168.63 162.74,168.82 162.74,170.39 163.13,170.79 164.12,170.79
+LCDVDD on IN4 (solid shape): outline of 781 points within 163.01,168.62 171.76,181.71
+TBTA_VBUS on TOP (solid shape): outline of 174 points within 190.32,175.36 194.34,180.06
+TBTA_VBUS on TOP (solid shape): outline of 242 points within 202.51,158.19 206.38,164.92
+TBTA_VBUS on BOTTOM (solid shape): 194.28,178.93 194.28,177.32 193.89,176.94 193.89,176.39 193.77,176.26 193.58,176.26 193.45,176.39 193.45,177.11 193.96,177.62 193.96,178.94 194.02,179.01 194.2,179.01
+TBTA_VBUS on BOTTOM (solid shape): 191.41,178.82 191.41,178.71 191.74,178.38 191.74,177.91 191.74,177.9 191.74,177.4 191.89,177.25 191.89,176.35 191.77,176.22 191.55,176.22 191.42,176.35 191.42,178.4 191.08,178.73 191.08,178.91 191.11,178.94 191.29,178.94
+TBTA_VBUS on BOTTOM (solid shape): 202.79,160.67 202.79,159.78 202.81,159.77 202.81,159.71 203.04,159.47 203.04,159.35 203.3,159.1 203.3,158.8 203.22,158.72 203.05,158.72 202.88,158.88 202.83,158.88 202.54,159.17 202.54,159.27 202.54,159.28 202.56,159.4 202.54,159.53 202.54,159.54 202.54,159.68 202.57,159.71 202.57,160.65 202.62,160.7 202.77,160.7
+TBTA_VBUS on BOTTOM (solid shape): 209.11,165.96 209.11,164.5 208.89,164.27 206.1,164.27 205.96,164.41 205.32,164.41 205.22,164.31 205.15,164.28 205.07,164.31 204.72,164.35 204.61,164.01 204.63,163.97 204.47,163.81 204.44,163.8 203.58,163.8 203.26,163.48 203.01,163.48 202.97,163.52 202.97,163.75 202.84,163.88 202.61,163.88 202.49,164.01 202.49,164.22 202.54,164.28 202.84,164.28 202.98,164.42 202.98,164.62 203.11,164.74 203.23,164.74 203.4,164.91 204.1,164.91 204.19,165 204.22,164.99 204.6,165.07 204.68,165.45 204.67,165.48 205.04,165.85 205.05,165.85 205.34,166.15 208.92,166.15
+TBTA_VBUS on IN3 (solid shape): outline of 1641 points within 190.83,163.67 206.96,179.16
+TBTA_VBUS on GND2: 190.99,178.85 194.81,178.85 198.17,175.49 202.03,175.49 206.96,170.57 206.96,164.23 206.32,163.6 203.68,163.6 203.32,163.95 203.32,167.91 199.32,171.92 196.84,171.92 193.53,175.23 191.75,175.23 190.83,176.15 190.83,178.68
+VGA_CORE on TOP (solid shape): outline of 4131 points within 208.16,63.21 263.6,105.32
+VGA_CORE on BOTTOM (solid shape): outline of 658 points within 210.83,62.26 264.11,75.66
+VGA_CORE on IN2 (solid shape): 227.03,64.77 227.11,64.73 227.12,64.64 227.47,64.19 227.81,64.64 227.82,64.73 227.91,64.77 228.85,64.77 228.94,64.73 228.95,64.64 229.29,64.19 229.64,64.64 229.65,64.73 229.73,64.77 230.65,64.77 230.73,64.73 230.74,64.64 231.09,64.19 231.43,64.64 231.44,64.73 231.53,64.77 235.96,64.77 236.05,64.72 236.05,64.62 236.34,64.06 236.64,64.62 236.64,64.72 236.73,64.77 237.79,64.77 237.88,64.72 237.87,64.62 238.17,64.06 238.47,64.62 238.47,64.72 238.55,64.77 239.58,64.77 239.67,64.73 239.68,64.63 240,64.13 240.33,64.63 240.33,64.73 240.42,64.77 244.52,64.77 244.61,64.73 244.62,64.63 244.94,64.13 245.27,64.63 245.27,64.73 245.36,64.77 246.37,64.77 246.45,64.73 246.46,64.63 246.78,64.13 247.11,64.63 247.11,64.73 247.2,64.77 248.19,64.77 248.28,64.73 248.29,64.63 248.54,64.14 248.97,64.48 249,64.56 249.07,64.59 263.6,64.59 263.6,63.72 263.34,63.47 242.53,63.47 242.23,63.63 241.93,63.47 233.96,63.47 233.66,63.63 233.36,63.47 226.07,63.47 225.32,64.22 225.32,64.29 225.31,64.35 225.31,64.77
+VGA_CORE on IN2 (solid shape): outline of 17882 points within 210.77,67.3 263.6,107.1
+VGA_CORE on IN3 (solid shape): outline of 11755 points within 207.84,63.38 263.43,106.01
+VGA_CORE on IN4 (solid shape): outline of 2831 points within 230.07,91.85 243.57,105.35
+VGA_CORE on GND1: 212.59,67.34 211.78,68.15 211.78,84.57 212.27,85.06 222.81,85.06 223.91,86.16 223.91,94.24 222.81,95.35 220.21,95.35 219.97,95.58 219.97,102.73 221.24,104 221.24,105.34 221.41,105.51 229.5,105.51 229.5,101.08 230.22,100.36 234.85,100.36 235.59,99.62 235.59,79.49 236.63,78.45 241.05,78.45 241.05,75.24 248.07,68.23 263.69,68.23 264.17,67.75 264.17,63.57 263.62,63.03 223.25,63.03 222.71,63.57 222.71,66.69 222.05,67.34
+VGA_CORE on IN1: 229.81,105.51 243.33,105.51 243.7,105.14 243.7,91.76 243.24,91.3 240.36,91.3 239.89,90.83 239.89,87.71 238.76,86.58 238.76,79.31 236.61,77.15 236.61,74.55 236.85,74.3 240.82,74.3 245.64,69.48 245.64,67.88 245.58,67.82 225.25,67.82 224.39,66.96 211.35,66.96 209.97,68.34 209.97,75.45 216.63,82.11 216.63,86.3 217.17,86.84 227.86,86.84 228.81,87.79 228.81,100.18 229.35,100.72 229.35,105.05
+VGA_CORE on GND2: 202.55,65.75 200.03,68.27 200.03,86.86 202.26,89.08 202.26,100.89 208.01,106.65 209.2,106.65 211.27,104.57 211.27,91.24 214.26,88.26 214.26,85.84 216.86,83.24 216.86,81.33 220.31,77.88 225.73,77.88 227.28,79.43 227.28,80.76 228.04,81.52 228.04,83.39 224.4,87.03 220.27,87.03 218.39,88.91 218.39,90.43 216.35,92.47 216.35,98.86 216.92,99.43 216.92,103.18 217.28,103.54 220.78,103.54 221.31,104.07 221.31,106.42 221.92,107.03 251.24,107.03 251.72,106.54 251.72,86.12 249.08,83.47 242.35,83.47 241.44,82.56 241.44,74.85 248.05,68.23 263.69,68.23 264.17,67.75 264.17,63.57 263.62,63.03 227.7,63.03 224.97,65.75
+VGA_CORE on VCC: 265.25,61.98 264.08,63.15 207.19,63.15 202.26,68.08 202.26,80.02 199.91,82.37 199.91,94.22 212.71,107.03 212.73,107.03 212.73,107.07 213.42,107.75 213.42,109.98 213.8,110.36 213.8,118.51 204.86,127.45 204.86,127.86 284.23,127.86 284.23,88.32 284.57,87.98 286.03,87.98 289.12,84.89 289.12,74.73 295.22,68.63 295.22,64.23 294.82,64.23 293.99,65.06 279.8,65.06 278.84,64.09 278.84,61.98
+VGA_PCIE on TOP (solid shape): outline of 3306 points within 198.76,79.98 228.35,100.43
