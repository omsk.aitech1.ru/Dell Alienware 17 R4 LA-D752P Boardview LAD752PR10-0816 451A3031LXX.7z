# Allegro board LAD752PR10-0816.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
FBD_D4: length 20.3
  IN4 w0.089: 252.17,91.8 251.77,91.4 v1(251.47,91.4)
  IN4 w0.119: 252.17,91.8 255.1,91.8 255.68,92.38 256.3,92.38 256.68,92 258.28,92 260.2,93.93 267.59,93.93 268.52,94.86 v1(268.52,95.01)
  BOTTOM w0.089: UG19.U11 v1(268.52,95.01) ; UG1.AJ6 251.47,91.55 v1(251.47,91.4)
FBD_D5: length 20.3
  IN4 w0.089: v1(252.37,91.4) 253.18,91.4
  IN4 w0.119: v1(269.32,95.01) 269.32,94.13 268.65,93.45 260.4,93.45 258.34,91.4 253.18,91.4
  BOTTOM w0.089: UG1.AJ5 252.37,91.55 v1(252.37,91.4) ; UG19.T11 v1(269.32,95.01)
FBD_D6: length 26.7
  IN4 w0.089: 249.55,90.92 v1(249.07,91.4)
  IN4 w0.119: 249.55,90.92 258.54,90.92 260.59,92.98 270.48,92.98 v1(272.52,95.01)
  BOTTOM w0.089: v1(249.07,91.4) 249.07,91.55 UG1.AJ9 ; UG19.N11 v1(272.52,95.01)
FBD_D7: length 26.9
  IN4 w0.089: v1(250.67,90.2) 251.07,90.6
  IN4 w0.119: 251.07,90.6 254.81,90.6 254.83,90.58 259.21,90.58 261.13,92.5 272.37,92.5 272.94,93.07 272.94,94.64 v1(273.32,95.01)
  BOTTOM w0.089: v1(250.67,90.2) 250.67,90.35 UG1.AK7 ; UG19.M11 v1(273.32,95.01)
FBD_D8: length 20.9
  IN4 w0.089: 251.49,88.18 v1(250.67,89)
  IN4 w0.119: 251.49,88.18 256.97,88.18 257.09,88.3 258.33,88.3 258.69,87.94 260.48,87.94 263,90.46 268.28,90.46 v1(268.52,90.21)
  BOTTOM w0.089: UG19.U4 268.92,89.81 v1(268.52,90.21) ; UG1.AM7 250.67,89.15 v1(250.67,89)
FBD_D9: length 20.7
  IN4 w0.089: v1(251.47,89) 251.9,88.57
  IN4 w0.119: v1(269.32,90.21) 268.6,90.93 262.8,90.93 260.44,88.57 251.9,88.57
  BOTTOM w0.089: UG1.AM6 251.47,89.15 v1(251.47,89) ; UG19.T4 269.72,89.81 v1(269.32,90.21)
FBD_D10: length 20.3
  IN4 w0.089: 252.27,87 v1(251.47,87.8)
  IN4 w0.119: 252.27,87 257.09,87 257.1,86.99 260.87,86.99 263.39,89.51 267.89,89.51 268.52,88.88 v1(268.52,88.61)
  BOTTOM w0.089: v1(268.52,88.61) 268.92,88.21 UG19.U2 ; v1(251.47,87.8) 251.47,87.95 UG1.AN6
FBD_D11: length 20.5
  IN4 w0.089: v1(252.4,87.77) 252.82,87.35
  IN4 w0.119: v1(269.32,88.61) 268.92,89.01 268.92,89.58 268.69,89.81 268.39,89.81 268.22,89.98 263.2,89.98 260.67,87.46 258.43,87.46 258.4,87.49 256.36,87.49 256.22,87.35 252.82,87.35
  BOTTOM w0.089: UG19.T2 269.72,88.21 v1(269.32,88.61) ; v1(252.4,87.77) 252.37,87.8 252.37,87.95 UG1.AN5
FBD_D12: length 26.1
  IN4 w0.089: 251.47,85.8 v1(250.67,86.6)
  IN4 w0.119: v1(271.72,88.61) 271.72,88.41 271.32,88.01 271.32,87.33 271.01,87.02 264.66,87.02 261.66,84.03 257.62,84.03 256.64,85 256.27,85 253.07,85 252.77,85.3 252.77,85.6 252.57,85.8 251.47,85.8
  BOTTOM w0.089: UG19.N2 v1(271.72,88.61) ; v1(250.67,86.6) 250.67,86.75 UG1.AR7
FBD_D13: length 25.7
  IN4 w0.089: v1(251.47,85.4) 252.13,84.74
  IN4 w0.119: 252.13,84.74 256.23,84.74 257.37,83.6 261.91,83.6 264.85,86.54 271.3,86.54 272.12,87.36 272.12,88.21 v1(272.52,88.61)
  BOTTOM w0.089: v1(251.47,85.4) 251.47,85.55 UG1.AT6 ; UG19.M2 v1(272.52,88.61)
FBD_D14: length 30.8
  IN4 w0.089: v1(249.92,85.5) 251.57,84.46
  IN4 w0.119: 251.57,84.46 252.46,83.57 256.61,83.57 257.43,82.75 262.26,82.75 265.15,85.64 271.69,85.64 273.7,87.66 273.7,89.84 v1(273.32,90.21)
  BOTTOM w0.089: v1(273.32,90.21) 272.92,89.81 UG19.M4 ; UG1.AT8 v1(249.92,85.5)
FBD_D15: length 26.9
  IN4 w0.089: v1(272.52,90.21) 272.88,89.85 272.88,87.58 271.74,86.43 ; 252.75,83.82 v1(252.37,84.2)
  IN4 w0.119: 271.74,86.43 271.43,86.12 265.03,86.12 262.09,83.18 257.43,83.18 256.79,83.82 252.75,83.82
  BOTTOM w0.089: UG19.N4 272.12,89.81 v1(272.52,90.21) ; v1(252.37,84.2) 252.37,84.35 UG1.AV5
FBD_D16: length 35.1
  IN1 w0.119: v1(262.12,95.28) 262.12,95.94 265.22,99.03 272.55,99.03 273.09,98.49 274.04,98.49 274.89,99.34 281.32,99.34 282.75,97.91 282.75,95.64 v1(282.12,95.01)
  BOTTOM w0.089: UG1.AG1 255.76,93.44 ; UG19.A11 v1(282.12,95.01)
  BOTTOM w0.135: v1(262.12,95.28) 262.12,94.99 260.57,93.44 v2(258.64,93.44) 255.76,93.44
FBD_D17: length 35.3
  IN1 w0.119: v1(282.12,96.61) 282.21,96.62 282.5,96.93 282.5,97.57 282.28,97.79 282.27,97.79 281.16,98.9 275.12,98.9 274.29,98.08 272.9,98.08 272.4,98.58 265.44,98.58 263.29,96.43 v1(263.29,95.41)
  BOTTOM w0.089: v1(282.12,96.61) 281.72,97.01 UG19.A13 ; UG1.AG3 254.17,92.75
  BOTTOM w0.135: v1(263.29,95.41) 263.29,95.03 v2(262.17,93.91) 260.98,92.72 258.6,92.72 258.31,93.01 256.49,93.01 256.22,92.75 254.17,92.75
FBD_D18: length 36.8
  IN1 w0.119: v1(281.32,95.01) 281.71,95.4 281.71,97.58 280.77,98.52 275.41,98.52 274.68,97.79 265.32,97.79 263.83,96.3 v1(263.83,95.74)
  BOTTOM w0.089: UG1.AG4 253.57,92.45 ; UG19.B11 v1(281.32,95.01)
  BOTTOM w0.135: v1(263.83,95.74) 263.83,94.84 260.74,91.75 257.8,91.75 257.1,92.45 253.57,92.45
FBD_D19: length 32.4
  IN1 w0.119: v1(281.32,96.61) 281.32,96.81 280.92,97.21 280.92,97.64 280.42,98.14 275.81,98.14 274.68,97.01 265.22,97.01 264.37,96.17 v1(264.35,96.17)
  BOTTOM w0.089: UG19.B13 280.92,97.01 v1(281.32,96.61) ; UG1.AJ2 255.07,91.55
  BOTTOM w0.135: 255.07,91.55 256.72,91.55 257.07,91.2 260.93,91.2 264.35,94.62 v1(264.35,96.17)
FBD_D20: length 28.4
  IN1 w0.089: 255.38,89.53 254.88,90.03 v1(254.88,90.2)
  IN1 w0.119: 255.38,89.53 257.51,89.53 257.95,89.96 257.95,90.65 258.47,91.17 259.52,91.17 261.5,93.16 265.74,93.16 267.22,94.65 268.35,94.65 268.36,94.64 275.08,94.64 275.09,94.65 275.22,94.65 275.61,95.04 276.81,95.04 278.12,96.35 v1(278.12,96.61)
  BOTTOM w0.089: v1(278.12,96.61) 277.72,97.01 UG19.F13 ; v1(254.88,90.2) 254.88,90.54 UG1.AK2
FBD_D21: length 32.3
  IN1 w0.089: v1(253.27,89) 254.07,88.2
  IN1 w0.119: 254.07,88.2 256.71,88.2 257.25,88.74 257.79,88.74 257.79,88.74 257.95,88.74 258.64,89.44 259.8,89.44 262.25,91.89 266.27,91.89 267.25,92.87 277.65,92.87 278.52,93.74 278.52,96.21 v1(278.92,96.61)
  BOTTOM w0.089: v1(278.92,96.61) 278.52,97.01 UG19.E13 ; v1(253.27,89) 253.27,89.15 UG1.AM4
FBD_D22: length 28.4
  IN1 w0.089: 254.57,88.6 v1(254.17,89)
  IN1 w0.119: 254.57,88.6 256.69,88.6 257.08,88.99 257.69,88.99 258.92,90.22 259.91,90.22 262,92.31 266.09,92.31 267.15,93.38 274.8,93.38 275.24,93.82 277.46,93.82 277.72,94.08 277.72,94.61 v1(278.12,95.01)
  BOTTOM w0.089: UG19.E11 v1(278.12,95.01) ; v1(254.17,89) 254.17,89.15 UG1.AM3
FBD_D23: length 25.5
  IN1 w0.089: v1(255.97,89) 256.62,89
  IN1 w0.119: 256.62,89 256.89,89.27 257.61,89.27 258.26,89.92 258.26,90.39 258.57,90.7 259.71,90.7 261.75,92.74 265.91,92.74 267.01,93.84 274.81,93.84 275.76,94.79 276.92,94.79 277.14,95.01 v1(277.32,95.01)
  BOTTOM w0.089: UG19.F11 v1(277.32,95.01) ; v1(255.97,89) 255.97,89.15 255.78,89.34 UG1.AM1
FBD_D24: length 26.6
  IN1 w0.089: v1(255.97,86.6) 256.12,86.6 256.96,87.44
  IN1 w0.119: v1(278.12,90.21) 277.74,90.59 277.74,91.28 277.43,91.6 268.87,91.6 267.59,90.32 262.9,90.32 260.22,87.65 258.54,87.65 258.33,87.44 256.96,87.44
  BOTTOM w0.089: v1(255.97,86.6) 255.97,86.75 UG1.AR1 ; UG19.E4 v1(278.12,90.21)
FBD_D25: length 25.7
  IN1 w0.089: 255.45,86.22 v1(255.07,86.6)
  IN1 w0.119: v1(277.32,90.21) 276.94,90.59 268.36,90.59 267.66,89.88 263.06,89.88 260.34,87.16 257.07,87.16 256.13,86.22 255.45,86.22
  BOTTOM w0.089: UG19.F4 v1(277.32,90.21) ; v1(255.07,86.6) 255.07,86.75 UG1.AR2
FBD_D26: length 26.8
  IN1 w0.089: 256.04,85.82 255.68,85.46 v1(255.68,85.39)
  IN1 w0.119: 256.04,85.82 256.39,85.82 257.26,86.69 260.66,86.69 263.34,89.38 267.92,89.38 268.33,89.79 276.9,89.79 277.19,89.5 278.03,89.5 v1(278.92,88.61)
  BOTTOM w0.089: UG1.AT1 255.62,85.9 255.62,85.45 v1(255.68,85.39) ; v1(278.92,88.61) 278.52,88.21 UG19.E2
FBD_D27: length 27.6
  IN1 w0.089: v1(254.17,85.4) 254.56,85.01
  IN1 w0.119: v1(278.12,88.61) 277.7,89.04 268.21,89.04 268.04,88.87 265.6,88.87 262.95,86.21 257.15,86.21 256.75,85.82 256.75,85.28 256.48,85.01 254.56,85.01
  BOTTOM w0.089: v1(254.17,85.4) 254.17,85.55 UG1.AT3 ; UG19.F2 277.72,88.21 v1(278.12,88.61)
FBD_D28: length 31.3
  IN1 w0.089: 254.87,83.5 v1(254.17,84.2)
  IN1 w0.119: v1(281.32,88.61) 280.92,88.21 280.92,87.59 280.43,87.09 268.24,87.09 267.66,86.51 266.77,86.51 263.98,83.72 256.61,83.72 256.39,83.5 254.87,83.5
  BOTTOM w0.089: v1(254.17,84.2) 254.17,84.35 UG1.AV3 ; v1(281.32,88.61) 280.92,88.21 UG19.B2
FBD_D29: length 31.7
  IN1 w0.089: 256.39,83.25 256.19,83.05 v1(255.97,83.05)
  IN1 w0.119: v1(281.32,90.21) 281.71,89.82 281.71,87.65 280.81,86.75 268.5,86.75 267.71,85.97 266.89,85.97 264.17,83.25 256.39,83.25
  BOTTOM w0.089: v1(281.32,90.21) 280.92,89.81 UG19.B4 ; v1(255.97,83.05) 255.97,83.15 UG1.AW1
FBD_D30: length 32.5
  IN1 w0.089: v1(254.87,81.8) 255.52,82.45
  IN1 w0.119: v1(282.12,88.61) 282.12,88.35 282.14,88.33 282.5,87.97 282.5,87.49 281.33,86.33 268.67,86.33 267.89,85.54 267.14,85.54 264.37,82.77 256.43,82.77 256.11,82.45 255.52,82.45
  BOTTOM w0.089: UG19.A2 282.12,88.61 v1(282.12,88.61) ; v1(254.87,81.8) 254.87,82.15 UG1.AY2
FBD_D31: length 33.6
  IN1 w0.089: v1(256.17,81.8) 256.67,82.3
  IN1 w0.119: 256.67,82.3 264.57,82.3 267.39,85.12 268.06,85.12 268.85,85.9 281.76,85.9 282.82,86.97 282.82,88.06 282.5,88.38 282.5,89.84 v1(282.12,90.21)
  BOTTOM w0.089: UG19.A4 281.72,89.81 v1(282.12,90.21) ; v1(256.17,81.8) 256.07,81.9 UG1.BA1
FBD_D32: length 26
  IN4 w0.089: v1(254.17,83.05) 254.68,82.54
  IN4 w0.119: v1(273.32,81.01) 273.32,82.01 273.71,82.4 273.71,83.58 272.37,84.91 265.38,84.91 262.2,81.73 256.78,81.73 255.96,82.54 254.68,82.54
  BOTTOM w0.089: UG1.AW3 254.17,83.15 v1(254.17,83.05) ; UG20.F4 v1(273.32,81.01)
FBD_D33: length 25.4
  IN4 w0.089: v1(253.27,83.05) 254.14,82.18
  IN4 w0.119: 254.14,82.18 255.05,82.18 255.97,81.25 262.39,81.25 265.58,84.44 267.85,84.44 267.96,84.55 271.94,84.55 272.91,83.58 272.91,82.4 272.52,82.01 v1(272.52,81.81)
  BOTTOM w0.089: v1(272.52,81.81) 272.12,81.41 UG20.E4 ; UG1.AW4 253.27,83.15 v1(253.27,83.05)
FBD_D34: length 24.1
  IN4 w0.089: v1(252.37,81.25) 253.79,79.83
  IN4 w0.119: 253.79,79.83 255.28,79.83 255.48,79.62 262.1,79.62 265.97,83.49 267.77,83.49 267.89,83.61 267.89,83.67 268.26,84.04 268.38,84.04 268.38,84.04 270.85,84.04 271.33,83.56 271.33,83 v1(271.72,82.61)
  BOTTOM w0.089: UG20.E2 v1(271.72,82.61) ; UG1.BA5 252.27,81.25 v1(252.37,81.25)
FBD_D35: length 24.7
  IN4 w0.089: 253.38,80.78 252.37,81.78 v1(252.37,82.15)
  IN4 w0.119: 253.38,80.78 262.59,80.78 265.78,83.96 267.83,83.96 268.16,84.29 268.23,84.29 268.23,84.3 270.95,84.3 270.95,84.29 271.39,84.29 272.12,83.57 272.12,83.01 v1(272.52,82.61)
  BOTTOM w0.089: v1(252.37,82.15) 252.27,82.15 UG1.AY5 ; UG20.F2 v1(272.52,82.61)
FBD_D36: length 30
  IN4 w0.089: 249.62,84.55 249.42,84.75 v1(248.82,84.75)
  IN4 w0.119: 249.62,84.55 249.62,83.75 249.87,83.5 250.22,83.5 250.42,83.3 250.42,82.75 250.77,82.4 250.77,79.15 251.06,78.86 251.06,78.48 251.31,78.23 251.31,78.22 251.55,77.98 251.88,77.98 252.93,76.93 262.89,76.93 266.48,80.52 267.13,80.52 267.95,81.33 267.95,81.78 268.52,82.35 v1(268.52,82.61)
  BOTTOM w0.089: UG20.A2 v1(268.52,82.61) ; v1(248.82,84.75) 248.67,84.75 UG1.AU9
FBD_D37: length 28.4
  IN4 w0.089: 249.62,82.25 v1(248.82,83.05)
  IN4 w0.119: v1(268.52,81.01) 268.52,80.39 267.79,79.67 266.87,79.67 263.28,76.08 252.26,76.08 251.21,77.13 251.2,77.13 250.46,77.87 250.46,77.88 250.16,78.18 250.16,80.58 249.62,81.12 249.62,82.25
  BOTTOM w0.089: v1(248.82,83.05) 248.67,83.05 UG1.AW9 ; UG20.A4 v1(268.52,81.01)
FBD_D38: length 29.2
  IN4 w0.089: v1(248.82,82.15) 249.2,81.77
  IN4 w0.119: 249.2,81.77 249.2,78.31 251.86,75.65 263.46,75.65 267.05,79.24 268.26,79.24 269.32,80.31 v1(269.32,81.01)
  BOTTOM w0.089: UG20.B4 v1(269.32,81.01) ; v1(248.82,82.15) 248.67,82.15 UG1.AY9
FBD_D39: length 32.9
  IN4 w0.089: 248.17,84.55 248.17,85 v1(247.62,85.55)
  IN4 w0.119: v1(269.32,82.61) 268.92,82.21 268.92,81.66 268.68,81.41 268.39,81.41 268.2,81.23 268.14,81.17 268.14,80.78 267.46,80.09 266.69,80.09 263.1,76.5 252.66,76.5 251.61,77.55 251.37,77.55 250.88,78.04 250.88,78.05 250.58,78.35 250.58,78.84 250.45,78.97 250.45,82.27 250.07,82.66 249.81,82.66 249.27,83.2 249.27,84.05 248.97,84.35 248.37,84.35 248.17,84.55
  BOTTOM w0.089: UG20.B2 v1(269.32,82.61) ; UG1.AT11 247.47,85.55 v1(247.62,85.55)
FBD_D40: length 38.8
  IN4 w0.089: 247.17,84 v1(246.42,84.75)
  IN4 w0.119: 247.17,84 247.17,79.13 247.94,78.36 247.94,77.35 251.21,74.09 264.11,74.09 267.52,77.5 267.92,77.5 268.26,77.84 272.4,77.84 272.93,77.31 272.93,76.6 v1(273.32,76.21)
  BOTTOM w0.089: UG1.AU12 246.27,84.75 v1(246.42,84.75) ; v1(273.32,76.21) 272.92,75.81 UG20.F11
FBD_D41: length 36.7
  IN4 w0.089: 246.82,83.55 v1(246.42,83.95)
  IN4 w0.119: v1(271.72,76.21) 271.72,76.87 271.2,77.39 268.38,77.39 267.98,76.99 267.61,76.99 264.28,73.66 251.03,73.66 247.51,77.18 247.51,78.41 246.82,79.1 246.82,83.55
  BOTTOM w0.089: UG20.E11 v1(271.72,76.21) ; UG1.AV12 246.27,83.95 v1(246.42,83.95)
FBD_D42: length 35.2
  IN4 w0.089: v1(245.19,84.75) 245.22,84.75 245.98,83.99
  IN4 w0.119: 245.98,83.99 245.98,79.24 246.89,78.33 246.89,77.2 250.86,73.24 264.46,73.24 267.81,76.59 268.94,76.59 v1(269.32,76.21)
  BOTTOM w0.089: v1(269.32,76.21) 269.72,75.81 UG20.B11 ; UG1.AU14 245.07,84.75 v1(245.19,84.75)
FBD_D43: length 35.3
  IN4 w0.089: 245.62,82.65 v1(245.22,83.05)
  IN4 w0.119: v1(268.52,76.21) 268.03,76.21 264.26,72.44 254.93,72.44 254.81,72.56 254.81,72.69 254.69,72.81 254.45,72.81 254.33,72.69 254.33,72.56 254.21,72.44 253.97,72.44 253.85,72.56 253.85,72.69 253.73,72.81 253.5,72.81 253.38,72.69 253.38,72.56 253.26,72.44 253.02,72.44 252.9,72.56 252.9,72.69 252.78,72.81 252.54,72.81 252.42,72.69 252.42,72.56 252.3,72.44 252.06,72.44 251.94,72.56 251.94,72.69 251.82,72.81 251.59,72.81 251.47,72.69 251.47,72.56 251.35,72.44 251.06,72.44 246.16,77.33 246.16,78.55 245.62,79.1 245.62,82.65
  BOTTOM w0.089: v1(268.52,76.21) 268.92,75.81 UG20.A11 ; UG1.AW14 245.07,83.05 v1(245.22,83.05)
FBD_D44: length 43.5
  IN4 w0.089: v1(244.02,85.55) 243.2,84.73
  IN4 w0.119: v1(269.32,74.61) 269.7,74.24 269.7,73.66 268.51,72.47 268.36,72.47 265.19,69.3 264.18,69.3 263.84,69.64 249.44,69.64 243.2,75.89 243.2,84.73
  BOTTOM w0.089: v1(244.02,85.55) 243.87,85.55 UG1.AT15 ; v1(269.32,74.61) 269.72,74.21 UG20.B13
FBD_D45: length 40.2
  IN4 w0.089: 243.51,83.44 v1(244.02,83.95)
  IN4 w0.119: 243.51,83.44 243.51,78.98 243.67,78.82 243.67,76.01 249.62,70.07 264.05,70.07 264.39,69.72 265.01,69.72 268.94,73.65 268.94,74.19 v1(268.52,74.61)
  BOTTOM w0.089: v1(244.02,83.95) 243.87,83.95 UG1.AV15 ; v1(268.52,74.61) 268.92,74.21 UG20.A13
FBD_D46: length 47
  IN4 w0.089: v1(242.82,84.75) 242.19,84.12
  IN4 w0.119: 242.19,84.12 242.19,75.69 249.09,68.8 263.35,68.8 263.7,68.45 266.3,68.45 269.37,71.52 269.37,71.69 270.5,72.82 271.26,72.82 272.1,73.66 272.1,74.19 v1(272.52,74.61)
  BOTTOM w0.089: UG20.F13 v1(272.52,74.61) ; v1(242.82,84.75) 242.67,84.75 UG1.AU17
FBD_D47: length 44.5
  IN4 w0.089: 242.44,83.57 v1(242.82,83.95)
  IN4 w0.119: v1(271.72,74.61) 271.33,74.22 271.33,73.69 270.96,73.32 270.33,73.32 268.94,71.93 268.94,71.7 266.12,68.87 263.91,68.87 263.56,69.22 249.26,69.22 242.77,75.71 242.77,78.58 242.44,78.91 242.44,83.57
  BOTTOM w0.089: UG1.AV17 242.67,83.95 v1(242.82,83.95) ; UG20.E13 v1(271.72,74.61)
FBD_D48: length 35.4
  IN1 w0.089: v1(252.94,79.58) 254.01,79.58
  IN1 w0.119: v1(282.12,82.61) 282.52,83.01 282.52,83.73 281.5,84.74 269.24,84.74 268.61,84.11 268.01,84.11 265.05,81.14 256.53,81.14 256.34,80.95 255.04,80.95 254.56,80.47 254.56,80.13 254.01,79.58
  BOTTOM w0.089: v1(282.12,82.61) 281.72,83.01 UG20.U2 ; v1(252.94,79.58) 253.02,79.65 UG1.BB4
FBD_D49: length 36.3
  IN1 w0.089: v1(254.05,80.38) 254.05,80.66
  IN1 w0.119: v1(282.12,81.01) 283.09,81.98 283.09,83.75 281.62,85.23 269.13,85.23 268.34,84.44 267.67,84.44 264.85,81.62 256.52,81.62 256.33,81.42 254.82,81.42 254.05,80.66
  BOTTOM w0.089: UG20.U4 v1(282.12,81.01) ; UG1.BC3 253.61,79.9 254.05,80.34 v1(254.05,80.38)
FBD_D50: length 36
  IN1 w0.089: v1(252.34,79.58) 252.34,79.48 252.62,79.2
  IN1 w0.119: v1(281.32,81.01) 281.71,81.4 281.71,83.58 280.97,84.32 280.6,84.32 280.56,84.36 276.51,84.36 276.47,84.32 269.36,84.32 268.9,83.85 268.43,83.85 265.24,80.67 256.87,80.67 256.03,79.83 254.77,79.83 254.14,79.2 252.62,79.2
  BOTTOM w0.089: UG1.BC5 252.14,79.58 v1(252.34,79.58) ; UG20.T4 v1(281.32,81.01)
FBD_D51: length 36.2
  IN1 w0.089: 251.91,80.56 v1(251.22,81.25)
  IN1 w0.119: 251.91,80.56 251.91,79.4 252.28,79.03 252.43,79.03 252.52,78.95 255.15,78.95 255.63,79.43 256.29,79.43 256.98,80.12 265.36,80.12 268.03,82.78 268.12,82.78 268.36,83.03 275.54,83.03 276.61,84.11 280.45,84.11 280.92,83.64 280.92,83.21 281.32,82.81 v1(281.32,82.61)
  BOTTOM w0.089: v1(251.22,81.25) 251.07,81.25 UG1.BA6 ; UG20.T2 280.92,83.01 v1(281.32,82.61)
FBD_D52: length 35.9
  IN1 w0.089: v1(250.02,81.25) 250.45,80.82
  IN1 w0.119: 250.45,80.82 250.45,78.07 251.42,77.1 265.87,77.1 268.94,80.17 268.94,80.49 269.06,80.61 276.74,80.61 276.93,80.8 276.93,81.86 277.31,82.24 277.74,82.24 v1(278.12,82.61)
  BOTTOM w0.089: v1(278.12,82.61) 277.72,83.01 UG20.M2 ; UG1.BA8 249.87,81.25 v1(250.02,81.25)
FBD_D53: length 32.8
  IN1 w0.089: 249.64,78.66 249.64,79.05 v1(249.57,79.11)
  IN1 w0.119: 249.64,78.66 249.64,78.19 251.15,76.68 266.12,76.68 269.04,79.6 276.55,79.6 276.94,79.99 276.94,80.43 277.32,80.81 v1(277.32,81.01)
  BOTTOM w0.089: UG1.BC8 249.57,79.75 v1(249.57,79.11) ; UG20.M4 v1(277.32,81.01)
FBD_D54: length 35.9
  IN1 w0.089: v1(248.82,80.35) 249.2,79.97
  IN1 w0.119: 249.2,79.97 249.2,77.96 250.9,76.26 266.37,76.26 269.33,79.22 277,79.22 277.7,79.92 277.7,80.59 v1(278.12,81.01)
  BOTTOM w0.089: v1(248.82,80.35) 248.67,80.35 UG1.BB9 ; UG20.N4 v1(278.12,81.01)
FBD_D55: length 38.4
  IN1 w0.089: v1(248.82,79.45) 248.82,77.66
  IN1 w0.119: 248.82,77.66 250.65,75.83 266.62,75.83 269.69,78.9 277.63,78.9 278.52,79.79 278.52,82.46 278.68,82.61 v1(278.92,82.61)
  BOTTOM w0.089: UG1.BC9 248.67,79.45 v1(248.82,79.45) ; v1(278.92,82.61) 278.52,83.01 UG20.N2
FBD_D56: length 42.2
  IN1 w0.089: 247.24,81.33 v1(246.42,82.15)
  IN1 w0.119: v1(278.12,76.21) 277.72,76.61 276.42,76.61 275.34,77.69 272.61,77.69 272.14,77.22 272.14,75.18 271.97,75.01 268.38,75.01 267.64,74.26 249.81,74.26 247.71,76.37 247.71,76.37 247.24,76.83 247.24,81.33
  BOTTOM w0.089: UG1.AY12 246.27,82.15 v1(246.42,82.15) ; UG20.N11 v1(278.12,76.21)
FBD_D57: length 41.3
  IN1 w0.089: v1(246.42,81.25) 246.8,80.87
  IN1 w0.119: v1(277.32,76.21) 276.38,76.21 275.2,77.39 273.16,77.39 272.9,77.12 272.9,74.39 272.73,74.22 268.4,74.22 268.01,73.84 249.63,73.84 246.8,76.67 246.8,80.87
  BOTTOM w0.089: v1(246.42,81.25) 246.27,81.25 UG1.BA12 ; UG20.M11 v1(277.32,76.21)
FBD_D58: length 44.3
  IN1 w0.089: 246.29,78.71 246.29,79.32 v1(246.42,79.45)
  IN1 w0.119: 246.29,78.71 246.29,76.58 249.46,73.42 249.87,73.42 249.99,73.3 249.99,73.12 250.11,73 250.35,73 250.47,73.12 250.47,73.3 250.59,73.42 250.83,73.42 250.95,73.3 250.95,73.12 251.07,73 251.31,73 251.43,73.12 251.43,73.3 251.55,73.42 251.78,73.42 251.9,73.3 251.9,73.12 252.02,73 252.26,73 252.38,73.12 252.38,73.3 252.5,73.42 252.74,73.42 252.86,73.3 252.86,73.12 252.98,73 253.22,73 253.34,73.12 253.34,73.3 253.46,73.42 253.7,73.42 253.82,73.3 253.82,73.09 253.94,72.97 254.18,72.97 254.3,73.09 254.3,73.3 254.42,73.42 254.66,73.42 254.78,73.3 254.78,73.09 254.9,72.97 255.13,72.97 255.25,73.09 255.25,73.3 255.37,73.42 255.61,73.42 255.73,73.3 255.73,73.09 255.85,72.97 256.09,72.97 256.21,73.09 256.21,73.3 256.33,73.42 256.57,73.42 256.69,73.3 256.69,73.09 256.81,72.97 257.04,72.97 257.16,73.09 257.16,73.3 257.28,73.42 276.68,73.42 276.94,73.68 276.94,74.77 277.17,74.99 278.54,74.99 v1(278.92,74.61)
  BOTTOM w0.089: v1(278.92,74.61) 278.52,74.21 UG20.N13 ; v1(246.42,79.45) 246.27,79.45 UG1.BC12
FBD_D59: length 45.7
  IN1 w0.089: v1(245.22,80.35) 245.82,79.75
  IN1 w0.119: 245.82,79.75 245.82,76.45 249.72,72.55 257.6,72.55 257.72,72.67 257.72,72.87 257.84,72.99 258.08,72.99 258.2,72.87 258.2,72.67 258.32,72.55 258.56,72.55 258.68,72.67 258.68,72.87 258.8,72.99 259.03,72.99 259.15,72.87 259.15,72.67 259.27,72.55 259.51,72.55 259.63,72.67 259.63,72.87 259.75,72.99 259.99,72.99 260.11,72.87 260.11,72.67 260.23,72.55 260.47,72.55 260.59,72.67 260.59,72.87 260.71,72.99 260.94,72.99 261.06,72.87 261.06,72.67 261.18,72.55 261.42,72.55 261.54,72.67 261.54,72.87 261.66,72.99 261.9,72.99 262.02,72.87 262.02,72.67 262.14,72.55 262.38,72.55 262.5,72.67 262.5,72.87 262.62,72.99 262.85,72.99 262.97,72.87 262.97,72.67 263.09,72.55 263.33,72.55 263.45,72.67 263.45,72.87 263.57,72.99 263.81,72.99 263.93,72.87 263.93,72.67 264.05,72.55 264.29,72.55 264.41,72.67 264.41,72.87 264.53,72.99 264.76,72.99 264.88,72.87 264.88,72.67 265,72.55 267.17,72.55 267.61,72.99 277.52,72.99 277.74,73.21 277.74,74.23 v1(278.12,74.61)
  BOTTOM w0.089: UG20.M13 277.72,74.21 v1(278.12,74.61) ; v1(245.22,80.35) 245.07,80.35 UG1.BB14
FBD_D60: length 50.5
  IN1 w0.089: 244.41,79.96 v1(244.02,80.35)
  IN1 w0.119: v1(281.32,74.61) 281.06,74.61 280.64,74.2 280.3,74.2 280.14,74.05 280.14,72.7 280.19,72.66 280.19,71.61 279.05,70.47 273.31,70.47 272.54,69.69 265.12,69.69 264.74,70.08 248.88,70.08 243.48,75.48 243.48,78.02 244.17,78.71 244.17,79 244.41,79.24 244.41,79.96
  BOTTOM w0.089: v1(244.02,80.35) 243.87,80.35 UG1.BB15 ; v1(281.32,74.61) 280.92,74.21 UG20.T13
FBD_D61: length 55.7
  IN1 w0.089: v1(242.82,82.15) 243.62,81.35
  IN1 w0.119: 243.62,81.35 243.62,78.97 243.05,78.4 243.05,75.31 248.71,69.65 264.48,69.65 264.87,69.27 279.07,69.27 280.9,71.1 280.9,73.92 281.17,74.19 281.43,74.19 281.74,74.5 281.74,75.79 v1(281.32,76.21)
  BOTTOM w0.089: UG1.AY17 242.67,82.15 v1(242.82,82.15) ; UG20.T11 280.92,75.81 v1(281.32,76.21)
FBD_D62: length 54.1
  IN1 w0.089: v1(242.82,81.25) 243.22,80.85
  IN1 w0.119: 243.22,80.85 243.22,79.14 242.63,78.55 242.63,75.13 248.53,69.23 264.16,69.23 264.55,68.84 279.24,68.84 281.73,71.33 281.73,73.34 281.7,73.37 281.7,74.1 282.12,74.52 v1(282.12,74.61)
  BOTTOM w0.089: UG1.BA17 242.67,81.25 v1(242.82,81.25) ; UG20.U13 281.72,74.21 v1(282.12,74.61)
FBD_D63: length 55.2
  IN1 w0.089: v1(242.82,79.45) 242.21,78.84
  IN1 w0.119: 242.21,78.84 242.21,74.96 248.36,68.81 263.97,68.81 264.36,68.42 279.42,68.42 282.5,71.5 282.5,75.84 v1(282.12,76.21)
  BOTTOM w0.089: v1(282.12,76.21) 281.72,75.81 UG20.U11 ; UG1.BC17 242.67,79.45 v1(242.82,79.45)
FBD_DBI0#: length 24.9
  IN4 w0.089: v1(249.87,91.4) 250.32,91.85
  IN4 w0.119: 250.32,91.85 251.77,91.85 252.07,92.15 254.81,92.15 255.85,93.19 258.5,93.19 259.92,94.6 267.07,94.6 267.88,95.41 270.26,95.41 270.54,95.7 270.54,96.24 v1(270.92,96.61)
  BOTTOM w0.089: v1(249.87,91.4) 249.87,91.55 UG1.AJ8 ; UG19.P13 v1(270.92,96.61)
FBD_DBI1#: length 22.9
  IN4 w0.089: v1(252.37,86.6) 253.19,85.78
  IN4 w0.119: v1(270.92,88.61) 270.92,88.41 270.52,88.01 270.52,87.6 270.33,87.41 268.39,87.41 268.1,87.7 264.37,87.7 261.38,84.7 257.9,84.7 256.83,85.78 253.19,85.78
  BOTTOM w0.089: v1(252.37,86.6) 252.37,86.75 UG1.AR5 ; UG19.P2 v1(270.92,88.61)
FBD_DBI2#: length 29.9
  IN1 w0.089: 256.09,89.78 255.97,89.89 v1(255.97,90.2)
  IN1 w0.119: v1(279.72,96.61) 279.33,97 277.18,97 276.94,96.77 276.94,95.7 276.66,95.41 268.04,95.41 267.98,95.35 266.97,95.35 265.46,93.84 261.22,93.84 259.23,91.85 258.39,91.85 257.6,91.06 257.6,89.97 257.41,89.78 256.09,89.78
  BOTTOM w0.089: UG1.AK1 255.97,90.35 v1(255.97,90.2) ; UG19.D13 279.32,97.01 v1(279.72,96.61)
FBD_DBI3#: length 29.7
  IN1 w0.089: 253.93,84.74 v1(253.27,85.4)
  IN1 w0.119: v1(279.72,88.61) 279.34,88.23 267.96,88.23 267.92,88.19 265.88,88.19 263.23,85.54 257.41,85.54 256.61,84.74 253.93,84.74
  BOTTOM w0.089: UG19.D2 279.32,88.21 v1(279.72,88.61) ; UG1.AT4 253.27,85.55 v1(253.27,85.4)
FBD_DBI4#: length 27.1
  IN4 w0.089: 251.97,82.7 251.62,83.05 v1(251.22,83.05)
  IN4 w0.119: v1(270.92,82.61) 270.92,82.68 270.52,83.08 270.52,83.57 270.3,83.79 268.36,83.79 268.14,83.56 268.14,83.19 267.76,82.81 266.26,82.81 262.39,78.94 254.11,78.94 252.91,80.15 252.24,80.15 251.97,80.42 251.97,82.7
  BOTTOM w0.089: v1(251.22,83.05) 251.07,83.05 UG1.AW6 ; UG20.D2 v1(270.92,82.61)
FBD_DBI5#: length 37.2
  IN4 w0.089: v1(245.23,82.16) 244.83,81.76
  IN4 w0.119: v1(270.92,74.61) 270.92,74.68 270.51,75.09 270.51,75.58 270.3,75.79 268.36,75.79 267.98,75.41 267.98,75.09 264.65,71.76 250.78,71.76 245.49,77.05 245.49,78.63 244.83,79.29 244.83,81.76
  BOTTOM w0.089: UG1.AY14 245.07,82.15 245.22,82.15 v1(245.23,82.16) ; UG20.D13 v1(270.92,74.61)
FBD_DBI6#: length 37.8
  IN1 w0.089: 250.82,81.35 v1(250.02,82.15)
  IN1 w0.119: 250.82,81.35 250.82,79.26 251.15,78.93 251.15,78.38 251.74,77.78 265.59,77.78 268.14,80.33 268.14,81.27 268.31,81.44 275.98,81.44 276.11,81.57 276.11,82.07 276.23,82.2 276.61,82.2 276.65,82.24 276.68,82.24 276.9,82.46 276.9,82.78 277.12,83 279.33,83 v1(279.72,82.61)
  BOTTOM w0.089: v1(279.72,82.61) 279.32,83.01 UG20.P2 ; UG1.AY8 249.87,82.15 v1(250.02,82.15)
FBD_DBI7#: length 42.8
  IN1 w0.089: v1(245.22,79.45) 245.22,78.52
  IN1 w0.119: v1(279.72,74.61) 279.46,74.61 279.08,74.24 278.81,74.24 278.54,73.97 278.54,72.86 278.42,72.74 268.32,72.74 267.45,71.87 249.44,71.87 245.14,76.17 245.14,78.44 245.22,78.52
  BOTTOM w0.089: v1(279.72,74.61) 279.32,74.21 UG20.P13 ; UG1.BC14 245.07,79.45 v1(245.22,79.45)
FBD_EDC0: length 23.3
  IN4 w0.089: 251.07,92.2 v1(250.67,92.6)
  IN4 w0.119: v1(270.12,96.61) 269.74,96.24 268.36,96.24 268.01,96.59 263.88,96.59 262.99,95.7 258.7,95.7 258.58,95.58 258.58,95.22 256.99,93.63 255.72,93.63 254.69,92.6 252.07,92.6 251.67,92.2 251.07,92.2
  BOTTOM w0.089: UG1.AG7 250.67,92.75 v1(250.67,92.6) ; UG19.R13 v1(270.12,96.61)
FBD_EDC1: length 22.8
  IN4 w0.089: 253.65,86.22 v1(253.27,86.6)
  IN4 w0.119: 253.65,86.22 258.1,86.22 258.3,86.02 258.3,85.65 258.42,85.54 258.66,85.54 258.78,85.65 258.78,86.04 258.9,86.16 259.14,86.16 259.26,86.04 259.26,85.65 259.38,85.54 259.61,85.54 259.73,85.65 259.73,86.04 259.85,86.16 260.09,86.16 260.21,86.04 260.21,85.65 260.33,85.54 260.57,85.54 260.69,85.65 260.69,86.02 260.83,86.16 261.32,86.16 263.84,88.68 267.49,88.68 267.95,88.21 270,88.21 270.12,88.33 v1(270.12,88.61)
  BOTTOM w0.089: UG19.R2 v1(270.12,88.61) ; v1(253.27,86.6) 253.27,86.75 UG1.AR4
FBD_EDC2: length 33.4
  IN1 w0.089: v1(256.55,90.2) 256.55,91.84
  IN1 w0.119: v1(280.52,96.61) 280.52,96.69 280.13,97.08 280.13,97.56 279.88,97.8 276.31,97.8 276.12,97.61 276.12,97.21 275.92,97.01 275.47,97.01 274.67,96.21 268.01,96.21 267.98,96.18 265.77,96.18 264.26,94.67 260.64,94.67 258.95,92.98 257.69,92.98 256.55,91.84
  BOTTOM w0.089: v1(280.52,96.61) 280.12,97.01 UG19.C13 ; UG1.AJ3 254.47,91.25 255.72,91.25 256.55,90.42 v1(256.55,90.2)
FBD_EDC3: length 29.3
  IN1 w0.089: v1(255.07,84.2) 255.46,83.81
  IN1 w0.119: 255.46,83.81 256.21,83.81 257.03,84.63 263.6,84.63 266.32,87.34 279.79,87.34 280.1,87.66 280.1,88.19 v1(280.52,88.61)
  BOTTOM w0.089: UG1.AV2 255.07,84.35 v1(255.07,84.2) ; UG19.C2 280.12,88.21 v1(280.52,88.61)
FBD_EDC4: length 28.6
  IN4 w0.089: 250.82,83.6 250.47,83.95 v1(250.02,83.95)
  IN4 w0.119: 250.82,83.6 250.82,82.85 251.07,82.6 251.37,82.6 251.61,82.36 251.61,79.67 253.53,77.76 262.37,77.76 266.52,81.9 267.64,81.9 268.14,82.41 268.14,82.77 268.38,83 269.73,83 v1(270.12,82.61)
  BOTTOM w0.089: v1(250.02,83.95) 249.87,83.95 UG1.AV8 ; UG20.C2 v1(270.12,82.61)
FBD_EDC5: length 40.1
  IN4 w0.089: 244.42,82.65 v1(244.02,83.05)
  IN4 w0.119: v1(270.12,74.61) 269.72,75.01 268.47,75.01 268.45,74.99 268.36,74.99 268.14,74.77 268.14,74.08 264.96,70.9 249.99,70.9 249.12,71.77 249.12,71.94 249.18,72.01 249.18,72.18 249.01,72.34 248.85,72.34 248.78,72.28 248.61,72.28 248.44,72.45 248.44,72.62 248.51,72.68 248.51,72.85 248.34,73.02 248.17,73.02 248.1,72.95 247.94,72.95 247.77,73.12 247.77,73.29 247.83,73.36 247.83,73.53 247.66,73.7 247.49,73.7 247.43,73.63 247.26,73.63 247.09,73.8 247.09,73.97 247.16,74.03 247.16,74.2 246.99,74.37 246.82,74.37 246.75,74.31 246.58,74.31 246.41,74.48 246.41,74.77 246.2,74.98 245.91,74.98 244.66,76.23 244.66,78.79 244.42,79.03 244.42,82.65
  BOTTOM w0.089: UG20.C13 v1(270.12,74.61) ; v1(244.02,83.05) 243.87,83.05 UG1.AW15
FBD_EDC6: length 35.3
  IN1 w0.089: v1(251.22,80.35) 251.62,79.95
  IN1 w0.119: 251.62,79.95 251.62,79.54 251.66,79.5 251.66,79.3 252.18,78.78 252.33,78.78 252.41,78.7 252.61,78.7 252.67,78.65 256.79,78.65 257.29,79.14 265.67,79.14 267.83,81.3 267.83,82.03 268.02,82.22 275.43,82.22 276.23,83.03 276.74,83.03 276.93,83.22 276.93,83.66 277.06,83.79 279.88,83.79 280.13,83.54 280.13,83 v1(280.52,82.61)
  BOTTOM w0.089: v1(251.22,80.35) 251.07,80.35 UG1.BB6 ; v1(280.52,82.61) 280.12,83.01 UG20.R2
FBD_EDC7: length 48.9
  IN1 w0.089: v1(244.02,81.25) 244.77,80.5
  IN1 w0.119: 244.77,80.5 244.77,78.66 244.31,78.2 244.31,75.83 249.23,70.91 257.12,70.91 257.25,71.04 265.23,71.04 265.38,70.9 265.38,70.7 265.5,70.58 267.82,70.58 267.83,70.58 272.25,70.58 273.1,71.44 274.8,71.44 275,71.63 276.87,71.63 277.06,71.44 278.84,71.44 279.36,71.95 279.36,73.17 279.34,73.19 279.34,73.97 279.57,74.2 279.84,74.2 280.26,74.61 v1(280.52,74.61)
  BOTTOM w0.089: UG1.BA15 243.87,81.25 v1(244.02,81.25) ; v1(280.52,74.61) 280.12,74.21 UG20.R13
FBD_MA0_H: length 51.6
  IN3 w0.089: 245.84,76.71 243.41,79.13 243.41,88.16 v1(242.82,88.75)
  IN3 w0.112: 245.84,76.71 247.31,75.24 265.49,75.24 268.53,78.28 275.42,78.28 275.57,78.43 276.04,78.43 276.15,78.54 276.15,78.78 276.04,78.89 275.65,78.89 275.54,79 275.54,79.23 275.65,79.34 276.04,79.34 276.15,79.45 276.15,79.68 276.04,79.79 275.65,79.79 275.54,79.9 275.54,80.12 275.65,80.23 276.04,80.23 276.15,80.35 276.15,80.9 276.26,81.01 v1(276.52,81.01)
  BOTTOM w0.089: UG20.K4 v1(276.52,81.01) ; v1(242.82,88.75) 242.67,88.75 UG1.AM17
FBD_MA0_L: length 33.9
  IN3 w0.089: v1(249.87,87.8) 250.07,87.8 250.47,87.4
  IN3 w0.112: 250.47,87.4 256.37,87.4 256.72,87.05 260.8,87.05 260.92,86.94 260.92,86.48 261.03,86.36 261.25,86.36 261.36,86.48 261.36,86.94 261.47,87.05 261.7,87.05 261.81,86.94 261.81,86.48 261.92,86.36 264.14,86.36 269.41,91.63 270.61,91.63 270.73,91.52 270.73,91.01 270.84,90.9 271.06,90.9 271.17,91.01 271.17,91.52 271.29,91.63 275.1,91.63 v1(276.52,90.21)
  BOTTOM w0.089: UG1.AN8 249.87,87.95 v1(249.87,87.8) ; UG19.H4 276.12,89.81 v1(276.52,90.21)
FBD_MA1_H: length 51.7
  IN3 w0.089: v1(242.77,87.28) 242.77,87.22 243.19,86.79 243.19,78.77 245.25,76.71
  IN3 w0.112: v1(276.52,80.21) 276.52,80.17 276.86,79.83 277.2,79.83 277.31,79.72 277.31,79.41 277.2,79.29 276.54,79.29 276.43,79.18 276.43,78.95 276.54,78.84 277.14,78.84 277.31,78.66 277.31,78.31 277.19,78.19 275.67,78.19 275.52,78.03 268.88,78.03 267.02,76.17 267.02,75.08 266.76,74.82 247.14,74.82 245.25,76.71
  BOTTOM w0.089: UG20.K5 v1(276.52,80.21) ; UG1.AP17 242.39,87.6 242.71,87.28 v1(242.77,87.28)
FBD_MA1_L: length 35
  IN3 w0.089: 246.97,88.45 246.58,88.84 v1(246.58,89.06)
  IN3 w0.112: v1(276.52,91.01) 276.52,91.44 276.09,91.87 269.06,91.87 263.97,86.78 262.55,86.78 261.87,87.47 257.32,87.47 256.49,88.3 248.47,88.3 248.32,88.45 246.97,88.45
  BOTTOM w0.089: UG19.H5 276.12,90.61 v1(276.52,91.01) ; v1(246.58,89.06) 246.36,89.06 UG1.AM12
FBD_MA2_H: length 51.5
  IN3 w0.089: v1(241.62,89.55) 242.2,88.97 242.2,87.68 242.23,87.65 242.23,85.8 242.23,85.8 242.23,79.2 242.23,79.2 242.23,78.41 243.92,76.71
  IN3 w0.112: v1(274.92,76.21) 274.54,76.6 274.54,77.36 274.35,77.55 272.34,77.55 271.42,76.63 268.41,76.63 267.68,75.9 267.68,74.22 267.45,73.99 246.65,73.99 243.92,76.71
  BOTTOM w0.089: UG1.AL18 241.47,89.55 v1(241.62,89.55) ; v1(274.92,76.21) 275.72,76.21 UG20.K11
FBD_MA2_L: length 32.9
  IN3 w0.089: v1(249.07,89) 249.45,89.38 256.11,89.38 256.65,88.83 258.73,88.83
  IN3 w0.112: v1(274.92,95.01) 274.92,94.33 273.85,93.26 269.05,93.26 264.62,88.83 262.87,88.83 262.76,88.72 262.76,88.41 262.65,88.3 262.42,88.3 262.31,88.41 262.31,88.72 262.2,88.83 261.98,88.83 261.86,88.72 261.86,88.41 261.75,88.3 261.53,88.3 261.42,88.41 261.42,88.72 261.3,88.83 258.73,88.83
  BOTTOM w0.089: UG1.AM9 249.07,89.15 v1(249.07,89)
  BOTTOM w0.13: v1(274.92,95.01) 275.72,95.01 UG19.H11
FBD_MA3_H: length 52.1
  IN3 w0.089: 244.59,76.71 242.52,78.78 242.52,79.23 242.45,79.3 242.45,85.7 242.45,85.71 242.45,85.98 v1(242.82,86.35)
  IN3 w0.112: v1(275.83,77.81) 276.11,77.53 276.11,76.83 276,76.71 275.43,76.71 275.29,76.85 275.29,77.26 275.18,77.38 275.01,77.38 274.6,77.79 271.92,77.79 271.81,77.68 271.81,77.36 271.7,77.25 271.47,77.25 271.36,77.36 271.36,77.68 271.25,77.79 271.03,77.79 270.92,77.68 270.92,77.15 270.8,77.04 270.58,77.04 270.47,77.15 270.47,77.68 270.36,77.79 270.13,77.79 270.02,77.68 270.02,77.43 269.91,77.32 269.69,77.32 269.57,77.43 269.57,77.68 269.46,77.79 269.22,77.79 267.43,76 267.43,74.61 267.23,74.41 246.89,74.41 244.59,76.71
  BOTTOM w0.089: UG20.K10 276.12,77.52 v1(275.83,77.81) ; v1(242.82,86.35) 242.67,86.35 UG1.AR17
FBD_MA3_L: length 33.7
  IN3 w0.089: v1(248.27,89) 248.72,88.55
  IN3 w0.112: 248.72,88.55 256.61,88.55 256.8,88.36 258.68,88.36 258.73,88.41 258.97,88.41 259.08,88.3 259.08,87.99 259.19,87.88 259.41,87.88 259.52,87.99 259.52,88.3 259.64,88.41 259.86,88.41 259.97,88.3 259.97,87.99 260.08,87.88 260.31,87.88 260.42,87.99 260.42,88.3 260.53,88.41 260.75,88.41 260.87,88.3 260.87,87.99 260.98,87.88 262.82,87.88 263.35,88.41 264.87,88.41 269.25,92.79 274.03,92.79 275.45,94.21 v1(275.72,94.21)
  BOTTOM w0.089: UG1.AM10 248.27,89.15 v1(248.27,89) ; UG19.H10 v1(275.72,94.21)
FBD_MA4_H: length 49.3
  IN3 w0.089: v1(241.62,85.55) 241.38,85.55 241.04,85.21
  IN3 w0.112: v1(274.12,76.21) 274.41,76.21 274.55,76.07 274.55,75.12 274.42,74.99 269.85,74.99 269.69,74.84 269.69,74.33 269.82,74.2 270.39,74.2 270.55,74.04 270.55,73.4 270.3,73.16 246.16,73.16 241.53,77.79 241.53,79.02 241.04,79.5 241.04,85.21
  BOTTOM w0.089: UG20.H11 v1(274.12,76.21) ; UG1.AT18 241.47,85.55 v1(241.62,85.55)
FBD_MA4_L: length 32.1
  IN3 w0.089: 253.69,90.01 253.5,89.82 248.65,89.82 v1(248.27,90.2)
  IN3 w0.107: 253.69,90.01 253.69,90.44 253.9,90.65 257.57,90.65
  IN3 w0.112: v1(274.12,95.01) 273.69,94.59 272.37,94.59 272.26,94.48 272.11,94.48 271.94,94.65 271.79,94.65 271.63,94.49 271.63,94.33 271.79,94.17 271.79,94.01 271.62,93.84 271.17,93.84 271.06,93.95 271.06,94.09 270.94,94.2 270.72,94.2 270.61,94.09 270.61,93.95 270.5,93.84 268.31,93.84 264.68,90.2 264.43,90.2 264.32,90.09 264.32,89.77 264.21,89.66 262.61,89.66 262.5,89.77 262.5,90.09 262.39,90.2 258.01,90.2 257.57,90.65
  BOTTOM w0.089: v1(248.27,90.2) 248.27,90.35 UG1.AK10 ; UG19.K11 v1(274.12,95.01)
FBD_MA5_H: length 49.9
  IN3 w0.089: v1(241.62,87.95) 242.01,87.56 242.01,85.89 242,85.89 242,79.11 242.01,79.11 242.01,77.97 243.26,76.71
  IN3 w0.112: v1(274.12,77.01) 273.86,77.01 273.75,76.9 273.75,75.9 273.64,75.79 272.86,75.79 272.75,75.9 272.75,76.5 272.63,76.61 272.41,76.61 272.3,76.5 272.3,75.9 272.19,75.79 268.37,75.79 268.15,75.57 268.15,73.68 268.04,73.57 246.4,73.57 243.26,76.71
  BOTTOM w0.089: UG1.AN18 241.17,88.4 v1(241.62,87.95) ; UG20.H10 v1(274.12,77.01)
FBD_MA5_L: length 33.8
  IN3 w0.089: 256.18,89.63 253.62,89.63 253.59,89.6 248.07,89.6 v1(247.47,90.2)
  IN3 w0.112: v1(274.12,94.21) 273.48,93.57 268.7,93.57 264.38,89.24 262.21,89.24 262.1,89.36 262.1,89.67 261.99,89.79 261.76,89.79 261.65,89.67 261.65,89.36 261.54,89.24 261.3,89.24 261.19,89.36 261.19,89.67 261.08,89.79 260.85,89.79 260.74,89.67 260.74,89.36 260.63,89.24 260.41,89.24 260.29,89.36 260.29,89.67 260.18,89.79 259.96,89.79 259.85,89.67 259.85,89.36 259.73,89.24 259.51,89.24 259.4,89.36 259.4,89.67 259.29,89.79 259.06,89.79 258.95,89.67 258.95,89.36 258.84,89.24 256.57,89.24 256.18,89.63
  BOTTOM w0.089: UG19.K10 v1(274.12,94.21) ; v1(247.47,90.2) 247.47,90.35 UG1.AK11
FBD_MA6_H: length 56.3
  IN3 w0.089: 246.6,77.55 244.6,79.54 244.6,87.37 v1(244.02,87.95)
  IN3 w0.112: 246.6,77.55 246.77,77.55 247.83,76.49 257.81,76.49 257.92,76.6 257.92,77.26 258.03,77.37 258.26,77.37 258.37,77.26 258.37,76.6 258.48,76.49 258.7,76.49 258.81,76.6 258.81,77.26 258.93,77.37 259.15,77.37 259.26,77.26 259.26,76.6 259.37,76.49 259.6,76.49 259.71,76.6 259.71,77.26 259.82,77.37 260.04,77.37 260.16,77.26 260.16,76.6 260.27,76.49 260.49,76.49 260.6,76.6 260.6,77.26 260.71,77.37 260.94,77.37 261.05,77.26 261.05,76.6 261.16,76.49 261.38,76.49 261.5,76.6 261.5,77.26 261.61,77.37 261.83,77.37 261.94,77.26 261.94,76.6 262.06,76.49 262.28,76.49 262.39,76.6 262.39,77.26 262.5,77.37 262.73,77.37 262.84,77.26 262.84,76.6 262.95,76.49 263.17,76.49 263.28,76.6 263.28,77.26 263.4,77.37 263.62,77.37 263.73,77.26 263.73,76.6 263.84,76.49 264.07,76.49 264.18,76.6 264.18,77.26 264.29,77.37 264.51,77.37 264.63,77.26 264.63,76.6 264.74,76.49 264.98,76.49 269.07,80.59 272.09,80.59 272.21,80.7 272.21,81.33 272.32,81.44 272.54,81.44 272.65,81.33 272.65,80.7 272.77,80.59 273.92,80.59 274.12,80.79 v1(274.12,81.01)
  BOTTOM w0.089: UG1.AN15 243.87,87.95 v1(244.02,87.95) ; UG20.H5 v1(274.12,81.01)
FBD_MA6_L: length 31.4
  IN3 w0.089: v1(249.87,86.6) 249.87,86.25 250.27,85.85
  IN3 w0.112: 250.27,85.85 256.33,85.85 257.65,84.53 265.21,84.53 267.77,87.08 268.08,87.08 268.19,87.19 268.19,87.3 268.3,87.41 268.53,87.41 268.64,87.3 268.64,87.19 268.75,87.08 268.97,87.08 269.09,87.19 269.09,87.3 269.2,87.41 269.42,87.41 269.53,87.3 269.53,87.19 269.65,87.08 269.87,87.08 269.98,87.19 269.98,87.3 270.09,87.41 270.32,87.41 270.43,87.3 270.43,87.19 270.54,87.08 270.76,87.08 270.87,87.19 270.87,87.3 270.99,87.41 271.21,87.41 271.32,87.3 271.32,87.19 271.43,87.08 271.78,87.08 272.11,87.41 272.11,88.73 273.17,89.79 273.69,89.79 v1(274.12,90.21)
  BOTTOM w0.089: v1(249.87,86.6) 249.87,86.75 UG1.AR8 ; UG19.K5 274.52,90.61 v1(274.12,90.21)
FBD_MA7_H: length 50.9
  IN3 w0.089: v1(244.02,86.35) 244.38,85.99 244.38,79.35 247.02,76.71
  IN3 w0.112: 247.02,76.71 247.66,76.07 265.15,76.07 268.41,79.33 268.88,79.33 268.99,79.45 268.99,80.15 269.1,80.27 269.32,80.27 269.43,80.15 269.43,79.45 269.55,79.33 269.77,79.33 269.88,79.45 269.88,79.73 269.99,79.84 270.22,79.84 270.33,79.73 270.33,79.45 270.44,79.33 270.66,79.33 270.78,79.45 270.78,80.23 270.89,80.34 271.11,80.34 271.22,80.23 271.22,79.45 271.33,79.33 271.56,79.33 271.67,79.45 271.67,80.23 271.78,80.34 272,80.34 272.12,80.23 272.12,79.45 272.23,79.33 272.45,79.33 272.56,79.45 272.56,79.76 272.68,79.87 272.9,79.87 273.01,79.76 273.01,79.45 273.12,79.33 273.35,79.33 273.46,79.45 273.46,79.82 273.57,79.93 273.79,79.93 273.9,79.82 273.9,79.45 274.02,79.33 274.44,79.33 274.55,79.45 274.55,80.83 274.73,81.01 v1(274.92,81.01)
  BOTTOM w0.089: UG20.H4 v1(274.92,81.01) ; UG1.AR15 243.87,86.35 v1(244.02,86.35)
FBD_MA7_L: length 34.6
  IN3 w0.089: v1(247.49,87.93) 248.42,87
  IN3 w0.112: v1(274.92,90.21) 274.52,90.61 272.39,90.61 272.11,90.33 272.11,89.27 271.82,88.99 268.37,88.99 264.91,85.53 259.73,85.53 259.62,85.42 259.62,85.06 259.51,84.94 259.29,84.94 259.18,85.06 259.18,85.42 259.06,85.53 258.84,85.53 258.73,85.42 258.73,85.06 258.62,84.94 258.39,84.94 258.28,85.06 258.28,85.42 258.17,85.53 257.35,85.53 256.65,86.22 250.49,86.22 250.28,86.44 250.28,86.75 250.03,87 248.42,87
  BOTTOM w0.089: UG19.K4 274.52,89.81 v1(274.92,90.21) ; v1(247.49,87.93) UG1.AN11
FBD_MA8_H: length 54
  IN3 w0.089: 244.74,78.2 243.68,79.26 243.64,79.31 243.64,89 243.09,89.55 v1(242.82,89.55)
  IN3 w0.112: v1(274.92,80.21) 275.09,80.04 275.09,78.8 274.81,78.52 274.46,78.52 274.35,78.63 274.35,78.98 274.24,79.09 274.01,79.09 273.9,78.98 273.9,78.63 273.79,78.52 273.57,78.52 273.46,78.63 273.46,78.98 273.34,79.09 273.12,79.09 273.01,78.98 273.01,78.63 272.9,78.52 272.67,78.52 272.56,78.63 272.56,78.98 272.45,79.09 272.23,79.09 272.11,78.98 272.11,78.63 272,78.52 271.78,78.52 271.67,78.63 271.67,78.98 271.56,79.09 271.33,79.09 271.22,78.98 271.22,78.63 271.11,78.52 270.89,78.52 270.77,78.63 270.77,78.98 270.66,79.09 270.44,79.09 270.33,78.98 270.33,78.63 270.21,78.52 269.99,78.52 269.88,78.63 269.88,78.98 269.77,79.09 269.54,79.09 269.43,78.98 269.43,78.63 269.32,78.52 269.1,78.52 268.99,78.63 268.99,78.98 268.87,79.09 268.65,79.09 268.54,78.98 268.54,78.63 268.43,78.52 268.19,78.52 265.32,75.66 247.48,75.66 244.94,78.2 244.74,78.2
  BOTTOM w0.089: v1(242.82,89.55) 242.67,89.55 UG1.AL17 ; UG20.J5 v1(274.92,80.21)
FBD_MA8_L: length 32.7
  IN3 w0.089: v1(249.07,87.8) 249.47,87.4
  IN3 w0.112: v1(274.92,91.01) 274.55,91.39 272.37,91.39 271.35,90.37 271.35,90.11 271.08,89.84 268.42,89.84 264.53,85.95 260.44,85.95 260.33,86.06 260.33,86.52 260.21,86.63 259.99,86.63 259.88,86.52 259.88,86.06 259.77,85.95 259.54,85.95 259.43,86.06 259.43,86.52 259.32,86.63 259.1,86.63 258.98,86.52 258.98,86.06 258.87,85.95 257.37,85.95 256.32,87 250.47,87 250.07,87.4 249.47,87.4
  BOTTOM w0.089: UG19.J5 v1(274.92,91.01) ; v1(249.07,87.8) 249.07,87.95 UG1.AN9
FBD_RAS#_H: length 52.2
  IN3 w0.089: v1(245.22,87.95) 246.05,87.12 246.05,81.97 246.39,81.62
  IN3 w0.112: 246.39,81.62 252.62,81.62 253.47,80.77 257.65,80.77 257.76,80.89 257.76,81.45 257.87,81.57 258.09,81.57 258.21,81.45 258.21,80.89 258.32,80.77 258.54,80.77 258.65,80.89 258.65,81.45 258.76,81.57 258.99,81.57 259.1,81.45 259.1,80.89 259.21,80.77 259.44,80.77 259.55,80.89 259.55,81.45 259.66,81.57 259.88,81.57 259.99,81.45 259.99,80.89 260.11,80.77 260.33,80.77 260.44,80.89 260.44,81.45 260.55,81.57 260.78,81.57 260.89,81.45 260.89,80.89 261,80.77 261.22,80.77 261.34,80.89 261.34,81.45 261.45,81.57 261.67,81.57 261.78,81.45 261.78,80.89 261.89,80.77 262.12,80.77 262.23,80.89 262.23,81.45 262.34,81.57 262.56,81.57 262.68,81.45 262.68,80.89 262.79,80.77 263.01,80.77 263.12,80.89 263.12,81.45 263.23,81.57 263.46,81.57 263.57,81.45 263.57,80.89 263.68,80.77 263.92,80.77 264.03,80.89 264.03,81.45 264.14,81.57 264.37,81.57 264.48,81.45 264.48,80.89 264.59,80.77 265.73,80.77 266.01,81.06 266.01,82.02 268.35,84.36 275.09,84.36 276.07,83.38 276.07,83.06 v1(276.52,82.61)
  BOTTOM w0.089: UG1.AN14 v1(245.22,87.95) ; UG20.L3 v1(276.52,82.61)
FBD_RAS#_L: length 36.8
  IN3 w0.089: v1(246.41,86.36) 246.9,85.87
  IN3 w0.112: 246.9,85.87 246.9,84.02 247.42,83.5 247.77,83.5 248.75,82.52 265.78,82.52 268.09,84.83 272.09,84.83 273.91,86.65 274.94,86.65 276.15,87.85 276.15,88.24 v1(276.52,88.61)
  BOTTOM w0.089: UG19.G3 276.92,89.01 v1(276.52,88.61) ; v1(246.41,86.36) 246.41,86.36 UG1.AR12
FBD_WCK0: length 22.9
  IN4 w0.089: 258.73,89.88 258.71,89.88 258.69,89.87 258.26,89.87 257.98,89.59 253.04,89.59 252.91,89.72 252.91,89.84 v1(253.27,90.2)
  IN4 w0.119: 258.73,89.88 260.36,89.88 262.3,91.82 270.95,91.82 271.43,91.35 271.43,90.51 v1(271.72,90.21)
  BOTTOM w0.089: v1(253.27,90.2) 253.27,90.35 UG1.AK4 ; UG19.P4 271.32,89.81 v1(271.72,90.21)
FBD_WCK0_N: length 22.9
  IN4 w0.089: 258.73,89.67 258.71,89.67 258.69,89.69 258.34,89.69 258.06,89.41 252.96,89.41 252.73,89.64 252.73,89.84 v1(252.37,90.2)
  IN4 w0.119: v1(270.92,90.21) 271.22,90.51 271.22,91.26 270.87,91.62 267.64,91.62 267.64,91.61 262.39,91.61 260.45,89.67 258.73,89.67
  BOTTOM w0.089: UG1.AK5 252.37,90.35 v1(252.37,90.2) ; v1(270.92,90.21) 271.32,90.61 UG19.P5
FBD_WCK1: length 30.5
  IN1 w0.089: 258.73,88.61 258.64,88.61 258.62,88.6 258.25,88.6 258.13,88.47 257.51,88.47 256.88,87.85 256.55,87.85 255.84,87.14 254.84,87.14 254.71,87.28 254.71,87.44 v1(255.07,87.8)
  IN1 w0.119: v1(279.72,90.21) 279.41,90.53 279.41,91.15 278.2,92.36 268.45,92.36 267.3,91.21 262.53,91.21 259.93,88.61 258.73,88.61
  BOTTOM w0.089: v1(255.07,87.8) 255.07,87.95 UG1.AN2
  BOTTOM w0.107: v1(279.72,90.21) 279.32,89.81 UG19.D4
FBD_WCK1_N: length 30.5
  IN1 w0.089: 258.73,88.4 258.72,88.4 258.7,88.42 258.33,88.42 258.2,88.3 257.58,88.3 256.96,87.67 256.62,87.67 255.91,86.96 254.77,86.96 254.53,87.2 254.53,87.44 v1(254.17,87.8)
  IN1 w0.119: 258.73,88.4 260.02,88.4 262.61,91 267.38,91 267.79,91.4 267.79,91.41 268.53,92.15 278.11,92.15 279.2,91.07 279.2,90.49 v1(278.92,90.21)
  BOTTOM w0.089: v1(254.17,87.8) 254.17,87.95 UG1.AN3
  BOTTOM w0.107: v1(278.92,90.21) 279.32,90.61 UG19.D5
FBD_WCK2: length 41
  IN4 w0.089: v1(247.62,83.05) 247.86,83.29 248.02,83.29 248.18,83.14 248.18,78.82 248.75,78.25 248.75,77.51
  IN4 w0.119: v1(271.72,81.01) 271.47,80.76 271.47,80.17 271.8,79.84 274.04,79.84 274.28,79.59 274.28,78.87 274.04,78.63 269.02,78.63 268.65,78.26 267.64,78.26 267.64,78.26 267.32,78.26 263.82,74.76 251.49,74.76 248.75,77.51
  BOTTOM w0.089: UG1.AW11 247.47,83.05 v1(247.62,83.05) ; UG20.D4 v1(271.72,81.01)
FBD_WCK2_N: length 41
  IN4 w0.089: v1(247.62,83.95) 247.62,83.57 247.72,83.47 248.1,83.47 248.36,83.21 248.36,78.9 248.93,78.33 248.93,77.63 248.94,77.61
  IN4 w0.119: v1(270.92,81.01) 271.26,80.67 271.26,80.08 271.72,79.63 273.96,79.63 274.07,79.51 274.07,78.96 273.95,78.84 268.93,78.84 268.57,78.47 267.23,78.47 263.74,74.97 251.58,74.97 248.94,77.61
  BOTTOM w0.089: UG1.AV11 247.47,83.95 v1(247.62,83.95) ; UG20.D5 v1(270.92,81.01)
FBD_WCK3: length 41.9
  IN1 w0.089: 248.14,76.9 248.13,76.9 248.13,76.93 248.09,76.96 248.09,77.12 248.11,77.14 248.11,80.36 247.93,80.54 247.81,80.54 247.66,80.39 v1(247.66,80.35)
  IN1 w0.119: 248.14,76.9 248.38,76.65 248.38,76.65 250.09,74.94 267.64,74.94 267.64,74.94 267.77,74.94 268.12,75.3 268.12,76.44 269.93,78.25 278.33,78.25 279.54,79.45 279.54,80.83 v1(279.72,81.01)
  BOTTOM w0.089: UG1.BB11 247.47,80.35 v1(247.66,80.35)
  BOTTOM w0.107: UG20.P4 v1(279.72,81.01)
FBD_WCK3_N: length 41.8
  IN1 w0.089: v1(247.62,81.25) 247.62,81.03 247.94,80.71 248,80.71 248.28,80.43 248.28,80.29 248.28,80.29 248.28,77.04
  IN1 w0.119: v1(278.92,81.01) 279.33,80.61 279.33,79.53 278.25,78.45 269.84,78.45 267.92,76.53 267.92,75.38 267.69,75.15 250.18,75.15 248.59,76.74 248.59,76.74 248.47,76.86 248.47,76.86 248.28,77.04
  BOTTOM w0.089: UG1.BA11 247.47,81.25 v1(247.62,81.25)
  BOTTOM w0.107: UG20.P5 v1(278.92,81.01)
FBD_WE#_H: length 51.4
  IN3 w0.089: 241.11,87.15 v1(241.62,87.15)
  IN3 w0.112: v1(274.12,74.61) 273.83,74.61 273.72,74.5 273.72,73.28 273.55,73.1 273.17,73.1 273.06,73.22 273.06,73.47 272.84,73.69 272.65,73.69 272.54,73.58 272.54,73.16 272.43,73.05 272.21,73.05 272.09,73.16 272.09,74.1 271.96,74.24 271.48,74.24 271.34,74.1 271.34,72.85 271.23,72.74 245.91,72.74 241.18,77.47 241.18,78.65 240.79,79.03 240.79,86.83 241.11,87.15
  BOTTOM w0.089: UG1.AP18 241.47,87.15 v1(241.62,87.15) ; UG20.G12 v1(274.12,74.61)
FBD_WE#_L: length 34
  IN3 w0.089: v1(249.87,90.2) 249.76,90.2 249.63,90.33 249.63,90.9 249.75,91.03 257.88,91.03
  IN3 w0.112: 257.88,91.03 258.24,90.67 262.92,90.67 263.03,90.56 263.03,90.19 263.14,90.08 263.36,90.08 263.47,90.19 263.47,90.56 263.59,90.67 264.44,90.67 268.36,94.59 268.97,94.59 269.08,94.48 269.08,94.2 269.19,94.08 269.42,94.08 269.53,94.2 269.53,94.48 269.64,94.59 270.27,94.59 270.44,94.76 270.6,94.76 270.85,94.5 271.01,94.5 271.17,94.66 271.17,94.82 270.91,95.07 270.91,95.23 271.12,95.44 272.54,95.44 272.65,95.55 272.65,96.22 272.76,96.33 272.99,96.33 273.1,96.22 273.1,95.55 273.21,95.44 273.64,95.44 273.75,95.55 273.75,96.5 273.86,96.61 v1(274.12,96.61)
  BOTTOM w0.089: UG1.AK8 249.87,90.35 v1(249.87,90.2) ; UG19.L12 273.72,96.21 v1(274.12,96.61)
FCCM_GT: length 39
  IN1 w0.254: v1(122.56,144.78) 122.56,145.54 123.94,146.91 128.22,146.91 129.29,147.98 129.29,148.88 131.33,150.91 133.71,150.91 134.25,150.37 134.25,148.94 134.67,148.52 135.21,148.52 135.63,148.94 137.58,148.94 137.87,149.22 137.87,149.6 139.58,151.32 v1(142.47,151.32) 142.86,151.71 149.83,151.71 v1(150.37,151.17)
  BOTTOM w0.203: v1(122.56,144.78) 122.56,143.29 122.97,142.88 PU500.11
  BOTTOM w0.254: PR585.2 v1(142.47,151.32) ; v1(150.37,151.17) 150.8,150.74 PR594.2
FCCM_SA: length 65.6
  IN3 w0.254: v1(181.49,146.46) 180.98,146.97 174.27,146.97 174.01,146.72 172.41,146.72 171.23,147.9 169.29,147.9 168.77,147.38 166.14,147.38 164.06,149.46 157.56,149.46 154.81,152.21 145.52,152.21 143.77,150.46 142.19,150.46 140.28,148.56 140.28,147.45 138.47,145.64 135.71,145.64 134.87,144.8 134.87,139.68 134.48,139.29 v1(131.2,139.29)
  BOTTOM w0.107: v1(181.49,146.46) v2(181.49,147.09)
  BOTTOM w0.203: PU500.34 130.13,139.68 130.52,139.29 v1(131.2,139.29)
  BOTTOM w0.254: PR5006.2 181.81,146.15 v1(181.49,146.46)
FCCM_VCORE: length 59.9
  IN2 w0.254: v1(131.9,148.5) 135.18,148.5 135.57,148.88 137.8,148.88 141.23,152.31 155.01,152.31 158.04,149.27 158.04,148.45 v1(158.49,148) 160.58,150.08 164.16,150.08 v1(166.38,147.86)
  IN4 w0.254: v1(175.16,147.93) 173.2,149.89 168.4,149.89 v1(166.38,147.86)
  BOTTOM w0.107: v1(175.16,147.93) v2(175.16,148.61)
  BOTTOM w0.203: v1(131.9,148.5) 131.52,148.11 131.52,147.22 130.54,146.24 130.54,144.84 130.26,144.56 128.8,144.56 128.67,144.43 PU500.24
  BOTTOM w0.254: PR576.2 v1(175.16,147.93) ; v1(166.38,147.86) 166.82,147.42 PR566.2 ; v1(158.49,148) 158.29,147.8 PR556.2
FFS_INT1: length 89.4
  TOP w0.107: US1.11 183.4,72.93 v2(183.14,73.18) 182.83,73.5 v1(182.74,73.5)
  IN2 w0.091: v1(182.74,73.5) 182.25,73.01 182.25,72.36 183.4,71.22 183.4,68.71 188.32,63.79 192.18,63.79 194.54,61.42 194.54,60.96 195.24,60.26 v1(195.68,60.26)
  IN3 w0.089: v1(211.15,21.56) 210.89,21.56 209.62,22.83 209.62,24.16 209.29,24.49 208.67,24.49 208.27,24.89 207.72,24.89 207.3,24.48 207.3,23.68 207.09,23.47 206.61,23.47 206.36,23.72 204.99,23.72 203.93,24.78 202.95,24.78 202.35,25.38 202.14,25.59 202.14,28.45 201.51,29.08 201.51,30.09 201.68,30.26 202.26,30.26 202.74,30.73 202.74,31.88 203.46,32.61 203.46,39.32 200.7,42.08
  IN3 w0.091: v1(195.68,60.26) 195.94,60 198.85,60 201.12,57.72 201.12,51.08 200.43,50.38 200.43,42.36 200.7,42.08
  IN4 w0.097: v1(219.3,25.3) 218.86,25.75 218.45,25.75 217.68,24.98 216.4,24.98 214.57,23.15 213.5,23.15 212.28,21.93 211.52,21.93 v1(211.15,21.56)
  BOTTOM w0.089: v1(211.15,21.56) 210.96,21.37 UH1.AN38
  BOTTOM w0.107: v1(219.3,25.3) 219.64,24.97 RP5.8
FFS_INT2: length 95.5
  TOP w0.107: US1.9 184.4,72.53 185.11,73.24 QS3.3 186.05,74.28 185.87,74.45 183.27,74.45 182.95,74.14 v1(182.74,74.14)
  IN2 w0.091: v1(182.74,74.14) 181.94,73.33 181.94,72.1 183.14,70.9 183.14,68.65 188.23,63.57 192.09,63.57 194.32,61.33 194.32,60.48 v1(194.98,59.82)
  IN3 w0.089: 199.99,42.08 199.99,41.86 200.77,41.08 200.77,40.18 202.54,38.41 202.54,36.2 202.93,35.81 202.93,32.58 201.16,30.81 201.16,28.93 201.79,28.3 201.79,25.44 202.81,24.42 202.95,24.42 203.78,24.42 204.87,23.33 204.87,23.14 205.33,22.68 206.1,22.68 206.54,23.11 207.24,23.11 207.55,23.43 208.2,23.43 208.59,23.04 208.59,22.39 209.06,21.92 209.26,21.92 209.82,21.37 210.5,21.37 211.15,20.72 v1(211.15,20.67)
  IN3 w0.091: 199.99,42.08 199.99,50.56 200.68,51.26 200.68,57.54 198.66,59.56 195.24,59.56 v1(194.98,59.82)
  IN4 w0.097: v1(211.15,20.67) 211.28,20.67 211.6,20.99 211.6,21.62 211.73,21.75 212.36,21.75 213.57,22.96 214.64,22.96 216.48,24.8 218.2,24.8 v1(218.7,25.3)
  BOTTOM w0.089: v1(211.15,20.67) 211.15,20.48 210.66,19.99 UH1.AN41
  BOTTOM w0.107: RP5.7 219.63,24.47 219.23,24.87 219.14,24.87 v1(218.7,25.3)
