# Allegro board LAD752PR10-0816.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
+5VS on TOP (solid shape): 291.86,77.75 291.86,73.61 291.19,72.93 290.61,72.93 289.8,72.12 289.28,72.12 288.92,72.47 288.92,72.86 289.58,73.51 289.58,75.07 290.39,75.88 290.39,77.92 290.69,78.23 291.38,78.23
+5VS on TOP (solid shape): 28.37,39.04 31.46,39.04 31.5,39 31.5,37.77 30.88,37.15 30.88,36.32 30.79,36.22 30.33,36.22 30.22,36.33 30.22,37.57 29.85,37.94 27,37.94 26.74,38.2 26.74,39.11 26.78,39.15 28.26,39.15
+5VS on TOP (solid shape): 194.62,17.4 194.62,14.21 194.59,14.18 194.59,12.85 194.55,12.84 194.28,12.49 194.55,12.15 194.59,12.14 194.59,11.57 194.49,11.47 193.28,11.47 193.02,11.73 193.02,17.34 193.15,17.47 194.55,17.47
+5VS on TOP (solid shape): 109.52,63.36 109.6,62.98 109.98,62.9 110.31,62.57 111.02,62.57 111.2,62.39 111.2,61.06 110.58,60.43 107.44,60.43 107.01,60 107.01,58.24 106.66,57.89 105.68,57.89 105.64,57.93 105.64,58.64 106.06,59.06 106.06,61.06 106.37,61.37 106.37,64.48 106.5,64.62 108.26,64.62
+5VS on TOP (solid shape): 222.39,56.61 222.39,53.56 222.24,53.42 221.75,53.42 221.26,53.91 221.26,54.79 221.19,55.19 220.79,55.27 220.67,55.39 220.67,55.72 220.82,55.87 220.94,55.85 221.05,55.87 221.14,55.87 221.34,56.08 221.34,56.71 221.43,56.8 222.2,56.8
+5VS on TOP (solid shape): 239.66,55.63 239.66,52.95 239.65,52.95 239.65,52.51 239.54,52.41 238.98,52.41 238.51,52.88 238.51,53.78 238.55,53.94 238.51,54.11 238.45,54.2 238.37,54.26 238.3,54.32 238.12,54.32 237.96,54.49 237.96,54.7 238.12,54.87 238.46,54.97 238.54,55.3 238.54,55.75 238.6,55.81 239.48,55.81
+5VS on TOP (solid shape): 280.16,63.61 280.18,63.51 280.1,63.44 279.82,63.02 280.25,62.74 280.33,62.72 280.37,62.64 280.37,62.45 280.08,62.15 279.04,62.15 278.23,62.97 278.23,63.96 278.47,64.2 279.56,64.2
+5VS on TOP (solid shape): 231.09,55.63 231.09,53.04 231.09,53.04 230.86,52.81 230.39,52.81 230.08,53.12 230.08,53.94 229.96,54.07 229.77,54.27 229.47,54.27 229.4,54.35 229.4,54.76 229.51,54.87 229.92,55.01 229.9,55.43 229.9,55.63 229.94,55.67 229.96,55.73 230.01,55.77 230.95,55.77
+5VS on TOP (solid shape): 248.2,55.66 248.2,53.12 247.82,52.74 247.13,52.74 246.87,52.99 246.87,53.6 247.11,54.03 246.68,54.29 246.54,54.43 246.54,54.71 246.69,54.86 247.05,54.99 247.08,55.37 247.08,55.69 247.1,55.72 247.15,55.77 248.09,55.77
+5VS on TOP (solid shape): outline of 236 points within 192.48,146.78 205.05,157.32
+5VS on TOP (solid shape): outline of 252 points within 206.57,152.18 211.16,159.52
+5VS on TOP (solid shape): outline of 596 points within 129.84,4.32 163.14,10.82
+5VS on BOTTOM (solid shape): 44.65,49.37 44.65,47.21 44.59,47.15 42.74,47.15 42.36,47.53 42.36,49.88 42.55,50.07 43.95,50.07
+5VS on BOTTOM (solid shape): 268.7,52.27 268.7,51.42 268.23,50.94 267.79,50.94 267.66,51.07 267.66,51.58 268.42,52.34 268.64,52.34
+5VS on BOTTOM (solid shape): 222.8,54.29 222.8,53.46 222.68,53.35 221.84,53.35 221.76,53.43 221.76,54.27 221.85,54.37 222.73,54.37
+5VS on BOTTOM (solid shape): 224.47,168.43 224.47,166.25 224.4,166.17 223.32,166.17 222.98,166.51 222.98,168.36 223.24,168.61 224.29,168.61
+5VS on BOTTOM (solid shape): 231.49,53.29 231.49,52.46 231.36,52.33 230.53,52.33 230.45,52.41 230.45,53.26 230.56,53.37 231.41,53.37
+5VS on BOTTOM (solid shape): 163.26,9.27 163.26,7.12 162.81,6.67 162.81,4.7 162.62,4.51 161.99,4.51 161.76,4.74 161.76,6.6 162.15,7 162.15,9.2 162.28,9.33 163.21,9.33
+5VS on BOTTOM (solid shape): 248.63,53.29 248.63,52.46 248.53,52.36 247.15,52.36 247.01,52.5 247.01,53.29 247.09,53.37 248.56,53.37
+5VS on BOTTOM (solid shape): 187.97,68.68 187.97,67.66 187.46,67.15 186.95,67.15 186.76,67.34 186.76,67.72 187.4,68.36 187.4,68.74 187.46,68.8 187.84,68.8
+5VS on BOTTOM (solid shape): 239.99,53.37 240.06,53.3 240.06,52.44 239.91,52.29 239.1,52.29 239.02,52.36 239.02,53.24 239.16,53.37 239.98,53.37
+5VS on BOTTOM (solid shape): 35.76,49.82 35.76,48.36 35.31,47.91 33.35,47.91 33.09,48.17 33.09,49.05 32.77,49.37 32.14,49.37 32.08,49.44 32.08,50.01 32.14,50.07 35.51,50.07
+5VS on BOTTOM (solid shape): 61.66,11.4 62.38,11.4 62.59,11.19 62.59,9.18 62.28,8.86 60.62,8.86 60.57,8.86 57.98,8.86 57.58,9.26 57.58,11.09 56.93,11.74 56.93,12.59 57.05,12.71 60.36,12.71
+5VS on BOTTOM (solid shape): outline of 224 points within 273.48,20.63 285.12,33.18
+5VS on IN1 (solid shape): 111.26,61.82 111.26,59.09 110.94,58.77 108.39,58.77 107.82,59.34 107.82,62.05 108.47,62.7 110.38,62.7
+5VS on IN1 (solid shape): 106.48,30.59 106.48,26.62 106.31,26.45 102.82,26.45 102.69,26.58 102.69,30.7 102.82,30.83 106.24,30.83
+5VS on IN1 (solid shape): 134.37,21.2 134.37,7.25 134.23,7.1 130,7.1 129.77,7.34 129.77,11 128.15,12.62 128.15,21.35 128.3,21.5 134.08,21.5
+5VS on IN1 (solid shape): 240.17,57.94 240.17,56.25 239.77,56.15 239.72,55.75 239.72,55.41 239.69,55.22 239.75,55.04 239.75,54.77 239.72,54.73 239.7,54.69 239.34,54.32 238.13,54.32 238.01,54.45 238.01,54.71 238.13,54.83 238.33,54.83 238.95,55.45 238.95,58.02 239,58.07 240.04,58.07
+5VS on IN1 (solid shape): 231.59,57.94 231.59,56.25 231.19,56.14 231.17,55.73 231.17,55.43 231.11,55.24 231.17,55.05 231.17,54.77 231.15,54.73 231.13,54.69 230.77,54.32 229.47,54.32 229.35,54.45 229.35,54.74 229.43,54.83 229.79,54.83 230.36,55.4 230.36,57.97 230.46,58.07 231.47,58.07
+5VS on IN1 (solid shape): 248.73,57.94 248.73,56.25 248.33,56.14 248.3,55.73 248.3,55.43 248.25,55.23 248.32,55.03 248.32,54.77 248.29,54.73 248.27,54.68 247.91,54.32 246.7,54.32 246.57,54.45 246.57,54.7 246.7,54.83 246.91,54.83 247.53,55.45 247.53,57.96 247.64,58.07 248.61,58.07
+5VS on IN1 (solid shape): outline of 206 points within 150.69,9.4 180.09,42.07
+5VS on IN1 (solid shape): outline of 278 points within 29.92,37.93 33.77,50.13
+5VS on IN1 (solid shape): outline of 717 points within 58.81,6.26 94.37,13.16
+5VS on IN2 (solid shape): 184.48,146.72 184.48,145.89 182.32,145.89 182.13,146.08 182.13,146.65 182.38,146.91 184.29,146.91
+5VS on IN2 (solid shape): 187.65,67.93 187.65,67.41 187.27,67.02 186.64,67.02 186.51,67.15 186.51,67.66 185.43,68.74 186.13,69.44 186.15,69.44
+5VS on IN2 (solid shape): 307.6,58.07 307.6,57.31 307.35,57.06 306.02,57.06 305.89,57.18 305.89,57.94 306.15,58.21 306.25,58.22 306.34,58.26 307.41,58.26
+5VS on IN3 (solid shape): 211.18,159.3 211.18,158.4 210.92,158.13 210.35,158.13 209.53,158.95 209.53,159.2 210.36,160.03 210.46,160.03
+5VS on IN3 (solid shape): 224.42,168.42 224.42,167.74 224.18,167.49 222.59,167.49 222.37,167.71 222.37,168.5 222.54,168.66 224.18,168.66
+5VS on IN3 (solid shape): 284.57,22.79 284.57,19.27 284.37,19.07 283.09,19.07 282.96,19.2 282.96,22.97 283.09,23.11 284.25,23.11
+5VS on IN3 (solid shape): 107.26,28.23 107.26,24.29 106.69,23.72 104.85,23.72 104.53,24.04 104.53,28.13 104.78,28.38 107.11,28.38
+5VS on IN3 (solid shape): 132.03,23.4 132.03,20.29 131.83,20.09 125.87,20.09 125.8,20.16 125.8,23.15 126.25,23.59 131.83,23.59
+5VS on IN3 (solid shape): 283.9,7.31 283.9,5.26 283.63,4.99 281.9,4.99 281.69,5.2 281.69,5.7 281.69,5.71 281.73,5.84 281.72,5.98 281.71,6.01 282.23,6.54 282.23,6.67 282.22,6.69 282.22,7.18 282.55,7.51 283.7,7.51
+5VS on IN3 (solid shape): 62.64,10.8 62.68,10.8 62.95,10.54 62.96,10.01 63.48,10.08 63.48,7.32 63.1,6.94 59,6.94 58.45,7.49 58.45,11.18 58.61,11.34 62.1,11.34
+5VS on IN3 (solid shape): 222.77,59.09 222.77,58.62 221.65,57.5 221.65,55.37 221.62,55.34 220.67,55.34 220.54,55.47 220.54,55.72 220.67,55.85 220.99,55.85 221,55.86 221.01,55.86 221.28,56.11 221.18,56.46 221.18,56.59 221.29,56.84 221.18,57.1 221.18,57.22 221.29,57.48 221.18,57.73 221.18,58.9 221.5,59.21 222.64,59.21
+5VS on IN4 (solid shape): 284.81,47.85 284.81,47.4 284.17,46.77 281.95,46.77 281.89,46.83 281.89,47.72 282.14,47.97 284.68,47.97
+5VS on IN4 (solid shape): 35.1,49.78 44.45,49.78 44.59,49.64 44.59,48.64 44.41,48.46 32.23,48.46 31.87,48.81 31.87,50.01 32.08,50.22 34.66,50.22
+5VS on IN4 (solid shape): 179.67,41.87 179.69,41.85 179.92,41.77 180.16,41.87 180.5,41.87 180.51,41.87 180.86,41.87 180.92,41.82 180.92,40.86 180.86,40.81 179.15,40.81 178.93,41.03 178.93,41.87 179.06,42 179.54,42
+5VS on IN4 (solid shape): outline of 726 points within 58.37,6.19 94.24,12.29
+5VS on IN4 (solid shape): outline of 2206 points within 186.43,50.6 269.57,69.3
+5VS on VCC: 97.63,4.17 96.94,5.59 95.47,6.17 90.69,6.17 90.69,9.13 92,10.45 104.42,10.45 107.09,7.78 163.31,7.78 169.21,13.68 184.37,13.68 187.55,10.51 231.57,10.51 232.08,11.02 240.19,11.02 241.9,9.3 251.64,9.3 259.19,16.86 264.02,16.86 267.89,12.99 271.43,12.99 276.64,7.78 332.79,7.78 334.65,9.64 334.65,45.22 332.35,47.53 322.12,47.53 312.98,56.67 298.18,56.67 292.88,61.98 280.11,61.98 280.1,61.98 279.35,61.98 279.35,61.98 279.35,63.87 280.02,64.55 293.78,64.55 296.84,61.49 297,61.49 300.76,61.47 300.92,61.63 301.59,61.22 302.37,61.08 321.25,61.08 321.25,52.8 321.89,51.27 323.42,50.63 337.25,50.63 337.25,4.17 238.71,4.17 238.71,6.95 237.82,7.84 233.84,7.84 232.63,6.64 187.27,6.64 182.06,11.84 176.81,11.84 171.97,7 171.97,4.17 ; 1 cut-out
+5VS on VCC: 57.58,8.86 54.22,12.22 43.99,12.22 40.52,15.69 40.52,23.93 43.76,27.17 43.76,32.76 45.28,34.28 45.28,46.11 42.15,49.24 32.56,49.24 32.2,49.6 32.2,52.99 32.69,52.87 33.19,52.83 42.17,52.83 42.3,52.82 42.42,52.79 44.62,52.09 45.74,51.73 46.5,50.97 46.62,50.86 46.74,50.76 46.74,25.98 43.63,22.87 43.63,18.47 44.54,17.56 60.08,17.56 60.08,12.88 61.92,11.04 61.92,9.47 61.31,8.86
+5VS_TP_LED on TOP (solid shape): 117.56,30.41 117.56,29.16 117.45,29.06 109.51,29.06 109.28,29.29 109.28,30.41 109.32,30.45 112.13,30.45 112.36,30.22 113.42,30.22 113.5,30.14 115.53,30.14 115.92,30.53 117.43,30.53
+5VS_TP_LED on BOTTOM (solid shape): 197.41,11.53 197.41,10.11 197.3,9.94 197.29,9.73 197.3,9.7 197.08,9.48 196.42,9.48 196.17,9.74 196.17,11.7 196.26,11.79 197.15,11.79
+AVDDL on IN2 (solid shape): outline of 506 points within 231.97,151.04 242.45,158.54
+PVDD on TOP (solid shape): 31.57,6.64 31.57,5.68 31.06,5.18 30.81,5.18 30.68,5.3 30.68,5.62 31.19,6.13 31.19,6.57 31.31,6.7 31.5,6.7
+PVDD on TOP (solid shape): 39.82,7.21 39.82,6.76 39.76,6.7 38.43,6.7 38.17,6.95 37.28,6.95 37.16,7.08 37.16,7.27 37.22,7.33 39.7,7.33
+PVDD on TOP (solid shape): 36.84,6.64 36.84,6.06 36.9,6 37.22,6 38.05,5.18 38.24,5.18 38.3,5.11 38.3,4.79 38.24,4.73 38.05,4.73 37.09,5.68 36.72,5.68 36.52,5.88 36.52,6.64 36.58,6.7 36.78,6.7
+PVDD on TOP (solid shape): 30.93,7.31 30.93,6.95 30.81,6.83 30.62,6.83 30.11,6.32 30.11,5.62 29.6,5.11 29.6,4.03 29.35,3.78 28.46,3.78 28.33,3.91 28.33,4.29 28.77,4.73 28.77,5.37 28.96,5.56 28.96,6.26 29.03,6.32 29.61,6.32 29.8,6.51 29.8,7.02 30.12,7.33 30.91,7.33
+PVDD on BOTTOM (solid shape): 28.84,10.57 28.84,9.68 28.46,9.31 28.46,8.8 28.77,8.48 28.77,7.27 29.16,6.89 30.11,6.89 30.36,6.64 30.93,6.64 31.5,6.06 33.09,6.06 33.41,6.38 36.2,6.38 36.39,6.19 37.41,6.19 37.79,6.57 37.79,7.02 37.98,7.21 38.49,7.21 38.52,7.18 38.59,7.18 38.68,7.08 38.68,6.32 38.55,6.19 38.55,5.56 38.37,5.37 37.85,5.37 37.66,5.56 37.44,5.74 37.17,5.63 36.73,5.63 36.69,5.59 36.12,5.59 36.01,5.6 35.83,5.59 35.41,5.16 35.41,5.08 35.12,4.79 34.81,4.79 34.62,4.99 34.62,5.18 34.81,5.37 35.06,5.37 35.12,5.43 35.12,5.56 35.06,5.62 34.55,5.62 34.24,5.3 33.41,5.3 33.28,5.18 33.28,4.86 33.16,4.73 32.9,4.73 32.77,4.86 32.77,5.24 32.58,5.43 31.38,5.43 31.31,5.37 31.31,5.18 31.19,5.05 30.68,5.05 30.55,5.18 30.55,5.81 30.49,5.87 30.11,5.87 29.98,5.75 29.98,4.41 29.35,3.78 28.39,3.78 28.01,4.16 28.01,7.78 27.76,8.03 27.76,9.43 28.08,9.75 28.08,10.64 28.11,10.67 28.74,10.67
+V18R on TOP (solid shape): 309.49,21.19 309.49,20.32 309.47,20.3 308.86,20.3 308.85,20.32 308.85,20.47 306.3,20.47 306.23,20.54 306.23,20.66 306.35,20.78 308.78,20.78 308.85,20.85 308.85,21.19 308.86,21.2 309.47,21.2
+VCC_CORE on TOP (solid shape): outline of 2712 points within 153.81,100.61 179.33,131.48
+VCC_CORE on BOTTOM (solid shape): outline of 1469 points within 154.45,113.5 179.74,137.24
+VCC_CORE on IN1 (solid shape): outline of 9506 points within 154.18,100.28 179.9,129.83
+VCC_CORE on IN2 (solid shape): outline of 3108 points within 153.7,100.91 168.25,124.43
+VCC_CORE on IN3 (solid shape): outline of 5009 points within 153.7,100.91 180.28,129.96
+VCC_CORE on IN4 (solid shape): outline of 2422 points within 153.65,103.65 166.26,123.66
+VCC_CORE on VCC: 167.83,101.29 153.73,101.35 153.73,121.07 156.28,123.62 156.28,133.45 179.16,133.45 179.84,132.77 179.84,125.11 178.57,123.83 165.82,123.83 164.78,122.79 164.78,113.9 163.51,112.63 163.51,108.1 164.04,107.57 166.3,107.57 166.3,103.09 167.83,101.56
+VCCGT on TOP (solid shape): outline of 3119 points within 132.06,101.33 154.25,134.82
+VCCGT on BOTTOM (solid shape): outline of 422 points within 138.8,101.01 151.91,102.96
+VCCGT on BOTTOM (solid shape): outline of 2442 points within 131.8,113.09 156.6,135.74
+VCCGT on IN1 (solid shape): outline of 5032 points within 132.18,101.49 154.31,134.87
+VCCGT on IN2 (solid shape): outline of 4073 points within 132.11,101.38 154.43,124.82
+VCCGT on IN3 (solid shape): outline of 4932 points within 131.75,101.44 154.31,134.94
+VCCGT on IN4 (solid shape): outline of 3590 points within 132.91,103.75 153.29,123.8
+VCCGT on VCC: 137.66,101.35 137.66,114.41 132.9,119.17 132.9,129.19 140.02,136.31 140.32,136.62 154.91,136.62 155.77,135.75 155.77,123.84 153.22,121.28 153.22,101.35
+VCCIO on TOP (solid shape): 168.3,110.34 168.4,110.29 168.42,110.18 168.44,109.97 168.57,109.81 168.63,109.7 168.58,109.59 168.45,109.19 168.83,109 168.87,109 169.14,108.73 169.12,108.69 169.09,108.46 169.21,108.27 169.21,107.93 169.65,107.5 169.65,107.4 169.6,107.3 169.49,107.28 169.08,106.96 169.49,106.64 169.6,106.62 169.65,106.52 169.65,105.83 169.6,105.73 169.49,105.71 169.2,105.64 169.08,105.38 168.97,105.27 168.97,104.37 168.84,104.24 167.32,104.24 167.04,104.52 167.04,105.3 167.08,105.39 167.18,105.42 167.33,105.44 167.46,105.53 167.7,105.77 168.6,105.77 168.6,106.61 167.51,106.61 167.51,106.58 167.26,106.33 167.12,106.3 167.04,106.42 167.04,110.12 167.26,110.34
+VCCIO on BOTTOM (solid shape): 121.74,101.82 122.44,101.82 122.44,102.3 122.94,102.3 122.94,101.82 123.64,101.82 123.64,102.3 124.96,102.3 125.22,102.05 125.22,99.95 124.71,99.45 120.96,99.45 120.58,99.83 120.58,102.05 120.84,102.3 121.74,102.3
+VCCIO on BOTTOM (solid shape): 167.06,113.1 167.35,112.94 167.63,113.1 167.65,113.13 168.53,113.13 168.59,113.08 168.59,112.32 168.64,112.27 168.64,112.01 168.6,112 168.44,111.88 168.37,111.69 168.37,111.66 168.29,111.58 167.85,111.58 167.52,111.91 167.44,111.91 167.11,112.06 166.84,111.81 166.76,111.72 166.64,111.74 166.51,111.8 166.36,111.79 166.27,111.81 166.23,111.89 166.23,113.13 167.04,113.13
+VCCIO on BOTTOM (solid shape): outline of 94 points within 166.23,103.19 169.7,110.64
+VCCIO on IN3 (solid shape): outline of 904 points within 166.28,87.85 170,112.87
+VCCIO on VCC: 119.31,97.1 119.31,125.69 132.39,138.77 132.39,142.2 140.44,150.25 180.21,150.25 193.93,136.53 193.93,117.92 183.64,107.63 183.64,103.36 181.57,101.29 168.34,101.29 168.34,101.77 166.81,103.3 166.81,112.42 168.46,114.07 168.46,116.68 169.2,117.42 182.54,117.42 188.16,123.04 188.16,131.14 186.17,133.13 180.2,133.13 179.37,133.95 156.28,133.95 156.28,135.96 155.12,137.13 140.11,137.13 139.66,136.67 132.39,129.4 132.39,118.96 137.16,114.2 137.16,101.35 128.29,101.35 124.03,97.1
+VCCIOP on BOTTOM (solid shape): 127.58,108.68 127.58,107.09 127.45,106.97 124.66,106.97 124.4,106.71 124.4,102.71 124.21,102.52 121.16,102.52 121.04,102.65 121.04,103.98 121.29,104.24 121.29,108.49 121.86,109.06 127.2,109.06
+VCCSA on TOP (solid shape): 165.93,114.65 165.93,109.82 165.49,109.38 165.49,108.24 165.3,108.05 164.41,108.05 164.35,108.11 164.35,112.17 164.6,112.43 164.6,114.71 164.66,114.78 165.81,114.78
+VCCSA on TOP (solid shape): 183.69,129.88 183.69,124.72 182.63,123.67 179.97,123.67 179.63,124.01 179.63,126.76 179.64,126.79 179.67,126.81 180,127.16 179.67,127.52 179.64,127.53 179.63,127.57 179.63,129.67 179.98,130.03 183.54,130.03
+VCCSA on BOTTOM (solid shape): 185.11,131.99 185.11,130.53 184.47,129.89 184.09,129.89 183.75,129.55 183.75,127.3 183.32,126.87 180.48,126.87 180.22,127.12 180.22,131.8 180.66,132.24 184.85,132.24
+VCCSA on BOTTOM (solid shape): outline of 447 points within 165.35,113.4 168.02,123.05
+VCCSA on IN2 (solid shape): outline of 1509 points within 165.59,115.47 183.92,130.01
+VCCSA on VCC: 164.25,108.08 164.02,108.31 164.02,112.42 165.29,113.69 165.29,122.58 166.03,123.32 178.78,123.32 180.35,124.89 180.35,132.62 185.96,132.62 187.65,130.93 187.65,123.25 182.33,117.93 168.99,117.93 167.95,116.89 167.95,114.28 166.3,112.63 166.3,108.08
+VCCST on TOP (solid shape): 175.7,92.93 177.04,91.59 177.04,88.36 178.63,86.76 178.63,84.23 178.19,83.79 178.19,82.84 178.38,82.65 178.38,80.99 178.25,80.87 176.41,80.87 175,82.28 175,85 172.82,87.17 172.82,89.92 175.25,89.92 175.26,89.87 175.27,89.82 175.29,89.77 175.32,89.72 175.35,89.68 175.39,89.64 175.43,89.61 175.48,89.59 175.53,89.57 175.59,89.57 175.64,89.57 175.69,89.57 175.74,89.59 175.79,89.61 175.83,89.64 175.87,89.68 175.91,89.72 175.93,89.77 175.95,89.82 175.96,89.87 175.97,89.92 175.96,89.98 175.95,90.03 175.93,90.08 175.91,90.12 175.87,90.16 175.83,90.2 175.79,90.23 175.74,90.25 175.69,90.27 175.64,90.28 175.59,90.28 175.53,90.27 175.48,90.25 175.43,90.23 175.39,90.2 175.35,90.16 175.32,90.12 175.29,90.08 175.27,90.03 175.26,89.98 175.25,89.92 172.82,89.92 172.82,92.96 173.24,93.38 175.25,93.38
+VCCST on IN2 (solid shape): outline of 4854 points within 165.67,88.14 176.59,116.33
+VCCSTG on TOP (solid shape): 183.13,84.71 183.13,83.22 182.06,83.22 181.43,82.58 181.43,81.76 181.56,81.63 181.81,81.63 182.06,81.38 182.06,80.99 182.03,80.99 181.94,80.9 179.99,80.9 179.59,81.31 179.59,84.61 180.73,85.76 182.09,85.76
+VCCSTG on TOP (solid shape): outline of 1070 points within 168.16,112.11 181.68,118.84
+VCCSTG on BOTTOM (solid shape): 129.34,114.14 129.34,112.69 129.22,112.57 128.65,112.57 128.6,112.62 128.6,113.19 128.28,113.51 127.81,113.51 127.25,112.94 127.25,112.54 127.2,112.5 126.03,112.5 125.94,112.58 125.94,113.06 127.09,114.21 129.25,114.21 129.26,114.22
+VDD_TOUCH on TOP (solid shape): 168.52,181.97 168.52,181.14 168.38,181.01 167.89,181.01 167.79,180.91 167.79,179.76 167.73,179.69 167.53,179.69 167.48,179.74 167.48,180.78 167.14,181.12 167.14,182.14 167.31,182.3 168.18,182.3
+VDD_TOUCH on BOTTOM (solid shape): 169.36,172.21 169.36,171.28 169.36,171.27 169.36,169.76 169.17,169.57 168.36,169.57 168.25,169.68 168.25,171.35 168.38,171.49 168.38,172.12 168.61,172.34 169.24,172.34
+VDD_TOUCH on IN3 (solid shape): outline of 524 points within 165.42,171.26 171.33,182.81
+VDDCI on TOP (solid shape): 244.03,101.99 244.03,101.01 243.93,100.91 243.49,100.91 243.49,100.91 243.4,100.91 243.26,100.77 243.26,100.5 243.26,100.5 243.26,100.44 243.24,100.43 243.13,100.43 243.12,100.42 242.85,100.42 242.85,100.42 242.85,101.41 243.12,101.67 243.12,101.72 243.12,101.72 243.12,102.26 243.34,102.47 243.55,102.47
+VDDCI on TOP (solid shape): 245.35,99.92 245.35,97.15 245.52,96.99 245.52,96.63 245.5,96.61 245.02,96.61 244.93,96.71 244.93,97.5 244.55,97.89 243.79,97.89 243.69,97.98 243.7,98.01 243.72,98.09 243.71,98.17 243.71,99.72 243.76,99.76 243.96,99.76 244.21,100.01 244.93,100.01 244.95,100.03 245.24,100.03
+VDDCI on TOP (solid shape): 245.27,95.6 245.27,95.5 245.09,95.32 245.07,95.32 244.88,95.25 244.76,95.08 244.02,94.33 243.54,94.33 243.51,94.36 243.47,94.38 243.36,94.49 243.36,94.87 243.35,94.88 243.17,94.88 243.09,94.96 243.09,95.22 243.47,95.6 244.36,95.6 244.64,95.88 244.79,95.88 244.79,95.88 244.99,95.88
+VDDCI on TOP (solid shape): outline of 197 points within 238.99,103.71 244.31,107.47
+VDDCI on TOP (solid shape): outline of 91 points within 228.9,101.06 238.25,107.11
+VDDCI on TOP (solid shape): outline of 8041 points within 236.61,62.83 273.63,93.31
+VDDCI on BOTTOM (solid shape): 275.66,68.99 275.98,68.99 276.42,68.55 276.42,64.99 275.82,64.39 272.96,64.39 272.96,65.28 272.2,65.28 272.2,63.82 270.79,62.41 264.6,62.41 264.27,62.74 264.27,68.01 265.25,68.99 275.66,68.99
+VDDCI on GND1: 236.84,78.96 236.1,79.7 236.1,99.83 235.06,100.87 230.43,100.87 230.01,101.29 230.01,105.51 243.17,105.51 243.53,105.15 243.53,87.45 241.75,85.67 241.75,79.45 241.27,78.96
+VDDCT_L on TOP (solid shape): 242.32,163.8 242.32,154.38 242.5,154.21 243.6,154.21 243.76,154.37 244.18,154.37 244.24,154.3 244.24,153.57 244.14,153.47 242.46,153.47 242.32,153.33 242.32,151.86 242.13,151.67 241.25,151.67 240.93,151.99 240.93,155.16 241.63,155.86 241.63,159.35 240.8,160.18 240.8,163.83 240.85,163.88 242.25,163.88
+VDDCT_L on BOTTOM (solid shape): 243.53,154.71 243.53,154.4 243.59,154.34 244.2,154.34 244.23,154.31 244.23,153.58 244.1,153.45 243.66,153.45 243.53,153.32 243.53,153.01 243.37,152.84 241.44,152.84 241.12,153.16 241.12,154.72 241.31,154.91 241.31,154.93 243.32,154.93
GND on TOP (solid shape): 141.24,104.11 141.24,102.77 141.18,102.71 140.29,102.71 140.22,102.77 140.22,104.17 140.29,104.23 141.11,104.23
GND on TOP (solid shape): 143.65,104.11 143.65,102.77 143.62,102.74 142.67,102.74 142.64,102.77 142.64,104.17 142.7,104.23 143.53,104.23
GND on TOP (solid shape): 146.26,104.11 146.26,102.77 146.19,102.71 145.3,102.71 145.24,102.77 145.24,104.11 145.37,104.23 146.13,104.23
GND on TOP (solid shape): 146.57,127.1 146.57,124.37 145.52,123.32 143.49,123.32 143.23,123.57 143.23,126.49 144.09,127.35 146.31,127.35
GND on TOP (solid shape): 146.69,131.79 146.69,129.06 146.31,128.68 142.38,128.68 141.93,129.13 141.93,131.6 142.25,131.92 146.55,131.92
GND on TOP (solid shape): 148.67,104.11 148.67,102.77 148.61,102.71 147.72,102.71 147.65,102.77 147.65,104.17 147.78,104.3 148.48,104.3
GND on TOP (solid shape): 151.08,104.17 151.08,102.77 151.02,102.71 150.13,102.71 150.07,102.77 150.07,104.17 150.19,104.3 150.96,104.3
GND on TOP (solid shape): 154.07,75.34 154.07,72.61 153.81,72.36 150.77,72.36 150.51,72.61 150.51,75.4 150.83,75.72 153.69,75.72
GND on TOP (solid shape): 171.24,79.94 171.24,77.05 170.91,76.72 169.55,76.72 169.4,76.86 169.4,79.94 169.47,80.01 171.18,80.01
GND on TOP (solid shape): 171.59,75.72 171.59,72.93 171.28,72.61 168.42,72.61 168.04,72.99 168.04,75.72 168.29,75.98 171.34,75.98
GND on TOP (solid shape): 188.86,129.06 188.86,124.3 188.35,123.79 185.24,123.79 184.29,124.75 184.29,128.62 185.56,129.89 188.03,129.89
GND on TOP (solid shape): 209.83,170.21 209.83,168.37 209.69,168.24 207.37,168.24 207.22,168.39 207.22,170.3 207.44,170.52 209.51,170.52
GND on TOP (solid shape): 221.29,170.23 221.29,167.81 221.23,167.76 219.95,167.76 219.88,167.83 219.88,170.27 219.98,170.38 221.14,170.38
GND on TOP (solid shape): 82.5,20.48 82.5,19.02 82.37,18.89 81.67,18.89 81.35,19.21 80.78,19.21 80.4,19.59 80.4,20.42 80.65,20.67 82.3,20.67
GND on TOP (solid shape): 150.38,79.95 150.38,76.52 150.31,76.46 149.25,76.46 149.15,76.56 149.15,79.77 149.34,79.97 150.36,79.97
GND on TOP (solid shape): 152.35,79.82 152.35,76.55 152.29,76.48 150.87,76.48 150.58,76.78 150.58,79.78 150.77,79.98 152.2,79.98
GND on TOP (solid shape): 178.51,127.22 178.51,123.92 178.32,123.73 174.95,123.73 174.76,123.92 174.76,126.21 175.59,127.03 175.59,127.35 176.03,127.79 177.94,127.79
GND on TOP (solid shape): 208.85,166.95 209.73,166.95 209.77,166.91 209.77,165.32 209.64,165.19 207.53,165.19 207.36,165.36 207.36,167.07 207.53,167.24 208.55,167.24
GND on TOP (solid shape): 229.54,81.41 229.54,78.19 229.36,78.01 226.49,78.01 226.3,78.2 226.3,78.96 226.47,79.12 226.47,81.34 226.74,81.61 229.34,81.61
GND on TOP (solid shape): 176.03,64.23 176.03,62.58 176.41,62.2 176.41,61.31 176.09,60.99 174.95,60.99 174.7,61.25 174.7,64.1 175.01,64.42 175.01,64.55 175.71,64.55
GND on TOP (solid shape): 181.4,51.83 182.66,50.57 182.66,45.83 182.53,45.7 181.26,45.7 181.16,45.8 181.16,49.69 180.47,50.38 180.47,52.97 180.67,53.18 181.4,53.18
GND on TOP (solid shape): 179.21,40.16 179.21,39.53 179.46,39.28 179.46,35.91 179.27,35.72 177.94,35.72 177.68,35.97 177.68,36.93 178.19,37.43 178.19,40.04 178.44,40.29 179.08,40.29
GND on TOP (solid shape): 45.49,42.09 45.49,40.74 45.34,40.58 43.43,40.58 43.19,40.82 43.19,41.18 43.51,41.5 44.12,41.5 44.78,42.16 45.42,42.16
GND on TOP (solid shape): 159.46,103.72 159.46,103.03 159.4,102.96 158.89,102.96 158.76,102.84 158.76,102.58 158.63,102.46 158.5,102.46 158.45,102.51 158.45,103.72 158.58,103.85 159.34,103.85
GND on TOP (solid shape): 225.5,51.76 225.5,51.48 225.68,51.3 229.79,51.3 230.2,50.9 230.2,50.11 229.99,49.9 224.15,49.9 222.84,51.21 222.84,51.7 223.03,51.89 225.38,51.89
GND on TOP (solid shape): 234.2,50.77 234.2,50.32 234.45,50.07 238.21,50.07 238.27,50.01 238.27,48.95 238.22,48.91 231.87,48.91 231.53,49.24 231.53,50.71 231.72,50.9 234.07,50.9
GND on TOP (solid shape): 242.77,50.77 242.77,50.32 243.02,50.07 247.29,50.07 247.46,49.9 247.46,49.11 247.26,48.91 241.41,48.91 240.1,50.22 240.1,50.71 240.29,50.9 242.64,50.9
GND on TOP (solid shape): 238.98,169.62 238.98,167.13 238.21,166.35 238.21,165.2 237.71,164.7 235.73,164.7 235.59,164.84 235.59,167.27 236.1,167.77 236.1,169.6 236.33,169.83 238.77,169.83
GND on TOP (solid shape): 275.34,55.9 275.34,51.96 274.77,51.39 268.61,51.39 268.42,51.58 268.42,55.01 268.55,55.13 269.5,55.13 269.69,55.32 269.69,56.02 269.95,56.28 274.96,56.28
GND on TOP (solid shape): 173.11,141.77 173.11,136.18 172.53,135.61 170.82,135.61 170.57,135.86 170.57,139.04 170.01,139.59 166.54,139.59 166.4,139.74 166.4,141.87 166.55,142.02 171.33,142.02 171.52,142.21 172.66,142.21
GND on TOP (solid shape): 200.43,183.6 200.75,183.45 201.1,183.4 205.22,183.4 205.22,176.7 199.22,176.7 199.22,183.6
GND on TOP (solid shape): 252.29,50.06 256.03,50.06 256.09,50 256.09,48.97 256.03,48.9 255.47,48.9 251.09,48.9 250.96,49.03 250.96,50.01 251.09,50.13 252.22,50.13
GND on TOP (solid shape): 268.8,33.31 270.01,33.31 270.71,32.61 271.28,32.61 271.47,32.42 271.47,30.44 271.15,30.12 270.21,30.12 268.3,32.04 266.2,32.04 265.88,32.35 265.88,33.81 266.14,34.07 268.04,34.07
GND on TOP (solid shape): 156.47,131.1 156.47,124.34 156.31,124.17 154.12,124.17 153.87,124.43 153.87,128.94 154.44,129.51 154.44,131.29 154.69,131.54 156.03,131.54
GND on TOP (solid shape): 172.86,146.46 172.86,145.83 172.73,145.7 171.96,145.7 171.84,145.57 171.84,145.11 171.73,145.01 168.39,145.01 168.28,145.12 168.28,146.42 168.39,146.53 172.79,146.53
GND on TOP (solid shape): 190.72,179.86 190.72,177.71 190.72,177.7 190.72,177.55 191.02,177.26 191.02,176.94 190.91,176.83 190.57,176.83 190.45,176.96 190.45,177.39 190.31,177.52 190.07,177.52 189.89,177.71 189.89,179.74 190.12,179.96 190.62,179.96
GND on TOP (solid shape): 237.75,57.06 237.75,53.04 237.58,52.87 237.43,52.87 237.43,52.87 231.44,52.87 231.21,53.1 231.21,56.04 231.34,56.17 231.73,56.17 231.73,56.15 232.88,56.15 232.94,56.22 232.94,57.17 233.08,57.31 237.5,57.31
GND on TOP (solid shape): 246.39,56.93 246.39,54.74 246.38,54.73 246.38,54.42 246.39,54.41 246.39,52.94 246.12,52.67 240.07,52.67 239.78,52.96 239.78,56.04 239.9,56.15 241.47,56.15 241.56,56.24 241.56,57.08 241.79,57.31 246.01,57.31
GND on TOP (solid shape): 147.34,114.58 147.34,112.04 146.83,111.54 146.83,108.93 146.7,108.8 146.32,108.8 146.13,109 146.13,109.73 146.14,109.82 146.13,109.91 146.13,111.85 146.26,111.98 146.26,114.58 146.38,114.71 147.21,114.71
GND on TOP (solid shape): 158.32,105.38 158.32,104.11 158.26,104.04 157.24,104.04 157.05,103.85 157.05,102.45 156.92,102.33 156.1,102.33 156.04,102.39 156.04,103.72 156.16,103.85 156.48,103.85 156.54,103.91 156.57,103.91 156.57,103.94 156.73,104.11 156.73,105.44 156.86,105.57 158.13,105.57
GND on TOP (solid shape): 161.88,105.44 161.88,103.03 161.81,102.96 160.86,102.96 160.8,103.03 160.8,103.57 160.81,103.66 160.8,103.75 160.8,103.85 160.61,104.04 160.42,104.04 160.35,104.11 160.35,105.5 160.42,105.57 161.75,105.57
GND on TOP (solid shape): 244.83,100.7 244.83,100.14 244.83,100.13 244.19,100.13 243.93,99.87 243.21,99.87 243.09,99.99 243.09,100.24 243.18,100.32 243.33,100.32 243.36,100.36 243.36,100.72 243.41,100.77 244.76,100.77
GND on TOP (solid shape): 154.7,105.44 154.7,103.75 154.69,103.66 154.7,103.57 154.7,102.3 154.73,102.3 155.08,101.95 155.08,101.57 155.02,101.5 154.13,101.5 154,101.63 154,105.38 154.13,105.5 154.64,105.5
GND on TOP (solid shape): 166.2,103.72 166.2,102.52 166.19,102.52 166.19,102.46 165.87,102.14 165.87,101.86 165.84,101.82 165.46,101.82 165.43,101.86 165.43,102.2 165.62,102.4 165.62,102.45 165.62,102.45 165.62,103.79 165.75,103.92 166.01,103.92
GND on TOP (solid shape): 167.53,114.77 167.53,114.27 167.47,114.2 166.96,114.2 166.77,114.01 166.77,109.76 166.89,109.63 166.89,106.39 166.83,106.33 166.13,106.33 166.01,106.46 166.01,109.69 166.2,109.88 166.2,114.77 166.32,114.9 167.4,114.9
GND on TOP (solid shape): 177.68,52.48 177.68,51.91 177.62,51.85 176.98,51.85 176.44,51.31 176.44,50.42 177.11,49.75 177.49,49.75 177.81,49.44 177.81,47.59 177.3,47.09 177.3,46.51 176.92,46.13 176.92,45.63 176.73,45.43 175.52,45.43 175.01,45.94 175.01,51.66 175.9,52.55 177.62,52.55
GND on TOP (solid shape): 203.15,161.45 203.46,161.45 203.53,161.39 203.53,160.5 203.46,160.43 201.62,160.43 201.3,160.75 201.3,160.93 201.31,160.94 201.33,161.03 201.33,161.13 201.32,161.15 201.68,161.51 201.68,161.77 201.81,161.89 202.7,161.89
GND on TOP (solid shape): 254.66,5.57 254.78,5.61 254.9,5.57 254.93,5.56 255.53,5.56 255.98,5.11 255.98,4.48 255.72,4.22 249.88,4.22 249.69,4.41 249.69,5.3 249.82,5.43 254.45,5.43 254.57,5.56 254.63,5.56
GND on TOP (solid shape): 9.57,66.3 1.27,66.3 1.27,72.1 1.51,72.66 2.07,72.9 9.57,72.9
GND on TOP (solid shape): 254.89,57.05 254.89,55.53 255.47,54.95 255.47,53.25 255.1,52.88 248.55,52.88 248.35,53.08 248.35,53.55 248.36,53.55 248.36,54.69 248.35,54.69 248.35,56.03 248.48,56.16 249.97,56.16 250.16,56.36 250.16,57.14 250.33,57.3 254.64,57.3
GND on TOP (solid shape): 180.15,146.37 180.15,145.23 179.75,144.82 178.38,144.82 178,145.21 176.64,145.21 176.03,144.6 176.03,143.48 175.66,143.11 175.18,143.11 174.51,143.78 174.51,145 174.61,145.1 175.62,145.1 175.95,145.43 175.95,145.93 176.67,146.64 179.88,146.64
GND on TOP (solid shape): 192.23,30.17 192.23,25.42 191.98,25.17 191.95,25.17 191.78,25.22 191.62,25.18 191.6,25.17 191.24,25.17 191.1,25.31 191.1,26.25 190.68,26.68 189.75,26.68 189.57,26.86 189.57,29.98 189.82,30.23 192.17,30.23
GND on TOP (solid shape): 229.12,58.18 229.12,53.67 228.87,53.41 222.61,53.41 222.52,53.51 222.52,57.03 222.65,57.16 223.5,57.16 223.51,57.16 224.22,57.16 224.33,57.27 224.33,58.25 224.49,58.41 228.89,58.41
GND on TOP (solid shape): 139.91,114.58 139.91,108.87 139.78,108.74 139.34,108.74 139.08,109 139.08,109.73 139.09,109.82 139.08,109.91 139.08,111.73 138.83,111.98 138.83,113.22 138.84,113.31 138.83,113.41 138.83,114.58 138.89,114.65 139.84,114.65
GND on TOP (solid shape): 197.16,78.39 197.16,77.06 197.3,76.92 198.35,76.92 198.53,77.1 198.53,77.87 198.61,77.94 199.15,77.94 199.28,77.81 199.28,75.67 199.12,75.51 197.85,75.51 197.34,75 197.34,74.27 197.29,74.23 195.78,74.23 195.66,74.35 195.66,75.19 195.82,75.34 195.82,78.49 196.04,78.72 196.83,78.72
GND on TOP (solid shape): 214.57,171.12 214.57,170.84 214.56,170.76 214.57,170.69 214.57,170.25 214.56,170.18 214.57,170.11 214.57,165.39 214.34,165.16 213.24,165.16 213.01,165.39 213.01,167.51 212.44,168.08 212.44,169.87 212.12,170.19 212.12,171.02 212.43,171.33 214.36,171.33
GND on TOP (solid shape): 234.97,156.41 234.97,156.19 234.96,156.18 234.96,156.01 235.1,155.87 237.61,155.87 237.7,155.78 237.7,155.23 237.75,155.18 237.75,151.42 237.82,151.35 238.58,151.35 238.77,151.54 239.28,151.54 239.4,151.42 239.4,150.97 239.09,150.65 235.72,150.65 235.15,150.08 234.01,150.08 233.87,150.21 233.87,156.51 233.95,156.58 234.8,156.58
GND on TOP (solid shape): 95.26,35.72 95.26,34.96 95.13,34.83 95.13,33.43 95.26,33.31 96.02,33.31 96.08,33.37 96.08,34.64 96.15,34.7 96.53,34.7 96.66,34.58 96.66,31.75 94.5,29.59 90.46,29.59 90.24,29.81 90.24,31.27 90.37,31.4 93.48,31.4 93.73,31.66 93.73,32.8 93.35,33.18 93.35,35.72 93.54,35.91 95.07,35.91
GND on TOP (solid shape): 149.81,114.52 149.81,111.6 149.24,111.03 149.24,108.8 149.18,108.74 148.73,108.74 148.61,108.87 148.61,109.73 148.62,109.82 148.61,109.91 148.61,111.79 148.73,111.92 148.73,113.28 148.75,113.38 148.73,113.47 148.73,114.65 149.69,114.65
GND on TOP (solid shape): 180.55,183.6 180.87,183.45 181.22,183.4 183.27,183.4 184.34,183.4 184.69,183.45 185.01,183.6 186.22,183.6 186.22,176.7 180.22,176.7 180.22,183.6
GND on TOP (solid shape): 144.86,114.58 144.86,111.98 144.48,111.6 144.48,108.8 144.35,108.68 143.91,108.68 143.72,108.87 143.72,109.73 143.73,109.82 143.72,109.91 143.72,111.73 143.78,111.79 143.78,113.22 143.79,113.31 143.78,113.41 143.78,114.58 143.84,114.65 144.8,114.65
GND on TOP (solid shape): 176.28,174.47 176.28,172.24 176.03,171.99 176.03,171.36 175.81,171.13 175.81,170.94 175.83,170.92 175.83,170.19 176.09,169.92 176.09,169.66 176.22,169.53 176.47,169.53 176.53,169.47 176.53,169.28 176.47,169.21 175.89,169.21 175.37,169.74 175.01,169.74 174.56,170.2 174.56,172.96 174.16,173.36 174.16,174.18 174.57,174.59 176.16,174.59
GND on TOP (solid shape): 142.38,114.58 142.38,111.92 142.19,111.73 142.19,108.87 142.13,108.8 141.56,108.8 141.3,109.06 141.3,109.61 141.38,109.82 141.3,110.03 141.3,113.22 141.32,113.31 141.3,113.41 141.3,114.58 141.37,114.65 142.32,114.65
GND on TOP (solid shape): 179.52,174.59 179.52,173.2 180.03,172.69 180.03,171.16 179.65,170.78 178.82,170.78 178.7,170.91 178.7,170.92 178.72,171.03 178.7,171.15 178.7,171.16 178.7,171.28 178.9,171.48 179.14,171.48 179.33,171.67 179.33,172.31 179.21,172.43 178.19,172.43 178.13,172.5 178.13,173.26 178.38,173.51 178.38,174.72 178.51,174.85 179.27,174.85
GND on TOP (solid shape): 273.8,166.54 274.17,166.54 274.22,166.52 274.59,166.15 275.38,166.15 275.49,166.13 275.61,166.12 275.75,165.97 275.75,165.33 275.58,165.16 275.29,165.16 275.29,165.16 273.7,165.16 272.85,166.01 271.99,166.01 271.98,166.02 271.98,167.09 271.98,167.14 271.98,167.14 271.98,167.3 272.09,167.41 272.13,167.43 272.23,167.45 272.28,167.45 272.29,167.46 272.89,167.46
GND on TOP (solid shape): 51.13,37.12 51.13,33.37 49.54,31.78 49.54,31.53 49.03,31.02 47.42,31.02 47.27,31.17 47.27,32.1 47.14,32.23 46.37,32.23 45.7,31.56 45.7,30.55 45.6,30.45 44.78,30.45 44.71,30.51 44.71,32.54 45.28,33.12 46.49,33.12 46.81,33.43 46.81,34.83 47.06,35.08 48.71,35.08 48.84,35.21 48.84,36.29 48.59,36.54 47.63,36.54 47.57,36.61 47.57,37.43 50.81,37.43
GND on TOP (solid shape): 255.84,25.03 255.84,22.92 256.13,22.63 257.44,22.63 257.74,22.33 257.74,20.85 255.17,18.29 252.52,18.29 251.6,19.21 251.6,22.13 251.72,22.26 253.25,22.26 253.5,22 253.5,20.98 253.56,20.91 253.58,20.89 254.85,20.89 254.96,21 254.96,22.3 254.95,22.31 254.95,22.33 254.83,22.45 254.81,22.45 254.55,22.71 254.55,24.91 254.83,25.19 255.67,25.19
GND on TOP (solid shape): 155.28,145.51 156.03,145.51 156.14,145.4 156.14,145.09 156.21,145.02 156.21,143.74 156.28,143.66 156.28,143.35 156.16,143.22 156.16,142.65 156.73,142.08 156.73,137.7 156.6,137.57 154.57,137.57 154.38,137.76 154.38,139.41 154.44,139.48 154.44,139.48 154.5,139.54 154.5,142.08 153.61,142.97 149.48,142.97 149.29,143.16 149.29,144.18 149.42,144.31 150.12,144.31 150.3,144.49 150.3,145.12 150.42,145.24 150.99,145.24 151.11,145.36 151.11,145.87 151.21,145.97 154.83,145.97
GND on TOP (solid shape): 179.96,142.15 179.99,142.12 180.01,142.1 180.24,141.88 180.26,141.83 180.29,141.78 180.29,141.13 180.16,141 180.16,140.43 180.29,140.3 180.54,140.3 180.73,140.11 180.73,138.97 181.36,138.34 181.36,135.73 180.79,135.16 179.14,135.16 178.82,135.48 178.82,139.04 178.19,139.67 173.8,139.67 173.61,139.86 173.61,140.88 173.74,141.01 174.44,141.01 174.66,141.23 174.66,141.74 174.85,141.93 175.31,141.93 175.42,142.04 175.42,142.5 175.61,142.69 179.42,142.69
GND on TOP (solid shape): 161.69,115.35 161.69,115.12 161.69,115.09 161.62,115.03 161.62,112.36 161.69,112.3 162.07,112.3 162.26,112.11 162.26,109.57 161.93,109.23 161.93,108.36 161.83,108.26 160.97,108.26 160.81,108.41 160.81,109.3 160.54,109.57 160.54,113.67 160.56,113.76 160.54,113.85 160.54,115.03 160.48,115.09 160.48,115.12 160.45,115.12 160.29,115.28 160.29,115.47 160.42,115.6 161.43,115.6
GND on TOP (solid shape): 163.91,115.41 163.91,115.15 164.17,114.89 164.37,114.89 164.48,114.78 164.48,112.61 164.48,112.61 164.48,112.46 164.23,112.21 164.23,108.55 163.97,108.3 163.27,108.3 163.21,108.36 163.21,108.4 163.22,108.48 163.21,108.58 163.21,112.23 162.96,112.49 162.96,113.67 162.97,113.76 162.96,113.85 162.96,115.09 162.7,115.35 162.7,115.47 162.77,115.54 163.78,115.54
GND on TOP (solid shape): 264.99,171.36 264.99,170.47 265.57,169.89 265.57,167.29 265.06,166.78 264.3,166.78 264.17,166.66 264.17,164.31 264.61,163.86 265.57,163.86 266.9,165.2 268.74,165.2 268.99,164.94 268.99,161.96 268.42,161.39 266.45,161.39 266.2,161.13 266.2,157.96 266.07,157.83 263.47,157.83 262.33,158.97 262.33,162.27 262.64,162.59 262.64,165.01 262.33,165.32 262.33,171.23 262.58,171.48 264.87,171.48
GND on TOP (solid shape): 64.84,26.51 67.89,26.51 68.3,26.1 68.3,24.96 68.14,24.8 65.86,24.8 65.35,24.29 65.35,22.13 65.29,22.07 64.4,22.07 63.95,21.62 63.45,21.62 63.32,21.75 63.32,23.65 62.94,24.04 62.05,24.04 61.6,24.48 61.35,24.48 61.22,24.61 61.23,24.64 61.24,24.8 61.16,24.94 61.16,26.37 61.19,26.38 61.3,26.47 61.37,26.6 61.38,26.64 64.72,26.64
GND on TOP (solid shape): 163.42,146.43 163.42,145.45 162.99,145.02 160.66,145.02 160.65,145.03 159.68,145.03 159.5,144.85 158.79,144.85 158.61,144.68 158.61,143.95 158.71,143.85 158.87,143.85 159.02,143.7 159.02,143.5 158.82,143.29 158.28,143.29 157.75,143.83 157.75,144.53 157.74,144.53 157.74,145.36 157.82,145.44 158.8,145.44 158.86,145.5 159.08,145.69 159.07,145.99 159.07,146.22 159.57,146.72 163.13,146.72
GND on TOP (solid shape): 265.58,10 268.22,10 270.69,8.97 271.72,6.5 271.72,3.2 258.56,3.2 258.56,10.01 265.58,10.01
GND on TOP (solid shape): 148.41,149.77 148.41,149.19 148.28,149.07 147.64,149.07 147.45,148.88 147.45,148.28 147.34,148.17 145.95,148.17 145.91,148.21 145.91,148.67 145.77,148.81 144.74,148.81 144.63,148.7 144.63,147.5 144.32,147.2 143.31,147.2 143.14,147.03 143.14,146.83 142.88,146.56 142.23,146.56 141.85,146.94 141.85,148.23 141.98,148.36 142.76,148.36 143.04,148.64 143.07,148.65 143.12,148.68 143.17,148.71 143.27,148.81 143.27,148.86 143.28,148.92 143.29,148.98 143.29,149.51 143.73,149.96 148.22,149.96
GND on TOP (solid shape): 151.84,106.74 151.84,106.42 151.78,106.36 151.46,106.36 151.34,106.23 151.34,106.22 151.32,106.21 151.26,106.01 151.32,105.81 151.34,105.8 151.34,105.79 151.46,105.66 151.72,105.66 151.84,105.53 151.84,105.15 151.78,105.09 151.46,105.09 151.34,104.96 151.34,104.95 151.32,104.94 151.26,104.75 151.31,104.56 151.34,104.52 151.27,104.46 150.77,104.46 150.7,104.52 150.7,106.87 150.77,106.93 151.65,106.93
GND on TOP (solid shape): 154.58,115.41 154.58,115.28 154.38,115.09 154.38,112.42 154.51,112.3 154.83,112.3 155.02,112.11 155.02,109.6 154.64,109.22 154.64,108.37 154.51,108.24 154.24,108.24 154.11,108.37 154.11,109.34 154.19,109.42 154.27,109.63 154.19,109.84 154.19,109.99 154.27,110.2 154.19,110.41 154.19,110.46 153.81,110.84 153.81,115.41 153.94,115.54 154.45,115.54
GND on TOP (solid shape): 33.17,13.78 33.17,12.26 33.3,12.13 34.38,12.13 34.5,12.26 34.5,13.72 34.57,13.78 35.08,13.78 35.14,13.72 35.14,12.26 35.27,12.13 36.35,12.13 36.35,7.49 36.09,7.49 35.96,7.37 35.96,5.84 35.9,5.78 35.44,5.78 35.33,5.89 35.33,7.37 35.2,7.49 32.98,7.49 32.79,7.3 32.79,5.88 32.69,5.78 32.22,5.78 32.15,5.84 32.15,7.11 31.77,7.49 31.77,10.03 31.5,10.31 30.1,10.31 30.05,10.36 30.05,10.86 30.12,10.93 31.59,10.93 31.77,11.11 31.77,12.13 32.79,12.13 32.92,12.26 32.92,13.78 32.98,13.84 33.11,13.84
GND on TOP (solid shape): 140.35,106.71 140.35,106.39 140.29,106.33 140.25,106.33 140.16,106.34 140.07,106.33 139.97,106.33 139.84,106.2 139.84,106.1 139.83,106.01 139.84,105.92 139.84,105.76 139.97,105.63 140.22,105.63 140.35,105.5 140.35,105.12 140.29,105.06 140.25,105.06 140.16,105.07 140.07,105.06 139.97,105.06 139.84,104.93 139.84,104.83 139.83,104.74 139.84,104.65 139.84,104.49 139.78,104.42 139.27,104.42 139.21,104.49 139.21,106.84 139.27,106.9 140.16,106.9
GND on TOP (solid shape): 165.48,105.9 165.49,105.84 165.5,105.79 165.5,104.58 165.49,104.53 165.48,104.47 165.31,104.3 164.8,104.3 164.46,103.96 164.45,103.95 164.37,103.9 164.31,103.81 164.27,103.76 164.27,102.41 164.25,102.39 163.85,102.39 163.78,102.46 163.75,102.53 163.72,102.59 163.72,102.71 163.59,102.84 163.4,102.84 163.21,103.03 163.21,103.72 163.34,103.85 163.66,103.85 163.91,104.11 163.91,105.88 164.1,106.07 165.31,106.07
GND on TOP (solid shape): 233.07,92.73 233.07,91.11 232.97,91 232.25,91 232.25,90.92 232.11,90.77 231.86,90.77 231.72,90.91 231.72,91.22 231.59,91.35 230.96,91.35 230.83,91.22 230.83,90.52 231.09,90.27 231.09,89.63 230.58,89.12 228.8,89.12 228.74,89.19 228.74,89.82 228.8,89.88 229.24,89.88 229.38,90.02 229.38,90.43 229.47,90.52 229.47,91.82 229.6,91.94 229.98,91.94 230.16,91.76 230.44,91.76 230.62,91.95 231.03,91.95 231.23,91.75 231.45,91.75 231.46,91.77 231.48,91.77 231.66,91.95 232.07,91.95 232.23,92.11 232.23,92.74 232.25,92.77 233.03,92.77
GND on TOP (solid shape): 142.64,106.74 142.64,106.42 142.59,106.38 142.55,106.39 142.42,106.4 142.29,106.37 142.28,106.36 142.26,106.36 142.13,106.23 142.13,106.17 142.12,106.07 142.13,105.98 142.13,105.79 142.26,105.66 142.51,105.66 142.64,105.53 142.64,105.15 142.59,105.11 142.55,105.12 142.42,105.13 142.29,105.1 142.28,105.09 142.26,105.09 142.13,104.96 142.13,104.9 142.12,104.8 142.13,104.71 142.13,104.52 142.07,104.46 141.56,104.46 141.49,104.52 141.49,106.87 141.56,106.93 142.45,106.93
GND on TOP (solid shape): 147.21,106.74 147.21,106.42 147.16,106.38 147.12,106.39 146.99,106.4 146.87,106.37 146.85,106.36 146.83,106.36 146.7,106.23 146.7,106.17 146.69,106.07 146.7,105.98 146.7,105.79 146.83,105.66 147.08,105.66 147.21,105.53 147.21,105.15 147.16,105.11 147.12,105.12 146.99,105.13 146.87,105.1 146.85,105.09 146.83,105.09 146.7,104.96 146.7,104.9 146.69,104.8 146.7,104.71 146.7,104.52 146.64,104.46 146.13,104.46 146.07,104.52 146.07,106.87 146.13,106.93 147.02,106.93
GND on TOP (solid shape): 149.56,106.74 149.56,106.42 149.51,106.38 149.47,106.39 149.34,106.4 149.21,106.37 149.2,106.36 149.18,106.36 149.05,106.23 149.05,106.17 149.04,106.07 149.05,105.98 149.05,105.79 149.18,105.66 149.43,105.66 149.56,105.53 149.56,105.15 149.51,105.11 149.47,105.12 149.34,105.13 149.21,105.1 149.2,105.09 149.18,105.09 149.05,104.96 149.05,104.9 149.04,104.8 149.05,104.71 149.05,104.52 148.99,104.46 148.48,104.46 148.42,104.52 148.42,106.87 148.48,106.93 149.37,106.93
GND on TOP (solid shape): 185.3,145.19 185.3,144.68 185.24,144.62 184.6,144.62 184.22,144.24 184.22,142.78 184.35,142.65 184.35,141.77 184.29,141.7 184.29,141.63 184.29,140.2 183.88,139.8 182.28,139.8 182.16,139.68 182.16,138.69 182.27,138.59 186.19,138.59 186.2,138.58 188.13,138.58 188.25,138.46 188.25,137.29 187.7,136.75 182.38,136.75 181.62,137.51 181.62,138.4 181.11,138.91 181.11,139.61 181.78,140.27 182.41,140.27 182.57,140.43 182.57,141.26 182.44,141.38 181.94,141.38 181.74,141.58 181.74,142.97 181.81,143.04 182.38,143.04 182.76,143.42 182.76,144.24 182.89,144.37 183.58,144.37 183.65,144.43 183.78,144.56 183.78,144.56 183.78,145.19 183.84,145.26 185.24,145.26
GND on TOP (solid shape): 289.29,60.9 289.29,60.16 289.06,59.93 289.06,59.85 289.06,58.78 288.87,58.59 288.41,58.59 288.29,58.72 288.29,59.05 288.24,59.1 287.45,59.1 287.28,58.93 287.28,54.13 287.03,53.88 287.03,53.25 286.97,53.18 286.39,53.18 286.33,53.25 286.33,53.82 286.08,54.07 284.62,54.07 283.92,53.37 283.41,53.37 283.28,53.5 283.28,54.9 283.57,55.19 283.59,55.19 283.59,55.2 283.73,55.34 283.73,55.91 283.48,56.16 283.35,56.16 283.32,56.19 283.32,57.02 283.13,57.21 283.13,57.83 282.84,58.12 282.84,60.36 283,60.51 283.36,60.51 283.55,60.33 283.88,60.33 283.88,60.33 284.4,60.33 284.89,59.84 287.82,59.84 288.24,60.26 288.24,60.64 288.55,60.96 289.23,60.96
GND on TOP (solid shape): 16.58,31.97 16.58,30.58 14.75,28.74 1.27,28.74 1.27,30.1 1.51,30.66 2.07,30.9 11.68,30.9 12.45,30.4 13.05,31.1 13.05,31.85 13.37,32.16 16.39,32.16
GND on TOP (solid shape): 156.51,149.72 156.51,148.5 156.32,148.31 155.77,148.31 155.6,148.13 154.19,148.13 154.1,148.23 154.1,148.71 154.01,148.8 152.81,148.8 152.64,148.63 152.64,147.41 152.43,147.21 151.71,147.21 151.71,146.59 151.52,146.4 150.63,146.4 150.25,146.78 150.25,148.18 150.31,148.24 151.02,148.24 151.24,148.46 151.24,148.62 151.27,148.65 151.4,148.68 151.52,148.76 151.57,148.81 151.57,148.82 151.62,149.01 151.57,149.19 151.57,149.32 151.67,149.42 151.84,149.5 151.93,149.68 152.39,150.14 156.09,150.14
GND on TOP (solid shape): 144.92,106.74 144.92,106.42 144.86,106.36 144.84,106.36 144.42,106.3 144.4,105.88 144.42,105.86 144.42,105.79 144.54,105.66 144.8,105.66 144.92,105.53 144.92,105.15 144.86,105.09 144.84,105.09 144.42,105.03 144.4,104.61 144.42,104.59 144.42,104.52 144.35,104.46 143.84,104.46 143.78,104.52 143.78,106.87 143.84,106.93 144.73,106.93
GND on TOP (solid shape): 240.61,104.73 240.61,103.08 240.47,102.93 240.44,102.91 240.42,102.88 240.36,102.88 240.36,102.86 240.29,102.8 240.29,102.42 240.37,102.34 240.39,102.34 240.56,102.17 240.56,102.02 240.45,101.91 240.42,101.88 240.36,101.88 240.32,101.84 240.32,101.38 240.35,101.34 240.35,101.33 240.37,101.32 240.41,101.32 240.57,101.16 240.61,101.12 240.61,96.17 241.56,95.22 241.56,95.02 241.42,94.88 241.27,94.88 241.25,94.88 241.18,94.81 241.18,94.43 240.99,94.24 240.99,92.63 240.78,92.42 240.39,92.42 240.38,92.44 240.38,92.81 240.28,92.91 239.96,92.91 239.67,93.2 239.67,95.27 239.08,95.86 239.08,101.09 238.89,101.28 238.89,103.09 239.68,103.88 239.68,104.81 239.69,104.82 240.53,104.82
GND on TOP (solid shape): 127.62,144.91 127.7,144.9 127.79,144.91 128.74,144.91 128.79,144.86 128.79,142.64 128.67,142.53 128.09,142.53 128.02,142.46 128.02,141.51 128.15,141.38 128.66,141.38 128.72,141.32 128.72,140.88 128.6,140.75 128.15,140.75 128.02,140.62 128.02,139.8 128.38,139.44 129.14,139.44 129.29,139.29 129.99,139.29 130.12,139.16 130.12,138.59 129.68,138.14 125.8,138.14 125.5,137.84 125.39,137.77 125.32,137.67 125.04,137.38 124.09,137.38 124.02,137.45 124.02,138.97 124.31,139.26 124.31,140.98 124.22,141.07 123.72,141.07 123.61,141.18 123.61,141.86 123.39,142.08 122.94,142.08 122.75,142.27 122.75,142.84 122.88,142.97 124.21,142.97 124.26,143.02 124.26,143.15 124.41,143.29 124.6,143.29 124.7,143.19 124.7,143.06 124.91,142.85 125.68,142.85 126.12,143.29 127.14,143.29 127.33,143.48 127.33,144.89 127.35,144.91
GND on TOP (solid shape): 152.23,114.58 152.23,113.19 152.48,112.93 152.48,111.34 152.35,111.22 152.35,107.73 152.23,107.6 151.65,107.6 151.59,107.66 151.59,107.7 151.6,107.79 151.59,107.88 151.59,107.98 151.4,108.17 151.15,108.17 151.02,108.3 151.02,108.55 151.08,108.61 151.4,108.61 151.59,108.8 151.59,108.97 151.6,109.06 151.59,109.15 151.59,109.25 151.46,109.38 151.37,109.38 151.27,109.39 151.18,109.38 151.15,109.38 151.02,109.5 151.02,109.82 151.15,109.95 151.46,109.95 151.59,110.07 151.59,110.3 151.6,110.39 151.59,110.49 151.59,110.58 151.4,110.77 151.15,110.77 151.02,110.9 151.02,111.09 151.15,111.22 151.15,111.63 151.16,111.73 151.15,111.82 151.15,114.58 151.21,114.65 152.16,114.65
GND on TOP (solid shape): 143.35,145.92 143.66,145.92 143.72,145.94 143.75,145.95 143.83,145.95 143.86,145.94 143.92,145.92 144.31,145.92 144.37,145.94 144.4,145.95 144.48,145.95 144.51,145.94 144.57,145.92 144.96,145.92 145.01,145.94 145.04,145.95 145.13,145.95 145.16,145.94 145.21,145.92 145.61,145.92 145.66,145.94 145.69,145.95 145.78,145.95 145.81,145.94 145.86,145.92 146.57,145.92 146.78,145.71 147.96,145.71 148.04,145.63 148.08,145.57 148.14,145.52 148.66,145.01 148.66,139.42 148.09,138.85 146.37,138.85 146.12,139.1 146.12,142.28 145.48,142.91 141.1,142.91 140.91,143.1 140.91,144.12 141.04,144.24 141.74,144.24 141.92,144.42 141.92,145.09 142.02,145.19 142.61,145.19 142.68,145.26 142.68,145.86 142.77,145.95 143.32,145.95
GND on TOP (solid shape): 164.54,143.04 164.44,142.69 164.69,142.44 164.72,142.43 164.72,142.4 165.01,142.12 165.01,136.53 164.6,136.12 163.44,136.12 162.99,135.67 162.44,135.67 162.18,135.93 162.18,135.97 161.9,136.26 161.9,139.16 161.32,139.74 157.17,139.74 156.98,139.93 156.98,140.94 157.1,141.07 157.8,141.07 157.92,141.18 157.92,141.78 158.05,141.91 158.57,141.91 158.72,142.06 158.72,142.53 158.9,142.71 159.37,142.71 159.75,142.71 159.86,142.71 160.4,142.71 160.51,142.71 161.04,142.71 161.16,142.71 161.69,142.71 161.81,142.71 162.34,142.71 162.61,142.44 162.61,140.67 162.75,140.53 163.6,140.53 163.83,140.76 163.83,143.06 163.89,143.12 164.45,143.12
GND on TOP (solid shape): 9.57,47.5 1.31,47.5 1.6,47.9 2.07,48.05 2.27,48.05 3.12,48.4 3.47,49.25 3.47,51.75 3.12,52.6 2.27,52.95 2.07,52.95 1.51,53.19 1.27,53.75 1.27,54.3 9.57,54.3
GND on TOP (solid shape): 159.21,115.54 159.21,112.49 159.08,112.36 158.96,112.36 158.91,112.36 158.77,112.21 158.77,109.44 158.89,109.31 159.4,109.31 159.53,109.19 159.53,108.72 159.53,108.58 159.52,108.51 159.52,108.45 159.52,108.42 159.4,108.3 158.58,108.3 158.4,108.47 158.39,108.54 158.39,108.58 158.39,109.25 158.26,109.38 157.18,109.38 157.05,109.25 157.05,108.36 156.99,108.3 156.1,108.3 155.98,108.42 155.98,108.45 155.98,108.51 155.97,108.58 155.97,109.19 156.04,109.25 156.67,109.25 156.8,109.38 156.8,110.52 156.92,110.65 156.92,112.11 156.54,112.49 155.72,112.49 155.72,113.67 155.73,113.76 155.72,113.85 155.72,114.96 155.78,115.03 155.87,115.03 156.16,115.03 156.35,115.22 156.35,115.47 156.48,115.6 156.73,115.6 156.83,115.5 156.83,113.54 156.8,113.5 156.8,112.46 156.89,112.36 158.05,112.36 158.13,112.45 158.13,113.67 158.14,113.76 158.13,113.85 158.13,115.09 157.94,115.28 157.94,115.47 158.07,115.6 158.48,115.6 158.48,115.6 159.15,115.6
