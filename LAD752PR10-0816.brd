# Allegro board LAD752PR10-0816.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
EC_TX: length 69.7
  TOP w0.107: v1(294.84,10.95) 294.94,11.06 294.94,17.93 294.46,18.41 294.46,22.31 293.94,22.83 UE5.30 293.94,24.85 294.64,25.55 294.64,27.39 292.49,29.53 v4(292.49,31.87) 292.49,33.91 290.31,36.1 v1(290.31,36.86) ; RM31.1 309.55,42.23 v1(309.57,42.26)
  IN1 w0.097: v1(290.31,36.86) 291.07,37.62 296.3,37.62 299.84,41.17 299.84,42.18 301.51,43.85 305.95,43.85 307.54,42.26 v1(309.57,42.26)
  BOTTOM w0.107: v1(294.84,10.95) 294.31,10.43 292.01,10.43 290.84,9.25 286.31,9.25 285.12,8.06 283.78,8.06 283.45,8.38 283.45,10.7 283.69,10.94 JEC.6 ; v1(309.57,42.26) JWLAN.30
ECAGND: length 251.8
  TOP w0.254: v1(153.94,109.63) 153.81,109.5 PH1.2 ; v1(280.17,27.02) 280.27,26.92 v2(280.27,26.32) 280.29,26.3 280.29,19.48 284.93,14.84 v1(284.93,12.41) 284.93,12.1 285.19,11.84 287.98,11.84 288.36,11.46 CE33.2 288.36,10.81 288.71,10.46 288.71,10.27 CE35.1 288.86,9.87 LE2.2
  IN1 w0.254: v1(294.76,9.44) 293.85,10.35 292.37,10.35 292.15,10.13 288.83,10.13 287.09,11.87 285.48,11.87 v1(284.93,12.41)
  IN2 w0.254: v1(280.17,27.02) 279.79,27.02 277.19,29.62 270.06,29.62 269.47,30.21 269.47,31.33 263.8,36.99 240.5,36.99 239.57,37.92 237.39,37.92 236.62,38.7 228.91,38.7 227.95,39.66 227.24,39.66 226.79,39.21 224.4,39.21 223.12,40.49 217.81,40.49 216.95,41.35 216.15,41.35 215.9,41.1 214.52,41.1 214.21,40.79 213.41,40.79 213.07,41.12 211.19,41.12 209.93,42.38 208.03,42.38 207.53,41.88 206.1,41.88 206.06,41.92 205.69,41.92 205.65,41.88 205.62,41.88 205.52,41.78 205.47,41.78 205.12,41.43 205.07,41.43 205.05,41.42 204.5,41.42 204.49,41.43 203.09,41.43 203.07,41.42 202.53,41.42 202.51,41.43 202.34,41.6 202.29,41.6 202.15,41.74 199.28,41.74 198.22,40.67 184.48,40.67 177.18,33.37 156.16,33.37 v1(155.9,33.62)
  IN3 w0.254: v1(153.94,109.63) 153.88,109.57 153.88,103.16 152.85,102.14 152.85,99.66 153.93,98.58 153.93,69.37 158.25,65.06 158.25,59.36 158.63,58.98 158.63,53.25 156.51,51.13 156.51,46.17 155.98,45.64 155.98,40.91 156.22,40.67 156.22,38.32 155.9,38.01 v1(155.9,33.62)
EDP_AUX#_C: length 21.2
  TOP w0.089: JEDP.14 158.12,179.86 158,179.74 158,178.61 156.15,176.76 156.15,176.07 155.24,175.16 155.24,172.83 153.93,171.52 153.93,170.53 154.25,170.21 156.31,170.21 156.77,169.75 v3(156.77,169.13) 156.77,168.86 156.28,168.37 152.35,168.37 151.98,168 151.98,167.76 CV13.1
EDP_AUX_C: length 21.1
  TOP w0.089: CV12.1 151.71,167.71 151.71,168.12 152.23,168.64 v3(155.39,168.64) 156.17,168.64 156.5,168.97 156.5,169.64 156.2,169.94 154.14,169.94 153.66,170.42 153.66,171.63 154.97,172.94 154.97,175.28 155.88,176.18 155.88,176.87 157.73,178.72 157.73,179.72 157.62,179.83 JEDP.13
EDP_HPD: length 296.1
  TOP w0.089: RH657.1 218.13,38.32 v1(217.5,37.69)
  TOP w0.107: v1(159.36,179.42) 159.12,179.65 JEDP.16
  IN1 w0.097: v1(217.5,37.69) 217.46,37.72 217.46,39.24 217.98,39.76 217.98,41.52 217.42,42.08 217.42,46.41 214.63,49.2 214.63,51.93 209.8,56.76 v1(206.56,56.76)
  IN2 w0.089: 221.71,78.66 219.68,80.69 218.55,80.69 217.76,81.48 217.76,82.33 215.65,84.44
  IN2 w0.091: 221.71,78.66 222.69,77.68 225.03,77.68 225.73,76.99 v1(229.52,76.99) ; 215.65,84.44 214.45,85.64 214.45,87.87 214.17,88.14 212.77,88.14 210.41,85.78 210.41,84.62 209.98,84.18 209.98,75.52 206.88,72.42 206.88,71.72 v1(207.32,71.28)
  IN3 w0.091: v1(187.14,66.26) 186.52,66.26 185.92,66.86 185.92,69.04 186.02,69.14 186.02,71.46 186.34,71.78 186.34,73.56 187.04,74.26 187.04,86.47 188.86,88.3 189.65,88.3 192.25,90.9 197.49,90.9 198.19,91.6 199.53,91.6 200.35,92.42 202.32,92.42 203.01,93.12 203.01,97.15 199.67,100.5 199.67,105.78 194.57,110.87 194.57,111.64 193.66,112.55 192.14,112.55 191.08,113.61 v1(191.08,114.54) 191.08,115.22 195.26,119.4 195.26,149.03 193.4,150.88 193.4,159.96 194.76,161.32 194.76,163.04 195.21,163.48 196.22,163.48 197.87,165.13 197.87,167.1 197.61,167.37 197.61,169.82 197.35,170.07 193.25,170.07 192.6,170.72 191.59,170.72 190.83,169.96 187.27,169.96 185.94,171.29 184.6,171.29 184.22,171.67 178.63,171.67 178.47,171.51 178.47,170.49 175.3,167.32 175.3,166.31 174.7,165.7 172.35,165.7 171.15,164.51 170.72,164.51 170.66,164.45 169.98,164.45 169.36,165.07 169.36,165.75 168.33,166.78 166.27,166.78 165.36,167.69 165.36,170.4 165.15,170.61 163.56,170.61 163.08,171.1 163.08,173.39 161.24,175.23 161.24,177.54 v1(159.36,179.42) ; v1(207.32,71.28) 206.37,70.33 206.37,62.21 207.1,61.48 207.1,60.07 207.08,60.05 207.08,57.29 v1(206.56,56.76)
  BOTTOM w0.107: v1(187.14,66.26) 187.78,65.62 192.72,65.62 196.78,61.56 201.28,61.56 204.99,57.85 204.99,56.53 205.22,56.29 206.09,56.29 v1(206.56,56.76) ; v1(229.52,76.99) 229.52,76.94 RG28.1 ; UV21.44 v1(191.08,114.54)
EDP_HPD_CPU: length 102.8
  TOP w0.089: v1(218.9,39.66) 218.89,39.66 218.89,39.66 218.98,39.57 RH656.1
  TOP w0.107: v1(184.1,116.94) 183.69,116.53 183.69,106.71 184.77,105.63 184.77,97.43 189.7,92.5 189.7,87.34 188.33,85.97 188.33,71.61 189.3,70.64 v2(189.3,68.99) 189.3,68.26 v1(188.99,67.95)
  IN1 w0.089: v1(218.9,39.66) 218.9,41.17 218,42.07 218,42.08
  IN1 w0.097: 218,42.08 217.91,42.17 217.91,42.17 217.87,42.21 217.87,42.27 217.86,42.27 217.86,46.6 215.08,49.38 215.08,52.54 209.7,57.92 206.23,57.92 205.98,57.67 205.98,56.95 v1(206,56.93)
  BOTTOM w0.107: v1(188.99,67.95) 190.72,67.95 196.87,61.8 201.38,61.8 205.36,57.81 205.36,57.56 v1(206,56.93) ; UV21.13 v1(184.1,116.94)
EDP_HPD_GPU: length 106.2
  IN2 w0.091: v1(206.7,60.23) 206.41,60.23 205.14,61.5 197.55,61.5 189.18,69.87 188.5,69.87 187.46,70.9 187.46,72.53 187.09,72.9 187.09,92.72 185.05,94.76 185.05,98.89 183.07,100.87 183.07,106.36 182.2,107.24 182.2,109.11 183.07,109.99 183.07,110.56 184.1,111.58 v1(184.1,112.68)
  IN3 w0.091: v1(207.32,71.91) 206.11,70.7 206.11,62.16 206.86,61.41 206.86,60.39 v1(206.7,60.23)
  IN4 w0.097: v1(214.99,74.28) 214.88,74.16 208.01,74.16 207.32,73.47 v1(207.32,71.91)
  BOTTOM w0.107: RG29.1 227.29,75.66 220.46,75.66 219.64,76.48 216.42,76.48 214.99,75.05 v1(214.99,74.28) ; UV21.3 184.35,112.94 v1(184.1,112.68)
EDP_MUX_PD: length 119.2
  IN2 w0.091: v1(200.35,72.93) 200.52,73.1 200.52,77.23 200.79,77.51 200.79,89.86 200.15,90.5 200.15,91.95 200.5,92.31 200.5,95.96 200.37,96.09 200.37,108.72 v1(200.15,108.94)
  IN3 w0.089: 198.96,42.08 198.96,39.81 199.3,39.47 200.48,39.47 201.11,38.83 201.11,37.56 201.61,37.07 201.61,34.31 201.36,34.07 201.36,32.29 200.62,31.55 200.62,28.71 201.25,28.08 201.25,24.34 201.78,23.81 202.42,23.81 203.23,23.01 204.17,23.01 205.1,22.08 208.14,22.08 208.34,21.89 208.34,21.19 208.54,20.99 208.54,20.57 208.83,20.28 208.83,19.81 209.01,19.63 209.41,19.63 210.04,19.01 210.57,19.01 210.84,19.27 v1(212.29,19.27)
  IN3 w0.091: 198.96,42.08 198.96,48.42 197.32,50.05 197.32,51.26 193.99,54.6 193.99,56.21 194.54,56.76 194.54,58.55 193.99,59.11 193.99,67.97 195.08,69.06 196.1,69.06 196.41,69.37 196.41,71.19 196.89,71.66 198.5,71.66 199.77,72.93 v1(200.35,72.93)
  BOTTOM w0.089: UH1.AU43 212.49,19.08 v1(212.29,19.27)
  BOTTOM w0.107: v1(200.15,108.94) 197.4,108.94 196.17,107.71 193.29,107.71 RV658.1 192.41,107.47 191.97,107.03 QV95.2
EDP_RCOMP: length 9.2
  BOTTOM w0.152: CPU1.D37 171,119.58 171.28,119.85 171.28,120.43 171.42,120.57 172.11,120.57 172.54,121
  BOTTOM w0.508: 172.54,121 173.05,121.51 174.89,121.51 176.2,122.82 v2(176.2,123.58) RC30.1
EDP_SW: length 218.2
  TOP w0.107: UE5.98 305.51,10.21 305.34,10.38 302.77,10.38 301.25,11.9 v1(301.25,13.68)
  IN2 w0.091: v1(194.89,66.45) 191.71,69.63 191.71,70.75 188.84,73.63 188.84,88.4 v1(189.18,88.74) 189.18,92.91 187.01,95.08 187.01,103.32 188.16,104.46 v1(188.16,110.46)
  IN3 w0.089: v1(213.11,19.78) 212.67,20.23 212.67,20.96 212.32,21.32 211.9,21.32 210.71,22.51 210.39,22.51 209.8,23.1 209.8,24.24 209.37,24.67 208.74,24.67 208.34,25.07 206.67,25.07 205.49,23.89 205.11,23.89 204.04,24.96 203.03,24.96 202.42,25.56 202.32,25.66 202.32,30.06 202.92,30.66 202.92,31.81 203.64,32.54 203.64,39.45 201.01,42.08
  IN3 w0.091: 201.01,42.08 200.65,42.45 200.65,50.29 201.34,50.98 201.34,57.81 198.41,60.74 196.63,60.74 195.53,61.84 195.53,65.82 v1(194.89,66.45)
  IN4 w0.089: v1(213.11,19.78) 213.11,18.57 213.94,17.75 215.77,17.75 216.54,16.98 218.71,16.98 219.18,16.51
  IN4 w0.097: 219.18,16.51 219.24,16.45 226.71,16.45 227.44,17.18 236.19,17.18 237.81,15.56 240.16,15.56 240.46,15.26 241.98,15.26 243.77,13.46 246.19,13.46 246.66,12.99 250.5,12.99 250.72,12.77 264.52,12.77 267.79,16.04 292.17,16.04 293.22,14.99 294.29,14.99 296,13.28 300.85,13.28 v1(301.25,13.68)
  BOTTOM w0.089: v1(213.11,19.78) 213.11,19.53 212.73,19.14 212.73,18.44 UH1.AV44
  BOTTOM w0.107: UV21.54 188.19,110.49 v1(188.16,110.46) ; RV659.1 v1(189.18,88.74) 189.25,88.82 UV22.1
EDP_TX0#_C: length 14.9
  TOP w0.089: JEDP.2 152.12,179.64 151.96,179.48 151.96,178.98 151.34,178.35 151.34,175.11 150.44,174.2 150.44,171.86 149.39,170.81 149.39,169.92 148.99,169.53 148.99,169.08 147.58,167.67 147.58,167.39 CV2.1
EDP_TX0_C: length 14.9
  TOP w0.089: JEDP.1 151.62,179.58 151.68,179.51 151.68,179.08 151.07,178.46 151.07,175.22 150.17,174.32 150.17,171.97 149.12,170.93 149.12,170.04 148.73,169.64 148.73,169.2 v3(147.68,168.15) 147.31,167.78 147.31,167.5 CV1.1
EDP_TX1#_C: length 14.7
  TOP w0.089: JEDP.5 153.62,179.62 153.45,179.44 153.45,179.12 152.09,177.77 152.09,174.92 151.14,173.97 151.14,171.61 150.05,170.52 150.05,169.57 149.66,169.18 149.66,168.81 v3(149.31,168.46) 148.92,168.07 148.92,167.71 CV4.1
EDP_TX1_C: length 14.7
  TOP w0.089: JEDP.4 153.12,179.58 153.18,179.52 153.18,179.23 151.82,177.88 151.82,175.03 150.87,174.08 150.87,171.72 149.79,170.64 149.79,169.68 149.39,169.29 149.39,168.92 148.65,168.18 148.65,167.77 148.46,167.58 CV3.1
EDP_TX2#_C: length 14.8
  TOP w0.089: CV6.1 150.2,167.69 150.2,167.82 150.61,168.22 150.61,168.51 151.03,168.93 151.03,170.49 153.81,173.27 153.81,177.45 155.03,178.67 155.03,179.56 155.12,179.66 JEDP.8
EDP_TX2_C: length 14.9
  TOP w0.089: JEDP.7 154.62,179.68 154.76,179.55 154.76,178.78 153.54,177.56 153.54,173.38 150.76,170.6 150.76,169.04 150.34,168.62 150.34,168.34 149.94,167.93 149.94,167.84 CV8.1
EDP_TX3#_C: length 16.5
  TOP w0.089: CV11.1 151.12,166.19 151.03,166.28 151.03,167.69 151.32,167.98 151.32,168.28 v3(151.5,168.46) 151.78,168.74 151.78,170.3 154.58,173.1 154.58,175.76 154.95,176.13 154.95,176.81 156.46,178.32 156.46,179.38 156.62,179.54 JEDP.11
EDP_TX3_C: length 16.4
  TOP w0.089: CV7.1 150.76,166.38 150.76,167.8 151.05,168.09 151.05,168.39 151.51,168.85 151.51,170.41 154.31,173.22 154.31,175.87 154.68,176.24 154.68,176.92 156.19,178.44 156.19,179.5 156.12,179.58 JEDP.10
ELC_8051_C2CK_RST#: length 28.1
  TOP w0.107: UE1.9 322.72,10.73 RE7.2 v1(322.75,10.07) 322.75,9.85 v2(322.33,9.43)
  BOTTOM w0.107: v1(322.75,10.07) 322.4,9.71 322.4,7.14 321.95,6.7 316.37,6.7 315.92,7.14 314.84,7.14 313.75,6.06 310.46,6.06 309.09,7.43 307,7.43 305.41,9.02 305.41,9.57 305.14,9.84 304.34,9.84 304.05,10.12 JELC.2
ELC_8051_C2D_P3: length 26.8
  TOP w0.107: v1(322.77,11.4) 322.63,11.53 UE1.10
  BOTTOM w0.107: JELC.3 304.85,10.18 304.96,10.07 305.24,10.07 305.64,9.67 305.64,9.12 307.01,7.75 309.12,7.75 310.59,6.29 313.61,6.29 314.78,7.46 315.98,7.46 316.43,7.02 321.94,7.02 322.16,7.24 322.16,10.8 v1(322.77,11.4)
ELC_EC#: length 253.6
  TOP w0.107: QE21.5 v1(200.11,172.11) ; QE22.5 205.06,172.26 205.17,172.37 v1(205.3,172.37) ; UE10.6 309.55,48.12 309.7,47.97 310.14,47.97 310.27,48.1 v1(310.27,48.55) ; v1(202.59,172.11) QE13.5
  IN2 w0.091: v1(202.59,172.11) 202.59,169.11 201.31,167.83 199.47,167.83 198.11,166.47 198.11,165.26 195.91,163.06 195.91,162.25 193.45,159.8 193.45,149.14 198.18,144.42 198.18,110.16 200.15,108.18 200.15,96 200.28,95.87 200.28,94.24 198.91,92.86 198.91,90.39 199.91,89.39 199.91,80.74 200.3,80.35 200.3,73.89 199.69,73.27 199.69,70.59 199.9,70.38 199.9,67.89 200.76,67.03 205.56,67.03 207.63,64.96 212.6,64.96 213.67,66.03 223.56,66.03 224.08,66.54 224.21,66.54 224.36,66.69 249.44,66.69 249.63,66.51 266.86,66.51 267.01,66.66 273.92,66.66 279.7,60.88 279.7,47.84 282.11,45.42 294.43,45.42 295.09,46.08 296.93,46.08 299.22,48.36 310.09,48.36 v1(310.27,48.55)
  BOTTOM w0.107: v1(205.3,172.37) 204.69,171.76 202.93,171.76 v1(202.59,172.11) v1(200.11,172.11)
EN_0.6VSP: length 5.1
  BOTTOM w0.107: PR211.1 95.88,47.71 96.27,48.1 v2(96.27,48.29)
  BOTTOM w0.203: PU201.7 94.8,44.4 95.13,44.74
  BOTTOM w0.254: 95.13,44.74 95.83,45.43 PC214.1 PR209.2 PR211.1
EN_1.2V: length 2.8
  BOTTOM w0.203: 95.17,44 PU201.8
  BOTTOM w0.254: PR208.1 PC213.1 95.72,44.55 95.17,44
EN_+1.8VGS: length 1.1
  BOTTOM w0.107: PR807.1 230.89,40.42 v2(230.89,41.27)
EN_+1VALWP: length 4.4
  TOP w0.107: 248.89,18.08 248.6,17.78 248.6,16.21 248.61,16.19 v2(248.61,16.16)
  TOP w0.254: PU300.3 248.11,18.09 PC300.1 PR300.2
EN_+VGA_PCIE: length 4.6
  TOP w0.254: v1(194.64,73.82) 194.76,73.69 PR802.1 ; PR802.1 196.01,73.61 PR801.1 ; PR802.1 196.93,73.69 PC801.1
  BOTTOM w0.254: v1(194.64,73.82) 194.64,74.39 194.89,74.65 PU800.11
EN_INVPWR: length 285.1
  TOP w0.107: v1(223.07,47.85) 224.21,46.7 224.21,39.21 v2(225.86,37.57) 225.97,37.45 232.84,37.45 233.5,36.79 238.6,36.79 240.83,34.56 240.83,26.13 241.68,25.28 241.68,17.84 v1(244.02,15.49) ; UE5.68 294.34,9.1 294.27,9.18 294.27,9.81 294.16,9.92 294.16,13.22 v1(293.7,13.68)
  IN2 w0.091: v1(155.58,163.33) 155.79,163.33 157.13,161.99 157.13,158.57 156.73,158.17 156.73,154.17 158.95,151.96 164.7,151.96 167.21,149.45 167.62,149.03 168.28,149.03 169.29,148.02 174.19,148.02 174.9,147.31 176.29,147.31 177,148.02 185.57,148.02 190.17,143.42 190.17,128.22 183.48,121.53 183.48,111.81 182.63,110.97 182.63,110.17 181.76,109.29 181.76,107.06 182.63,106.18 182.63,100.69 184.6,98.72 184.6,94.59 186.65,92.54 186.65,72.72 186.89,72.48 186.89,70.66 188.47,69.08 189.15,69.08 197.29,60.93 205.02,60.93 210.12,55.83 210.58,55.37 210.58,54.04 211.79,52.84 211.79,51.92 215.44,48.27 222.64,48.27 v1(223.07,47.85) ; v1(293.7,13.68) 293.05,13.68 292.87,13.5 291.78,13.5 290.59,14.69 277.91,14.69 273.96,18.64 272.09,18.64 271.98,18.74 268.86,18.74 268.27,18.15 267.29,18.15 264.64,15.51 247.71,15.51 246.88,14.68 244.57,14.68 244.02,15.23 v1(244.02,15.49)
  BOTTOM w0.107: v1(155.58,163.33) 155.2,163.71 155.2,164.43 155.86,165.09 QV2.2
EN_WOL#: length 227.3
  TOP w0.107: v1(300.05,14.14) 300.05,12.44 302.58,9.91 305.15,9.91 305.7,9.36 305.7,9.24 305.94,9 306.2,9 306.24,8.95 306.88,8.95 307.42,9.48 308.01,9.48 308.51,9.98 RE79.2 ; UE10.14 v1(309.05,53.68)
  IN3 w0.089: 280.16,98.71 280.16,92.88 281.25,91.79 282.39,91.79 282.56,91.62 ; 280.16,100.45 280.16,112.73
  IN3 w0.091: v1(239.72,146.72) 241.86,146.72 243.82,144.76 265.19,144.76 274.15,135.8 281.56,135.8 282.48,134.87 282.48,122.06 280.16,119.74 280.16,112.73 ; 282.56,91.62 282.9,91.28 283.77,91.28 284.31,90.75 284.31,86.17 287.88,82.6 287.88,77.16 293.2,71.85 293.2,62.02 296.34,58.88 v1(296.34,45.68) ; 280.16,98.71 280.16,100.45
  BOTTOM w0.107: UL2.4 225.84,148.12 225.84,146.77 CL42.1 226.37,146.03 226.61,145.8 231.31,145.8 231.66,146.15 239.15,146.15 v1(239.72,146.72) ; v1(309.05,53.68) 305.93,53.68 300.4,48.15 v2(300.09,48.15) 297.2,48.15 296.34,47.29 v1(296.34,45.68) 296.34,45.4 298.07,43.67 298.07,41.21 297.98,41.11 297.98,31.79 299.58,30.19 299.58,27.02 298.33,25.77 298.33,24.65 297.83,24.15 297.83,20.07 298.63,19.27 298.63,15.56 v1(300.05,14.14)
ENBKL: length 211.9
  TOP w0.107: v1(298.46,22.15) 298.46,21.7 297.72,20.96 297.72,13.2 297.19,12.67 297.19,9.62 297.54,9.27 UE5.76
  IN1 w0.089: 193.46,32.83 193.5,32.79 194.7,32.79 195.59,33.69 198.07,33.69 200.41,31.34 200.41,30 201.93,28.49 201.93,25.71 202.8,24.83 202.8,23.83 203.39,23.23 204.33,23.23 204.61,22.95 204.61,22.07 204.42,21.88 v1(204.42,21.88)
  IN1 w0.097: 193.46,32.83 192.44,32.83 191.54,33.74 191.54,34.46 191.32,34.68 191.32,40.3 188.41,43.21 v1(188.41,44.1)
  IN3 w0.091: v1(298.46,22.15) 298.11,22.15 297.71,21.75 292.5,21.75 292.1,22.15 288.58,22.15 285.8,24.94 280.49,24.94 279.58,25.85 276.51,25.85 275.96,26.4 269.02,26.4 265.57,22.95 265.57,22.38 265.25,22.07 258.99,22.07 255.83,18.91 251.82,18.91 250.27,17.36 246.65,17.36 246.45,17.15 240,17.15 239.38,17.77 227.37,17.77 226.76,18.38 223.85,18.38 223.16,19.07 222.16,19.07 220.24,20.99 214.89,20.99 214.45,20.54 214.45,19.97 213.61,19.13 213.16,19.13 212.52,18.49 211.45,18.49 211.25,18.29 210.25,18.29 209.27,19.28 208.86,19.28 208.47,19.66 208.47,20.14 208.18,20.42 208.18,20.85 207.93,21.09 207.63,21.09 207.53,20.99 205.56,20.99 204.67,21.88 v1(204.42,21.88) ; v1(188.41,44.1) 186.37,46.15 186.37,61.84 185.15,63.06 185.15,66.45 185.49,66.78 185.49,70.02 185,70.51 185,71.92 185.9,72.82 185.9,73.74 186.6,74.44 186.6,87.24 192.41,93.05 193.99,93.05 v1(194.3,93.36)
  BOTTOM w0.107: UV22.9 194.3,93.37 v1(194.3,93.36)
ENVDD: length 100.7
  TOP w0.107: v1(190.89,109.63) 190.63,109.37 190.63,103.42 v2(191.46,102.58) 192.43,101.62 192.43,97.3 193.17,96.56 193.17,93.92 193.63,93.46 v1(193.64,93.46)
  IN2 w0.091: v1(166.8,163.16) 167.02,162.94 167.02,160.67 166.03,159.68 166.03,156.32 169.11,153.24 170.35,153.24 172.14,151.45 173.41,151.45 173.99,150.86 187.1,150.86 194.42,143.54 194.42,113.87 192.62,112.07 192.62,111.36 v1(190.89,109.63)
  BOTTOM w0.107: UV17.4 166.12,164.75 RV600.2 166.87,163.24 v1(166.8,163.16) ; UV22.7 193.09,92.72 193.64,93.27 v1(193.64,93.46)
EQA0: length 6.3
  BOTTOM w0.107: RM84.2 125.54,151.14 RM81.2 126.43,152.7 125.68,153.45 v2(125.68,153.83) 125.68,154.08 126.27,154.68 UM8.20
EQA1: length 5.1
  BOTTOM w0.107: UM8.19 126.3,154.18 126.11,153.99 126.11,153.52 127.38,152.25 v2(127.38,151.99) RM76.2 RM70.2
EQB0: length 3.6
  BOTTOM w0.107: UM8.46 137.33,158.18 138,158.85 RM85.2 RM82.2 137.63,160.19 v2(137.4,160.19)
EQB1: length 6.1
  TOP w0.107: v1(137.74,157.65) 137.74,160.75 v1(137.74,160.75)
  BOTTOM w0.107: v2(137.74,161.64) v1(137.74,160.75) RM26.2 RM23.2 ; v1(137.74,157.65) 137.71,157.68 UM8.47
FB_3V: length 5.5
  BOTTOM w0.107: v2(58.24,50.08) 56.83,50.08 56.22,49.47 PR101.2
  BOTTOM w0.203: PR103.2 55.16,48.53 54.77,48.14 54.65,48.14 54.26,47.75 PU100.4
  BOTTOM w0.254: PR101.2 56.16,49.47 55.22,48.53 PR103.2
FB_5V: length 3.8
  BOTTOM w0.203: PR104.1 52.72,48.53 53.46,47.79 PU100.2
  BOTTOM w0.254: PR102.1 51.01,49.42 51.9,48.53 PR104.1
FB_+1.8VGS: length 1.2
  BOTTOM w0.107: 235.47,40.29 v2(234.26,40.29)
FB_+1VALWP: length 5.2
  TOP w0.107: PR307.1 250.95,18.08 251.41,17.62 v2(252.8,17.62)
  TOP w0.254: PU300.4 248.61,19.09 249.04,18.66 249.37,18.66 249.94,18.09 PR308.1 PR307.1
FB_+VGA_PCIE: length 4
  TOP w0.107: v1(194.54,76.14) v2(194.03,76.14)
  TOP w0.254: v1(194.54,76.14) 195.08,75.61 PR805.1
  BOTTOM w0.254: PC809.2 193.96,77.49 PR804.2 193.96,76.59 194.41,76.14 v1(194.54,76.14) 194.57,76.14 194.72,76 PU800.14
FB_VDDQ_SENSE: length 3.2
  TOP w0.107: v2(277.1,161.89) 277.48,161.51 277.48,161.17 278.14,160.51 PR8209.1
  TOP w0.203: PR8209.1 278.14,159.83 278.06,159.75 278.06,159.73 278.04,159.71 PU8200.12
FBA_ABI#_H: length 33
  TOP w0.089: 222.87,111.5 v1(223.77,110.6)
  TOP w0.135: 222.87,111.5 222.87,118.1 221.05,119.92 221.05,124.21 220.91,124.35 220.23,124.35 220.1,124.49 220.1,124.76 220.23,124.89 220.91,124.89 221.05,125.03 221.05,125.29 220.91,125.43 220.23,125.43 220.1,125.56 220.1,125.83 220.23,125.97 220.91,125.97 221.05,126.1 221.05,127.43 220.16,128.32 220.16,130.1 220.66,130.6 220.66,136.79 v1(221.07,137.2)
  BOTTOM w0.089: v1(223.77,110.6) 223.77,110.45 UG1.J36 ; UG14.J4 v1(221.07,137.2)
FBA_ABI#_L: length 51.1
  IN3 w0.089: v1(223.77,107) 223.3,107.47
  IN3 w0.112: 223.3,107.47 219.53,107.47 219.02,107.98 219.02,108.55 218.58,109 217.16,109 216.1,110.06 216.1,117.15 213.82,119.43 213.82,120.6 213.93,120.71 214.91,120.71 215.02,120.82 215.02,121.05 214.91,121.16 213.93,121.16 213.82,121.27 213.82,121.51 213.93,121.62 214.84,121.62 214.96,121.73 214.96,121.96 214.84,122.07 213.93,122.07 213.82,122.18 213.82,122.4 213.93,122.52 214.84,122.52 214.96,122.63 214.96,122.85 214.84,122.96 213.93,122.96 213.82,123.08 213.82,123.3 213.93,123.41 214.84,123.41 214.96,123.52 214.96,123.75 214.84,123.86 213.93,123.86 213.82,123.97 213.82,124.19 213.93,124.3 214.84,124.3 214.96,124.42 214.96,124.64 214.84,124.75 213.93,124.75 213.82,124.86 213.82,128.42 215.45,130.05 215.45,135.76 215.17,136.03 214.05,136.03 213.87,136.21 213.87,136.8 v1(213.47,137.2)
  BOTTOM w0.089: v1(223.77,107) 223.77,106.85 UG1.P36 ; UG13.J4 v1(213.47,137.2)
FBA_CAS#_H: length 35.9
  TOP w0.089: v1(224.57,109.4) 224.02,109.95
  TOP w0.135: v1(220.27,136.4) 219.87,136 219.87,130.55 219.66,130.34 219.66,127.21 219.8,127.08 220.47,127.08 220.61,126.95 220.61,126.68 220.47,126.54 219.8,126.54 219.66,126.41 219.66,123.91 219.8,123.78 220.47,123.78 220.61,123.64 220.61,123.37 220.47,123.24 219.8,123.24 219.66,123.1 219.66,122.84 219.8,122.71 220.28,122.71 220.42,122.57 220.42,122.3 220.28,122.17 219.8,122.17 219.66,122.04 v2(219.66,121.76) 219.66,120.68 221.92,118.42 221.92,112.51 222.07,112.36 222.46,112.36 222.57,112.25 222.57,110.19 222.81,109.95 224.02,109.95
  BOTTOM w0.089: UG14.G3 v1(220.27,136.4) ; UG1.L35 224.57,109.25 v1(224.57,109.4)
FBA_CAS#_L: length 54.3
  IN3 w0.089: 215.65,118.2 217.3,116.55 ; 226.29,106.48 v1(226.97,105.8)
  IN3 w0.112: v1(214.27,136.4) 214.65,136.77 215.23,136.77 215.85,136.15 215.85,131.09 215.86,131.08 215.86,129.42 215.75,129.3 215.29,129.3 215.18,129.19 215.18,128.97 215.29,128.86 215.75,128.86 215.86,128.74 215.86,128.52 215.75,128.41 214.4,128.41 214.28,128.3 214.28,128.07 214.4,127.96 215.75,127.96 215.86,127.85 215.86,127.63 215.75,127.52 214.34,127.52 214.23,127.4 214.23,127.18 214.34,127.07 215.75,127.07 215.86,126.96 215.86,126.73 215.75,126.62 214.34,126.62 214.23,126.51 214.23,126.29 214.34,126.17 215.75,126.17 215.86,126.06 215.86,125.84 215.75,125.73 214.34,125.73 214.23,125.62 214.23,125.39 214.34,125.28 215.32,125.28 215.43,125.17 215.43,118.42 215.65,118.2 ; 217.3,116.55 217.3,116.25 218.09,115.45 218.09,110.55 219.1,109.55 219.1,109.25 219.91,108.43 219.91,107.92 220.04,107.79 223.78,107.79 224.16,107.41 224.16,106.84 224.52,106.48 226.29,106.48
  BOTTOM w0.089: v1(214.27,136.4) 213.87,136 UG13.L3 ; UG1.R32 226.97,105.65 v1(226.97,105.8)
FBA_CKE_H: length 36.7
  TOP w0.089: v1(225.37,108.2) 224.57,109
  TOP w0.135: 224.57,109 222.83,109 222.57,109.26 222.57,109.6 221.65,110.52 221.65,117.98 221.21,118.43 221.02,118.43 220.92,118.33 220.73,118.33 220.54,118.52 220.54,118.71 220.64,118.81 220.64,119 v2(219.72,119.92) 219.09,120.55 219.09,136.62 219.27,136.8 219.67,136.8 219.87,137 219.87,137.45 220.07,137.65 220.72,137.65 v1(221.07,138)
  BOTTOM w0.089: v1(225.37,108.2) 225.37,108.05 UG1.M34 ; UG14.J3 v1(221.07,138)
FBA_CKE_L: length 52.8
  IN3 w0.089: 224.96,107.74 225.37,107.33 v1(225.37,107)
  IN3 w0.112: v1(213.47,138) 213.87,138.4 216.03,138.4 216.28,138.16 216.28,125.33 216.16,125.21 215.96,125.21 215.85,125.1 215.85,124.88 215.96,124.76 216.81,124.76 216.92,124.65 216.92,124.43 216.81,124.32 215.96,124.32 215.85,124.2 215.85,123.98 215.96,123.87 216.81,123.87 216.92,123.76 216.92,123.53 216.81,123.42 216.3,123.42 216.19,123.31 216.19,123.09 216.3,122.98 216.81,122.98 216.92,122.86 216.92,122.64 216.81,122.53 216.25,122.53 216.14,122.42 216.14,122.19 216.25,122.08 216.81,122.08 216.92,121.97 216.92,121.75 216.81,121.63 215.96,121.63 215.85,121.52 215.85,121.3 215.96,121.19 216.81,121.19 216.92,121.08 216.92,120.85 216.81,120.74 215.96,120.74 215.85,120.63 215.85,120.41 215.96,120.29 216.81,120.29 216.92,120.18 216.92,119.96 216.81,119.85 215.96,119.85 215.85,119.73 215.85,119.51 215.96,119.4 216.81,119.4 216.92,119.29 216.92,118.17 218.04,117.05 218.04,115.84 218.34,115.55 218.34,115.52 218.95,114.91 218.95,110.59 220,109.55 220,109.1 220.42,108.68 223.97,108.68 224.16,108.49 224.16,107.89 224.32,107.74 224.96,107.74
  BOTTOM w0.089: UG13.J3 213.87,137.6 v1(213.47,138) ; v1(225.37,107) 225.37,106.85 UG1.P34
FBA_CLK0: length 59.6
  TOP w0.135: v1(207.07,138) 207.36,137.71 207.48,137.71 208.07,138.3 209.12,138.3 RG57.1
  IN3 w0.089: v1(226.97,102.2) 226.66,101.89 226.66,101.64 226.43,101.4 215.68,101.4 215.67,101.4 215.65,101.4
  IN3 w0.112: 215.65,101.4 215.55,101.4 214.76,102.19 214.76,102.88 208.54,109.1 208.54,112.62 204.6,116.56 204.6,129.91 204.6,129.92 204.6,137.2 205.32,137.92 206.41,137.92 206.63,137.71 206.78,137.71 v1(207.07,138)
  BOTTOM w0.089: UG13.J12 v1(207.07,138) ; v1(226.97,102.2) 226.97,102.05 UG1.W32
FBA_CLK0#: length 58.8
  TOP w0.135: RG58.1 209.32,138.08 208.16,138.08 207.57,137.49 207.36,137.49 v1(207.07,137.2)
  IN3 w0.089: v1(226.17,102.2) 226.33,102.2 226.48,102.05 226.48,101.71 226.35,101.58 215.68,101.58 215.67,101.59 215.65,101.59
  IN3 w0.112: 215.65,101.59 215.63,101.59 214.96,102.27 214.96,102.96 208.74,109.18 208.74,112.7 204.8,116.64 204.8,137.12 205.4,137.72 206.33,137.72 206.54,137.51 206.96,137.51 207.07,137.4 v1(207.07,137.2)
  BOTTOM w0.089: UG1.W33 226.62,101.75 v1(226.17,102.2) ; UG13.J11 v1(207.07,137.2)
FBA_CLK1: length 41.5
  TOP w0.135: v1(227.47,137.2) 227.11,137.56 226.97,137.56 226.51,138.02 226.51,138.34 v3(226.28,138.57) 225.88,138.97 225.49,138.97 RG52.1
  IN3 w0.089: v1(229.62,108.45) 229.62,108.69 229.42,108.88 229.16,108.88 228.94,109.1 228.94,109.82 229.07,109.95 229.07,120.04 228.43,120.67 228.43,121.2 228.42,121.2 228.42,121.23 ; v1(227.47,137.2) 227.84,137.57 228.42,137.57 228.61,137.38 229.12,137.38 229.57,136.93 229.57,130.43 229.41,130.27 229.41,130 229.41,129.99 229.41,129.94 229.39,129.93 229.39,129.92
  IN3 w0.112: 229.39,129.92 229.39,129.79 229.31,129.7 228.68,129.7 228.42,129.45 228.42,129.05 228.7,128.77 229.23,128.77 229.39,128.61 229.39,128.37 229.23,128.21 228.7,128.21 228.42,127.93 228.42,127.54 228.7,127.26 229.23,127.26 229.39,127.1 229.39,126.87 229.23,126.7 228.7,126.7 228.42,126.42 228.42,126.03 228.7,125.75 229.23,125.75 229.39,125.59 229.39,125.36 229.23,125.19 228.7,125.19 228.42,124.92 228.42,121.23
  BOTTOM w0.089: v1(227.47,137.2) 227.87,137.6 UG14.J12 ; UG1.M29 229.77,108.45 v1(229.62,108.45)
FBA_CLK1#: length 41.3
  TOP w0.135: RG53.1 225.26,139.51 225.58,139.19 225.98,139.19 226.74,138.43 226.74,138.11 227.06,137.78 227.25,137.78 v1(227.47,138)
  IN3 w0.089: v1(227.47,138) 227.72,137.75 228.49,137.75 228.68,137.56 229.19,137.56 229.75,137 229.75,130.35 229.59,130.19 229.59,129.92 ; 228.62,121.23 228.62,121.2 228.61,121.2 228.61,120.75 229.24,120.11 229.24,109.88 229.12,109.75 229.12,109.18 229.23,109.06 229.43,109.06 v1(229.62,109.25)
  IN3 w0.112: 228.62,121.23 228.62,124.83 228.78,125 229.31,125 229.59,125.28 229.59,125.67 229.31,125.95 228.78,125.95 228.62,126.11 228.62,126.34 228.78,126.51 229.31,126.51 229.59,126.78 229.59,127.18 229.31,127.46 228.78,127.46 228.62,127.62 228.62,127.85 228.78,128.02 229.31,128.02 229.59,128.29 229.59,128.69 229.31,128.97 228.78,128.97 228.62,129.13 228.62,129.37 228.76,129.51 229.39,129.51 229.59,129.71 229.59,129.92
  BOTTOM w0.089: UG14.J11 227.07,137.6 v1(227.47,138) ; v1(229.62,109.25) 229.77,109.25 UG1.L29
FBA_CS#_H: length 38.3
  IN3 w0.089: 230.32,108.95 v1(230.82,108.45)
  IN3 w0.112: v1(228.27,138.8) 228.67,138.4 230.13,138.4 230.46,138.07 230.46,130.05 230.59,129.91 231.15,129.91 231.28,129.78 231.28,129.6 231.15,129.47 230.59,129.47 230.46,129.34 230.46,129.1 230.59,128.97 231.15,128.97 231.28,128.84 231.28,128.65 231.15,128.52 230.59,128.52 230.46,128.39 230.46,128.2 230.59,128.07 231.15,128.07 231.28,127.94 231.28,127.76 231.15,127.63 230.59,127.63 230.46,127.5 230.46,125.2 229.56,124.3 229.56,114.74 230.32,113.97 230.32,108.95
  BOTTOM w0.089: UG14.L12 v1(228.27,138.8)
  BOTTOM w0.135: UG1.M27 230.97,108.45 v1(230.82,108.45)
FBA_CS#_L: length 56.7
  IN3 w0.089: 224.97,100.6 v1(225.37,101)
  IN3 w0.112: 224.97,100.6 215.4,100.6 213.76,102.24 213.46,102.24 207.6,108.1 207.6,112.16 203.91,115.86 203.91,137.76 205.34,139.2 205.87,139.2 v1(206.27,139.6)
  BOTTOM w0.089: v1(225.37,101) 225.37,100.85 UG1.Y34 ; UG13.G12 v1(206.27,139.6)
FBA_D0: length 56.5
  IN1 w0.089: v1(217.67,104.6) 217.45,104.38 215.65,104.38
  IN1 w0.119: 215.65,104.38 212.87,104.38 203.12,114.13 203.12,117.81 201.88,119.05 201.88,124.73 201.51,125.11 201.51,142.11 204.43,145.03 207.24,145.03 v1(207.87,144.4)
  BOTTOM w0.089: v1(217.67,104.6) 217.67,104.45 UG1.U43 ; UG13.A11 v1(207.87,144.4)
FBA_D1: length 55.4
  IN1 w0.089: 215.65,104.8 217.2,104.8 217.37,104.98 219.09,104.98 v1(219.47,104.6)
  IN1 w0.119: v1(206.27,144.4) 205.89,144.78 204.77,144.78 201.93,141.94 201.93,125.28 202.3,124.91 202.3,119.23 203.55,117.99 203.55,114.3 213.04,104.8 215.65,104.8
  BOTTOM w0.089: v1(219.47,104.6) 219.47,104.45 UG1.U41 ; UG13.A13 v1(206.27,144.4)
FBA_D2: length 56
  IN1 w0.089: v1(220.37,104.6) 219.74,105.23 215.65,105.23
  IN1 w0.119: v1(207.87,143.6) 207.48,144 205.33,144 205.03,143.69 205.03,143.25 204.09,142.31 204.09,132.51 202.36,130.78 202.36,125.46 202.73,125.08 202.73,119.4 203.97,118.16 203.97,114.48 213.22,105.23 215.65,105.23
  BOTTOM w0.089: UG13.B11 v1(207.87,143.6) ; UG1.U40 220.37,104.45 v1(220.37,104.6)
FBA_D3: length 51
  IN1 w0.089: 215.65,105.68 216.95,105.68 217.46,106.19 218.18,106.19 v1(218.57,105.8)
  IN1 w0.119: v1(206.26,143.6) 205.89,143.22 205.36,143.22 204.34,142.2 204.34,132.16 202.78,130.6 202.78,125.63 203.15,125.26 203.15,119.58 204.49,118.24 204.49,114.56 213.37,105.68 215.65,105.68
  BOTTOM w0.089: UG13.B13 205.87,143.21 v1(206.26,143.6) ; UG1.R42 218.57,105.65 v1(218.57,105.8)
FBA_D4: length 44.4
  IN1 w0.089: 217.87,107.7 v1(218.57,107)
  IN1 w0.119: 217.87,107.7 217.46,107.7 217.37,107.79 216.67,107.79 216.44,108.02 214.57,108.02 214.15,108.44 214.15,108.64 214.31,108.81 214.31,109.01 214.17,109.15 213.98,109.15 213.81,108.98 213.61,108.98 213.47,109.12 213.47,109.32 213.64,109.48 213.64,109.68 213.5,109.82 213.3,109.82 213.13,109.65 212.94,109.65 206.83,115.76 206.83,119.21 205.49,120.55 205.49,126.23 205.12,126.6 205.12,130.08 205.09,130.11 205.09,139.87 205.21,139.99 205.86,139.99 v1(206.27,140.4)
  BOTTOM w0.089: UG1.P42 218.57,106.85 v1(218.57,107) ; UG13.F13 v1(206.27,140.4)
FBA_D5: length 42.5
  IN1 w0.089: v1(217.67,108.2) 216.96,108.2
  IN1 w0.119: v1(207.07,141.2) 206.65,140.78 206.65,139.44 206.39,139.18 206.12,139.18 205.85,138.91 205.85,130.21 205.54,129.9 205.54,126.78 205.92,126.41 205.92,120.72 207.34,119.3 207.34,115.85 210.09,113.1 210.83,113.1 215.18,108.74 216.42,108.74 216.96,108.2
  BOTTOM w0.089: v1(217.67,108.2) 217.67,108.05 UG1.M43 ; UG13.E13 206.27,141.2 v1(207.07,141.2)
FBA_D6: length 43.9
  IN1 w0.089: v1(219.47,108.2) 219.47,108.48 219.35,108.6
  IN1 w0.119: v1(207.87,139.6) 207.47,139.2 207.47,138.66 207.22,138.42 206.96,138.42 206.65,138.11 206.65,130.49 205.97,129.81 205.97,126.95 206.34,126.58 206.34,120.9 207.93,119.31 207.93,117.3 208.29,116.93 208.29,116.76 207.76,116.23 207.76,116.03 207.9,115.89 208.1,115.89 208.64,116.43 208.84,116.43 208.98,116.29 208.98,116.1 208.44,115.55 208.44,115.35 209.45,114.34 209.45,114.34 210.27,113.52 211,113.52 215.3,109.22 216.45,109.22 217.07,108.6 219.35,108.6
  BOTTOM w0.089: UG13.F11 v1(207.87,139.6) ; v1(219.47,108.2) 219.47,108.05 UG1.M41
FBA_D7: length 44.8
  IN1 w0.089: 219.64,108.93 v1(220.37,108.2)
  IN1 w0.119: v1(207.87,140.4) 208.25,140.02 208.25,138.25 207.48,137.47 207.48,130.35 207.02,129.89 207.02,127.03 206.76,126.78 206.76,121.08 208.35,119.49 208.35,117.52 209.68,116.19 209.68,116 209.14,115.45 209.14,115.25 209.28,115.11 209.47,115.11 210.02,115.66 210.21,115.66 210.35,115.52 210.35,115.32 209.81,114.78 209.81,114.58 209.95,114.44 210.15,114.44 210.32,114.61 210.52,114.61 215.3,109.82 216.25,109.82 217.14,108.93 219.64,108.93
  BOTTOM w0.089: v1(220.37,108.2) 220.37,108.05 UG1.M40 ; UG13.E11 v1(207.87,140.4)
FBA_D8: length 39
  IN1 w0.089: 217.1,111.09 217.6,110.6 v1(217.67,110.6)
  IN1 w0.119: 217.1,111.09 214.37,113.83 214.37,116.57 209.14,121.8 209.14,129.98 209.94,130.78 209.94,138.84 210.66,139.57 210.66,139.82 211.67,140.82 213.89,140.82 v1(214.27,141.2)
  BOTTOM w0.089: UG1.J43 217.67,110.45 v1(217.67,110.6) ; UG13.E2 214.67,140.8 v1(214.27,141.2)
FBA_D9: length 36.7
  IN1 w0.089: 217.8,111.37 v1(218.57,110.6)
  IN1 w0.119: v1(212.67,140.4) 212.29,140.02 211.63,140.02 210.32,138.72 210.32,130.65 209.65,129.98 209.65,121.96 214.85,116.77 214.85,113.95 217.42,111.37 217.8,111.37
  BOTTOM w0.089: UG13.E4 213.07,140.8 v1(212.67,140.4) ; UG1.J42 218.57,110.45 v1(218.57,110.6)
FBA_D10: length 34.9
  IN1 w0.119: v1(217.67,111.8) 217.55,111.8 215.78,113.57 215.78,113.63 215.32,114.09 215.32,116.97 210.13,122.16 210.13,129.95 210.7,130.52 210.7,138.34 211.59,139.22 212.03,139.22 213.21,140.4 v1(213.47,140.4)
  BOTTOM w0.089: UG13.F4 v1(213.47,140.4) ; UG1.H43 217.67,111.65 v1(217.67,111.8)
FBA_D11: length 37
  IN1 w0.089: v1(219.47,111.8) 219.07,112.2
  IN1 w0.119: 219.07,112.2 217.53,112.2 216.67,113.06 216.67,113.17 215.8,114.04 215.8,117.16 210.6,122.36 210.6,129.92 211.08,130.4 211.08,138.34 211.61,138.86 212.2,138.86 212.52,139.18 213.58,139.18 213.89,139.49 213.89,140.02 v1(214.27,140.4)
  BOTTOM w0.089: UG1.H41 219.47,111.65 v1(219.47,111.8) ; v1(214.27,140.4) 214.67,140 UG13.F2
FBA_D12: length 39.1
  IN1 w0.089: v1(219.47,113) 219,113.47
  IN1 w0.119: v1(214.27,143.6) 214.65,143.98 215.23,143.98 216,143.2 216,143.16 216.07,143.1 216.07,136.77 215.32,136.02 214.09,136.02 213.85,135.78 213.85,129.7 213.57,129.42 213.57,125.31 215.06,123.81 215.06,122.25 217.41,119.91 217.41,117.59 216.99,117.17 216.99,115.07 217.45,114.61 218.75,114.61 219,114.35 219,113.47
  BOTTOM w0.089: UG1.F41 219.47,112.85 v1(219.47,113) ; UG13.B2 214.67,143.2 v1(214.27,143.6)
FBA_D13: length 37.8
  IN1 w0.089: v1(217.6,114.16) 217.28,114.16
  IN1 w0.119: v1(212.67,143.6) 213.09,143.18 215.23,143.18 215.78,142.62 215.78,137.57 214.99,136.78 213.26,136.78 213.09,136.62 213.09,125.18 214.64,123.64 214.64,122.08 216.99,119.73 216.99,117.63 216.67,117.32 216.67,114.78 217.28,114.16
  BOTTOM w0.089: UG1.E43 217.6,114.12 v1(217.6,114.16) ; v1(212.67,143.6) 213.07,143.2 UG13.B4
FBA_D14: length 36.9
  IN1 w0.089: 218.77,116.24 v1(218.77,115.67)
  IN1 w0.119: 218.77,116.24 219.13,116.6 219.13,118.02 218.41,118.74 218.41,121.66 215.12,124.95 215.12,130.28 215.59,130.75 215.59,134.54 216.91,135.86 216.91,143.45 215.33,145.03 215.27,145.03 215.26,145.04 214.85,145.04 214.83,145.07 213.34,145.07 v1(212.67,144.4)
  BOTTOM w0.089: UG13.A4 213.07,144 v1(212.67,144.4) ; v1(218.77,115.67) 218.49,115.67 UG1.C43
FBA_D15: length 36.2
  IN1 w0.089: 217.29,117.06 217.29,115.42 v1(217.43,115.28)
  IN1 w0.119: 217.29,117.06 217.94,117.7 217.94,121.54 214.65,124.83 214.65,135 214.88,135.22 215.34,135.22 216.49,136.38 216.49,143.27 216,143.76 216,144 215.59,144.41 215.23,144.78 214.92,144.78 214.78,144.64 214.51,144.64 v1(214.27,144.4)
  BOTTOM w0.089: v1(217.43,115.28) 217.92,114.8 UG1.D42 ; v1(214.27,144.4) 214.67,144 UG13.A2
FBA_D16: length 47.2
  IN4 w0.089: 221.77,104.2 v1(222.17,104.6)
  IN4 w0.119: 221.77,104.2 216.83,104.2 216.76,104.14 210.87,104.14 203.51,111.5 203.51,131.7 203.53,131.72 203.53,131.79 205.36,133.62 205.89,133.62 v1(206.27,134)
  BOTTOM w0.089: v1(222.17,104.6) 222.17,104.45 UG1.U38 ; UG13.N13 205.87,134.4 v1(206.27,134)
FBA_D17: length 49.8
  IN4 w0.089: v1(206.27,134.8) 206.27,134.79 205.88,134.4 205.36,134.4 204.18,133.22 ; v1(222.97,104.6) 221.88,103.85
  IN4 w0.119: 204.18,133.22 203.08,132.12 203.08,111.33 210.69,103.71 217.8,103.71 217.94,103.85 221.88,103.85
  BOTTOM w0.089: v1(222.97,104.6) 222.97,104.45 UG1.U37 ; UG13.M13 205.87,135.2 v1(206.27,134.8)
FBA_D18: length 43
  IN4 w0.089: v1(222.17,105.8) 221.77,105.4
  IN4 w0.119: 221.77,105.4 216.97,105.4 216.96,105.4 210.81,105.4 204.35,111.85 204.35,125.07 204.86,125.57 204.86,130.97 205.11,131.22 205.85,131.22 v1(206.27,130.8)
  BOTTOM w0.089: v1(222.17,105.8) 222.17,105.65 UG1.R38 ; UG13.U13 205.87,131.2 v1(206.27,130.8)
FBA_D19: length 46.9
  IN4 w0.089: v1(223.77,105.8) 222.95,104.98
  IN4 w0.119: v1(206.27,131.6) 205.85,132.02 204.43,132.02 203.93,131.52 203.93,111.68 210.63,104.98 213.15,104.98 213.15,104.98 222.95,104.98
  BOTTOM w0.089: v1(223.77,105.8) 223.77,105.65 UG1.R36 ; v1(206.27,131.6) 205.87,132 UG13.T13
FBA_D20: length 36.4
  IN4 w0.089: v1(221.27,107) 220.87,107.4
  IN4 w0.119: 220.87,107.4 217.37,107.4 216.82,107.94 215.95,107.94 215.91,107.98 212.29,107.98 206.7,113.57 206.7,113.64 206.69,113.65 206.69,123.91 207.23,124.44 207.23,126.7 207.87,127.34 v1(207.87,130.8)
  BOTTOM w0.089: v1(207.87,130.8) 207.47,131.2 UG13.U11 ; UG1.P39 221.27,106.85 v1(221.27,107)
FBA_D21: length 38.5
  IN4 w0.089: 222.21,107.76 v1(222.97,107)
  IN4 w0.119: 222.21,107.76 217.45,107.76 216.79,108.42 215.85,108.42 215.85,108.43 212.52,108.43 207.12,113.83 207.12,123.73 207.65,124.27 207.65,124.62 207.65,126.52 208.35,127.22 208.35,131.12 v1(207.87,131.6)
  BOTTOM w0.089: UG1.P37 222.97,106.85 v1(222.97,107) ; v1(207.87,131.6) 207.47,132 UG13.T11
FBA_D22: length 39.9
  IN4 w0.089: v1(222.17,108.2) 221.73,108.64
  IN4 w0.119: 221.73,108.64 217.01,108.64 216.75,108.89 212.72,108.89 207.54,114.07 207.54,123.55 208.8,124.81 208.8,130.9 209.05,131.15 209.05,133.62 208.67,134 v1(207.87,134)
  BOTTOM w0.089: v1(222.17,108.2) 222.17,108.05 UG1.M38 ; UG13.N11 207.47,134.4 v1(207.87,134)
FBA_D23: length 41.6
  IN4 w0.089: 222.22,108.95 v1(222.97,108.2)
  IN4 w0.119: 222.22,108.95 217.14,108.95 216.72,109.37 212.92,109.37 207.97,114.32 207.97,123.29 209.26,124.58 209.26,130.99 209.3,131.03 209.3,133.76 209.26,133.81 209.26,134.77 208.8,135.22 208.25,135.22 v1(207.87,135.6)
  BOTTOM w0.089: UG1.M37 222.97,108.05 v1(222.97,108.2) ; UG13.M11 v1(207.87,135.6)
FBA_D24: length 34.2
  IN4 w0.089: 223.22,109.95 v1(223.77,109.4)
  IN4 w0.112: 215.65,112.91 216.38,112.91 217.09,112.2
  IN4 w0.119: 217.09,112.2 220.52,112.2 220.88,111.85 220.88,111.59 221.42,111.05 222.27,111.05 222.57,110.75 222.57,110.15 222.77,109.95 223.22,109.95 ; v1(214.27,131.6) 213.87,131.2 213.28,131.2 213.09,131.01 213.09,130.69 212.83,130.42 212.57,130.42 212.19,130.05 212.19,124.87 211.7,124.38 211.7,123.6 211.3,123.2 211.3,117.29 212.16,116.42 212.16,115.49 214.75,112.91 215.65,112.91
  BOTTOM w0.089: v1(223.77,109.4) 223.77,109.25 UG1.L36 ; v1(214.27,131.6) 214.67,132 UG13.T2
FBA_D25: length 31.5
  IN4 w0.089: 219.97,111 v1(220.37,110.6)
  IN4 w0.119: 219.97,111 216.76,111 216.04,111.73 215.15,111.73 214.87,112 213.88,112 211.12,114.76 211.12,114.92 210.88,115.16 210.88,115.7 210.69,115.89 210.69,116.19 210.04,116.84 210.04,123.14 210.85,123.95 210.85,131.05 211.02,131.22 212.03,131.22 212.41,131.6 v1(212.67,131.6)
  BOTTOM w0.089: UG1.J40 220.37,110.45 v1(220.37,110.6) ; v1(212.67,131.6) 213.07,132 UG13.T4
FBA_D26: length 30.9
  IN4 w0.089: v1(221.27,110.6) 220.47,111.4
  IN4 w0.119: v1(212.67,130.8) 212.21,130.8 211.39,130.8 211.27,130.68 211.27,123.78 210.46,122.96 210.46,120.42 210.88,120 210.88,117.08 211.11,116.84 211.11,116.06 211.3,115.87 211.3,115.34 211.55,115.09 211.55,114.93 214.05,112.43 216.29,112.43 217.32,111.4 220.47,111.4
  BOTTOM w0.089: UG13.U4 213.07,131.2 v1(212.67,130.8) ; v1(221.27,110.6) 221.27,110.45 UG1.J39
FBA_D27: length 31.3
  IN4 w0.089: v1(222.97,110.6) 222.97,111.2
  IN4 w0.119: v1(214.27,130.8) 213.89,130.42 213.18,130.42 212.9,130.14 212.74,130.14 212.62,130.02 212.62,124.39 212.48,124.25 212.48,120.1 211.72,119.35 211.72,117.46 212.73,116.45 212.73,115.84 215.19,113.38 215.84,113.38 216.41,113.38 217.2,112.6 220.57,112.6 220.97,112.2 221.52,112.2 221.72,112 221.72,111.65 221.97,111.4 222.77,111.4 222.97,111.2
  BOTTOM w0.089: UG13.U2 214.67,131.2 v1(214.27,130.8) ; UG1.J37 222.97,110.45 v1(222.97,110.6)
FBA_D28: length 26.7
  IN4 w0.089: 219.81,114.71 v1(220.37,114.15)
  IN4 w0.119: 219.81,114.71 218.94,114.71 218.86,114.79 217.14,114.79 216.49,115.44 216.49,116.18 215.5,117.16 215.5,129.8 216.01,130.31 216.01,133.61 215.23,134.4 214.67,134.4 v1(214.27,134.8)
  BOTTOM w0.089: v1(214.27,134.8) 214.67,135.2 UG13.M2 ; v1(220.37,114.15) 220.37,114.05 UG1.E40
FBA_D29: length 25.4
  IN4 w0.089: v1(219.47,114.15) 219.14,114.15
  IN4 w0.119: 219.14,114.15 218.75,114.54 217.03,114.54 216.16,115.41 216.16,115.83 215.08,116.91 215.08,129.92 215.72,130.56 215.72,133.11 215.22,133.61 214.66,133.61 v1(214.27,134)
  BOTTOM w0.089: UG13.N2 214.67,134.4 v1(214.27,134) ; v1(219.47,114.15) 219.47,114.05 UG1.E41
FBA_D30: length 28.7
  IN4 w0.089: 220.22,115.15 221.24,115.15
  IN4 w0.119: v1(212.67,134.8) 213.06,135.19 215.27,135.19 216.41,134.05 216.41,118.59 216.73,118.27 216.73,116.43 217.5,115.66 217.88,115.66 218.39,115.16 219.21,115.16 219.4,114.97 220.04,114.97 220.22,115.15 ; 221.24,115.15 v1(221.24,115.16)
  BOTTOM w0.089: UG13.N4 v1(212.67,134.8) ; v1(221.24,115.16) 221.35,115.05 221.37,115.05 UG1.D39
FBA_D31: length 28.1
  IN4 w0.089: 219.75,115.7 221.02,115.7 v1(221.27,115.95)
  IN4 w0.119: 219.75,115.7 219.68,115.78 219.29,115.78 219.02,116.05 217.56,116.05 217.12,116.49 217.12,118.6 216.84,118.88 216.84,134.39 215.23,135.99 213.86,135.99 v1(213.47,135.6)
  BOTTOM w0.089: v1(221.27,115.95) 221.37,115.95 UG1.C39 ; v1(213.47,135.6) 213.07,135.2 UG13.M4
FBA_D32: length 34.8
  IN1 w0.089: v1(220.02,117.95) 219.09,118.88
  IN1 w0.119: 219.09,118.88 219.09,121.94 216.08,124.96 216.08,130.75 216.52,131.19 216.52,134.38 217.59,135.45 217.59,144.35 218.34,145.1 221.17,145.1 v1(221.87,144.4)
  BOTTOM w0.089: v1(220.02,117.95) 220.12,117.85 UG1.A41 ; UG14.U4 v1(221.87,144.4)
FBA_D33: length 33.8
  IN1 w0.089: v1(220.02,116.65) 220.4,117.03
  IN1 w0.119: 220.4,117.03 220.4,118.11 219.57,118.94 219.57,122.14 216.5,125.21 216.5,130.57 216.95,131.02 216.95,134.12 218.07,135.24 218.07,144.16 218.7,144.79 219.88,144.79 v1(220.27,144.4)
  BOTTOM w0.089: UG1.B40 220.37,116.65 v1(220.02,116.65)
  BOTTOM w0.13: v1(220.27,144.4) UG14.U2
FBA_D34: length 33.2
  IN1 w0.089: v1(221.27,117.75) 220.04,118.98
  IN1 w0.119: v1(221.87,143.6) 221.49,143.98 219.07,143.98 218.39,143.29 218.39,134.78 217.37,133.76 217.37,130.84 216.92,130.4 216.92,125.45 220.04,122.34 220.04,118.98
  BOTTOM w0.089: UG1.A39 221.37,117.75 v1(221.27,117.75) ; UG14.T4 v1(221.87,143.6)
FBA_D35: length 32.6
  IN1 w0.089: v1(222.42,115.95) 221.65,116.72
  IN1 w0.119: 221.65,116.72 221.65,117.91 220.52,119.04 220.52,122.53 217.37,125.68 217.37,130.2 217.79,130.62 217.79,133.59 218.7,134.5 218.7,142.57 219.34,143.2 UG14.T2 v1(220.27,143.6)
  BOTTOM w0.089: UG1.C38 222.57,115.95 v1(222.42,115.95) ; UG14.T2 v1(220.27,143.6)
FBA_D36: length 28
  IN1 w0.089: v1(223.62,115.95) 223.21,116.36
  IN1 w0.119: v1(220.27,140.4) 220.66,140.01 220.66,133.83 220.41,133.58 220.09,133.58 219.85,133.34 219.85,126.73 223.01,123.57 223.01,118.51 223.21,118.31 223.21,116.36
  BOTTOM w0.089: UG1.C36 223.77,115.95 v1(223.62,115.95) ; UG14.M2 v1(220.27,140.4)
FBA_D37: length 27.1
  IN1 w0.089: 221.46,133.72 221.46,140.01 v1(220.27,141.2) ; 223.62,118.21 v1(223.62,117.75)
  IN1 w0.119: 221.46,133.72 221.32,133.58 220.85,133.58 220.65,133.38 220.65,130.61 221.5,129.76 221.5,125.75 223.48,123.76 223.48,118.35 223.62,118.21
  BOTTOM w0.089: UG14.N2 v1(220.27,141.2)
  BOTTOM w0.135: UG1.A36 223.77,117.75 v1(223.62,117.75)
FBA_D38: length 26.3
  IN1 w0.089: 222.31,132.96 222.31,139.16 v1(221.87,139.6) ; v1(224.82,116.85) 224.26,117.41
  IN1 w0.119: 222.31,132.96 222.17,132.82 221.68,132.82 221.45,132.59 221.45,130.64 222.08,130.01 222.08,125.84 223.96,123.96 223.96,118.71 224.26,118.41 224.26,117.41
  BOTTOM w0.089: UG1.B35 224.97,116.85 v1(224.82,116.85) ; UG14.M4 v1(221.87,139.6)
FBA_D39: length 26
  IN1 w0.089: 223.08,132.28 223.08,139.74 222.82,140.01 222.27,140.01 v1(221.87,140.4) ; 224.81,118.44 224.81,117.76
  IN1 w0.119: 223.08,132.28 222.56,131.75 222.56,126.16 224.43,124.29 224.43,118.83 224.81,118.44 ; 224.81,117.76 v1(224.82,117.75)
  BOTTOM w0.089: UG14.N4 v1(221.87,140.4) ; v1(224.82,117.75) 224.97,117.75 UG1.A35
FBA_D40: length 25.8
  IN1 w0.119: v1(226.67,139.6) 227.05,139.22 227.05,133.68 226.52,133.15 226.09,133.15 225.49,132.56 225.49,127.82 228.21,125.1 228.21,118.74 v1(227.22,117.75)
  BOTTOM w0.089: UG1.A32 227.37,117.75 v1(227.22,117.75) ; v1(226.67,139.6) 227.07,140 UG14.M11
FBA_D41: length 28.7
  IN1 w0.089: 226.82,116.35 v1(227.22,115.95)
  IN1 w0.119: v1(226.67,140.4) 225.77,140.4 225.49,140.13 225.49,133.32 225.02,132.84 225.02,127.62 227.74,124.9 227.74,118.96 226.82,118.05 226.82,116.35
  BOTTOM w0.089: v1(226.67,140.4) 227.07,140.8 UG14.N11 ; v1(227.22,115.95) 227.37,115.95 UG1.C32
FBA_D42: length 31.7
  IN1 w0.089: 226.42,115.85 v1(227.22,115.05)
  IN1 w0.119: 226.42,115.85 226.42,118.04 226.37,118.1 226.37,125.6 224.54,127.43 224.54,140.06 225.26,140.78 227.85,140.78 228.23,141.16 v1(228.23,141.19)
  BOTTOM w0.089: v1(228.23,141.19) 228.28,141.19 228.67,140.8 UG14.N13 ; v1(227.22,115.05) 227.37,115.05 UG1.D32
FBA_D43: length 26
  IN1 w0.089: v1(228.42,116.85) 228.02,117.25
  IN1 w0.119: v1(228.27,140.4) 227.85,139.98 227.85,130.65 227.74,130.54 227.74,126.24 228.69,125.3 228.69,118.64 228.02,117.97 228.02,117.25
  BOTTOM w0.089: UG14.M13 228.67,140 v1(228.27,140.4) ; v1(228.42,116.85) 228.57,116.85 UG1.B30
FBA_D44: length 30.8
  IN1 w0.119: v1(228.27,143.6) 228.67,143.2 229.29,143.2 229.75,142.74 229.75,131.12 230.36,130.52 230.36,127.46 231.59,126.22 231.59,122.45 230.88,121.73 v1(230.75,121.73)
  BOTTOM w0.089: UG1.B29 229.74,116.88 ; v1(228.27,143.6) 228.67,143.2 UG14.T13
  BOTTOM w0.135: v1(230.75,121.73) 229.43,120.42 229.43,118.21 229.74,117.9 229.74,116.88
FBA_D45: length 35.4
  IN1 w0.119: v1(226.67,143.6) 227.06,143.99 229.36,143.99 230,143.35 230,132.14 230.78,131.36 230.78,127.71 232.04,126.45 232.04,122.19 v1(230.75,120.9)
  BOTTOM w0.089: UG1.D27 230.67,115.35 ; UG14.T11 227.07,143.2 v1(226.67,143.6)
  BOTTOM w0.135: v1(230.75,120.9) 229.94,120.1 v2(229.94,119.48) 229.94,118.82 230.67,118.1 230.67,115.35
FBA_D46: length 34
  IN1 w0.089: 230.87,120.35 v1(230.75,120.35)
  IN1 w0.119: 230.87,120.35 232.48,121.96 232.48,126.68 231.28,127.88 231.28,127.96 231.2,128.03 231.2,131.68 230.41,132.48 230.41,143.37 230.07,143.71 230.07,144.4 229.65,144.81 228.68,144.81 v1(228.27,144.4)
  BOTTOM w0.089: UG1.C27 230.97,115.95 ; UG14.U13 228.67,144 v1(228.27,144.4)
  BOTTOM w0.135: 230.97,115.95 230.97,118.26 230.37,118.86 230.37,119.97 v1(230.75,120.35)
FBA_D47: length 34.3
  IN1 w0.089: 231.81,120.11 v1(230.99,119.29)
  IN1 w0.119: v1(226.67,144.4) 227.36,145.09 230.18,145.09 230.49,144.77 230.49,143.88 230.83,143.54 230.83,132.66 231.63,131.86 231.63,128.2 232.93,126.91 232.93,121.22 231.81,120.11
  BOTTOM w0.089: UG14.U11 227.07,144 v1(226.67,144.4)
  BOTTOM w0.135: UG1.A27 231.42,118.86 v1(230.99,119.29)
FBA_D48: length 28.4
  IN4 w0.089: 221.97,114.4 222.22,114.15 v1(222.42,114.15)
  IN4 w0.119: 221.97,114.4 221.97,116.68 221.28,117.37 220.93,117.37 220.73,117.57 219.86,117.57 217.94,119.5 217.94,133.89 219.24,135.19 221.48,135.19 v1(221.87,134.8)
  BOTTOM w0.089: UG14.E4 221.47,134.4 v1(221.87,134.8) ; UG1.E38 222.57,114.15 v1(222.42,114.15)
FBA_D49: length 31.2
  IN4 w0.089: v1(223.77,111.65) 222.72,113.3
  IN4 w0.119: v1(221.07,135.6) 220.47,135.99 219.33,135.99 217.52,134.18 217.52,119.32 217.96,118.88 218.1,118.88 219.66,117.32 220.26,117.32 221.22,116.36 221.39,116.36 221.66,116.1 221.66,114.36 222.72,113.3
  BOTTOM w0.089: v1(223.77,111.65) UG1.H36 ; UG14.F4 v1(221.07,135.6)
FBA_D50: length 27.5
  IN4 w0.089: 222.8,114.07 v1(223.62,113.25)
  IN4 w0.119: v1(220.27,134.8) 219.87,134.4 219.32,134.4 218.45,133.53 218.45,119.76 219.75,118.46 221.62,118.46 221.94,118.14 221.94,117.35 222.06,117.23 222.58,117.23 222.8,117.01 222.8,114.07
  BOTTOM w0.089: v1(220.27,134.8) 219.87,135.2 UG14.F2 ; UG1.F36 223.77,113.25 v1(223.62,113.25)
FBA_D51: length 27.5
  IN4 w0.089: v1(224.82,112.45) 224.02,113.25
  IN4 w0.119: 224.02,113.25 224.02,114.35 223.82,114.55 223.52,114.55 223.22,114.85 223.22,117.48 221.74,118.97 219.85,118.97 218.96,119.86 218.96,133.24 219.32,133.6 219.87,133.6 v1(220.27,134)
  BOTTOM w0.089: UG14.E2 219.87,134.4 v1(220.27,134) ; v1(224.82,112.45) 224.97,112.45 UG1.G35
FBA_D52: length 22.5
  IN4 w0.089: 225.62,114.55 v1(226.02,114.15)
  IN4 w0.119: v1(220.27,131.6) 220.67,131.2 221.23,131.2 221.47,130.95 221.47,130.59 221.63,130.43 221.63,120.29 223.4,118.52 225.18,118.52 225.62,118.08 225.62,114.55
  BOTTOM w0.089: v1(220.27,131.6) 219.87,132 UG14.B2 ; UG1.E33 226.17,114.15 v1(226.02,114.15)
FBA_D53: length 22.5
  IN4 w0.089: v1(226.02,113.25) 225.22,114.05
  IN4 w0.119: v1(220.27,130.8) 220.54,130.8 221.16,130.18 221.16,120.09 222.98,118.27 224.83,118.27 225.22,117.88 225.22,114.05
  BOTTOM w0.089: v1(226.02,113.25) 226.17,113.25 UG1.F33 ; v1(220.27,130.8) 219.87,131.2 UG14.A2
FBA_D54: length 22.8
  IN4 w0.089: 226.82,113.65 v1(227.22,113.25)
  IN4 w0.119: v1(221.87,131.6) 222.46,131.01 222.46,130.18 222.7,129.94 222.7,120.56 224.1,119.16 225.56,119.16 226.82,117.9 226.82,113.65
  BOTTOM w0.089: v1(227.22,113.25) 227.37,113.25 UG1.F32 ; v1(221.87,131.6) 221.47,132 UG14.B4
FBA_D55: length 23
  IN4 w0.089: v1(227.22,112.45) 226.42,113.25
  IN4 w0.119: 226.42,113.25 226.42,117.92 225.5,118.84 223.59,118.84 222.11,120.32 222.11,130.56 v1(221.87,130.8)
  BOTTOM w0.089: v1(221.87,130.8) 221.47,131.2 UG14.A4 ; v1(227.22,112.45) 227.37,112.45 UG1.G32
FBA_D56: length 28.9
  IN4 w0.089: 228.81,112.84 v1(228.42,112.45)
  IN4 w0.119: 228.81,112.84 228.81,117 228.55,117.25 228.35,117.25 228.02,117.59 228.02,118.03 228,118.06 228,118.07 227.54,118.53 227.53,118.53 226.24,119.81 224.74,119.81 224.27,120.28 224.27,126.33 224.61,126.68 224.61,134.09 225.73,135.21 226.28,135.21 v1(226.67,135.6)
  BOTTOM w0.089: v1(228.42,112.45) 228.57,112.45 UG1.G30 ; UG14.F11 v1(226.67,135.6)
FBA_D57: length 29
  IN4 w0.089: v1(229.62,110.85) 229.03,111.44
  IN4 w0.119: 229.03,111.44 229.03,112.7 229.06,112.73 229.06,117.1 228.8,117.36 228.8,117.91 228.58,118.13 228.52,118.13 226.47,120.17 225.06,120.17 224.74,120.49 224.74,126.13 225.09,126.48 225.09,132.95 226.67,134.53 v1(226.67,134.8)
  BOTTOM w0.089: UG14.E11 v1(226.67,134.8) ; v1(229.62,110.85) 229.77,110.85 UG1.J29
FBA_D58: length 23.1
  IN4 w0.089: 229.31,114.46 v1(229.62,114.15)
  IN4 w0.119: 229.31,114.46 229.31,117.21 229.05,117.47 229.05,118.01 228.68,118.38 228.62,118.38 226.42,120.58 225.33,120.58 225.22,120.7 225.22,125.94 225.56,126.28 225.56,130.38 225.43,130.51 225.43,131.73 225.62,131.92 226.35,131.92 v1(226.67,131.6)
  BOTTOM w0.089: v1(226.67,131.6) 227.07,132 UG14.B11 ; v1(229.62,114.15) 229.77,114.15 UG1.E29
