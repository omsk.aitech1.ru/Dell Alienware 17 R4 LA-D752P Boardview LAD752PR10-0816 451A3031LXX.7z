# Allegro board LAD752PR10-0816.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
GNDA: length 204.3
  TOP w0.109: v4(17.9,25.01) 18.09,24.82 v1(18.09,24.05) ; v1(24.92,32.57) 25.43,32.06 v4(25.87,32.06)
  TOP w0.127: v1(26.91,35.4) v4(26.11,35.4)
  TOP w0.203: UA3.A2 19.97,22.7 20.39,22.28 20.39,21.6 20.79,21.21 20.79,20.8 21.24,20.34 22.3,20.34 22.54,20.1 v1(22.54,19.69)
  TOP w0.356: RA44.2 21.92,24.99 v1(21.64,24.71) ; v1(21.71,25.56) 22.04,25.89 CA51.1
  TOP w0.381: CA50.2 20.47,24.19 v1(19.95,24.19) ; CA48.2 21.55,21.61 v1(22.45,21.61) 22.79,21.61 RA45.2 ; CA44.1 v1(18.09,24.05)
  TOP w0.508: JACK2.3 7.58,17 v1(6.93,16.35) 6.28,17 JACK2.4 ; v1(26.87,16.8) 26.74,16.92 RA4.1 ; v1(30.17,22.89) 30.17,23.02 29.42,23.77 CA16.2 28.84,24.02 CA17.2 ; RA7.1 v1(14.11,1.8) ; CA30.2 31.76,23.46 CA31.2 v1(32.28,22.05) ; JACK2.6 10.98,26.5 v1(12.33,27.85) ; RA1.1 15.88,27.78 v1(15.78,27.88) ; CA32.2 v1(26.91,35.4) ; RA6.1 28.14,33.43 28.1,33.47 v1(27.96,33.47) ; CA24.2 28.58,27.67 CA25.2 v1(27.72,27.57) ; JACK1.5 14.22,13.8 v1(14.87,14.45) ; CA91.2 v1(18.26,14.99) ; CA92.2 18.13,20.11 17.83,19.81 v1(17.6,19.81)
  GND1 w0.203: JACK1.5 14.55,13.13 ; JACK1.5 12.39,13.13 ; JACK1.5 14.55,13.8 ; JACK1.5 12.39,13.8 ; JACK1.5 13.47,14.47 ; JACK1.5 14.55,14.47 ; JACK1.5 12.39,14.47 ; JACK1.5 13.47,13.13 ; JACK2.4 6.75,16.33 ; JACK2.4 4.59,16.33 ; JACK2.4 4.59,17 ; JACK2.4 5.67,16.33 ; JACK2.4 6.75,17 ; JACK2.3 9.35,16.33 ; JACK2.3 7.19,17 ; JACK2.3 9.35,17 ; JACK2.3 7.19,16.33 ; JACK2.3 8.27,16.33 ; 10.72,25.83 JACK2.6 ; JACK2.6 10.72,27.17 ; JACK2.6 9.64,25.83 ; JACK2.6 11.8,25.83 ; JACK2.6 11.8,27.17 ; JACK2.6 9.64,27.17 ; JACK2.6 11.8,26.5 ; JACK2.6 9.64,26.5
  IN1 w0.254: v1(32.28,22.05) 32.28,24.34 32.08,24.54 32.08,25.87 32.33,26.13 v1(32.82,26.13)
  GND2 w0.203: JACK2.6 11.8,25.83 ; JACK2.6 9.64,25.83 ; JACK2.6 11.8,27.17 ; JACK2.6 10.72,25.83 ; JACK2.6 10.72,27.17 ; JACK2.6 11.8,26.5 ; JACK2.6 9.64,27.17 ; JACK2.6 9.64,26.5 ; 13.47,13.13 JACK1.5 ; JACK1.5 14.55,13.13 ; JACK1.5 12.39,13.13 ; JACK1.5 14.55,14.47 ; JACK1.5 12.39,13.8 ; JACK1.5 13.47,14.47 ; JACK1.5 14.55,13.8 ; JACK1.5 12.39,14.47 ; 5.67,16.33 JACK2.4 ; JACK2.4 6.75,16.33 ; JACK2.4 4.59,16.33 ; JACK2.4 4.59,17 ; JACK2.4 6.75,17 ; 7.19,17 JACK2.3 ; JACK2.3 7.19,16.33 ; JACK2.3 9.35,16.33 ; JACK2.3 8.27,16.33 ; JACK2.3 9.35,17
  VCC w0.203: 7.19,16.33 JACK2.3 ; JACK2.3 8.27,16.33 ; JACK2.3 9.35,16.33 ; JACK1.5 14.55,14.47 ; JACK1.5 13.47,14.47 ; JACK1.5 12.39,14.47 ; 9.64,27.17 JACK2.6 ; JACK2.6 10.72,27.17 ; JACK2.6 11.8,27.17 ; JACK2.4 6.75,16.33 ; JACK2.4 5.67,16.33 ; JACK2.4 4.59,16.33
  GND3 w0.203: 12.39,13.13 JACK1.5 ; JACK1.5 14.55,13.13 ; JACK1.5 14.55,14.47 ; JACK1.5 13.47,13.13 ; JACK1.5 14.55,13.8 ; JACK1.5 12.39,14.47 ; JACK1.5 12.39,13.8 ; JACK1.5 13.47,14.47 ; JACK2.6 11.8,27.17 ; JACK2.6 10.72,25.83 ; JACK2.6 9.64,25.83 ; JACK2.6 9.64,27.17 ; JACK2.6 11.8,25.83 ; JACK2.6 11.8,26.5 ; JACK2.6 9.64,26.5 ; JACK2.6 10.72,27.17 ; JACK2.3 9.35,17 ; JACK2.3 7.19,17 ; JACK2.3 8.27,16.33 ; JACK2.3 7.19,16.33 ; JACK2.3 9.35,16.33 ; 4.59,17 JACK2.4 ; JACK2.4 6.75,16.33 ; JACK2.4 4.59,16.33 ; JACK2.4 6.75,17 ; JACK2.4 5.67,16.33
  GND4 w0.203: JACK2.3 9.35,16.33 ; JACK2.3 9.35,17 ; JACK2.3 8.27,16.33 ; JACK2.3 7.19,16.33 ; JACK2.3 7.19,17 ; JACK2.6 11.8,25.83 ; JACK2.6 10.72,25.83 ; JACK2.6 9.64,25.83 ; JACK2.6 10.72,27.17 ; JACK2.6 9.64,26.5 ; JACK2.6 9.64,27.17 ; JACK2.6 11.8,26.5 ; JACK2.6 11.8,27.17 ; 4.59,17 JACK2.4 ; JACK2.4 5.67,16.33 ; JACK2.4 6.75,17 ; JACK2.4 6.75,16.33 ; JACK2.4 4.59,16.33 ; 13.47,13.13 JACK1.5 ; JACK1.5 12.39,13.13 ; JACK1.5 14.55,13.13 ; JACK1.5 14.55,14.47 ; JACK1.5 12.39,13.8 ; JACK1.5 14.55,13.8 ; JACK1.5 13.47,14.47 ; JACK1.5 12.39,14.47
  GND5 w0.203: 7.19,17 JACK2.3 ; JACK2.3 7.19,16.33 ; JACK2.3 8.27,16.33 ; JACK2.3 9.35,17 ; JACK2.3 9.35,16.33 ; JACK1.5 14.55,13.8 ; JACK1.5 12.39,13.8 ; JACK1.5 13.47,13.13 ; JACK1.5 14.55,14.47 ; JACK1.5 12.39,14.47 ; JACK1.5 14.55,13.13 ; JACK1.5 13.47,14.47 ; JACK1.5 12.39,13.13 ; JACK2.4 6.75,16.33 ; JACK2.4 4.59,17 ; JACK2.4 5.67,16.33 ; JACK2.4 6.75,17 ; JACK2.4 4.59,16.33 ; 9.64,27.17 JACK2.6 ; JACK2.6 11.8,25.83 ; JACK2.6 11.8,27.17 ; JACK2.6 9.64,26.5 ; JACK2.6 9.64,25.83 ; JACK2.6 10.72,25.83 ; JACK2.6 11.8,26.5 ; JACK2.6 10.72,27.17
  BOTTOM w0.203: UA1.20 v1(32.82,26.13) ; v1(27.96,33.47) 27.96,33.43 28.28,33.11 UA1.42 ; UA1.30 28.24,28.31 27.95,28.02 27.95,27.8 v1(27.72,27.57)
  BOTTOM w0.356: v1(18.26,14.99) 18.26,15.11 18.28,15.13 18.28,15.45 18.44,15.6 CA43.2
  BOTTOM w0.381: v1(22.54,19.69) 23.05,19.69 CA42.2 ; v1(26.81,17.81) 27.06,18.07 27.36,18.07 27.82,18.52 CA45.2 27.91,18.65 CA46.2
  BOTTOM w0.508: v1(30.17,22.89) 30.56,22.89 31.31,23.65 CA29.2 31.31,23.73 31.63,24.04 CA28.2 ; v1(27.01,36.5) 27.05,36.54 CA14.2 ; v1(26.91,35.4) 26.97,35.46 CA15.2 ; v1(24.92,32.57) CA33.2 ; v1(25.66,33.41) 25.87,33.62 CA27.2 CA26.2
  vias: v1(23.57,28.16)
VCC_CORE_PT1: length 1.5
  BOTTOM w0.254: PU502.22 156.7,142.2 156.16,142.74 PT1.1
VCC_CORE_PT2: length 1.3
  BOTTOM w0.254: PU503.22 PT2.1
VCC_CORE_PT3: length 1.4
  BOTTOM w0.254: PT3.1 172.96,142.17 PU504.22
VCC_GT_PT1: length 1.7
  BOTTOM w0.254: PU507.22 140.84,145.44 140.09,144.69 PT4.1
VCC_GT_PT2: length 1.2
  BOTTOM w0.254: PU510.22 148.48,145.46 PT5.1
VCC_SA_PT1: length 1.3
  BOTTOM w0.254: PT6.1 180.79,141.39 181.05,141.13 PU511.9
VCCGT_SENSE: length 45.1
  IN2 w0.381: v1(150.76,123.92) 150.38,124.3 140.79,124.3 139.52,125.57 137.74,125.57 136.6,126.71 130.95,126.71 125.23,132.43 122.87,132.43 122.06,133.24 122.06,136.94 v1(121.33,137.66)
  BOTTOM w0.254: CPU1.AH38 152.8,120.47 152.64,120.47 152.14,120.97
  BOTTOM w0.381: 152.14,120.97 151.19,120.97 150.31,121.85 v2(150.31,122.27) 150.31,122.71 150.83,123.22 151.2,123.22 RH203.2 150.9,123.92 v1(150.76,123.92) ; PR531.2 v1(121.33,137.66) 121.34,137.65 PC508.1
VCCIO_PGOOD: length 3.5
  BOTTOM w0.107: v2(124.41,120.11) 124.08,119.78 PR5016.2 122.77,119.09 122.16,119.09 122.01,118.94 PU509.9
VCCIO_SENSE: length 66.7
  IN4 w0.254: v1(168,102.18) 168,103.61 167.74,103.87 167.74,108.12 165.1,110.77 165.1,112.97 165.46,113.33 165.46,122.04 164.54,122.95
  IN4 w0.381: 164.54,122.95 164.46,123.04 164.46,123.4 162.89,124.96 156.99,124.96 156.63,125.32 148.21,125.32 147.83,124.94 137.42,124.94 137.11,125.25 132.09,125.25 130.18,123.35 v1(130.18,122.91)
  BOTTOM w0.254: v1(168,102.18) 168,102.25 CPU1.H14
  BOTTOM w0.381: PR5017.1 124.28,121.76 124.83,121.76 125.98,122.91 v1(130.18,122.91)
VCCSA_SENSE: length 77.7
  IN4 w0.381: v1(133.7,141.17) 133.3,140.77 133.3,134.89 131.85,133.45 131.85,128.73 133.8,126.78 137.74,126.78 138.05,126.46 147.2,126.46 147.58,126.84 157.26,126.84 157.62,126.49 159.94,126.49 160.29,126.84 168.97,126.84 169.07,126.74 170.16,126.74 170.26,126.84 173.36,126.84 v1(173.94,126.27)
  BOTTOM w0.254: CPU1.M38 165.66,120.62 165.24,121.03 165.24,122.97 165.96,123.69 169.35,123.69 170.64,122.39 174.5,122.39 175.27,123.16 175.27,124 RH201.1
  BOTTOM w0.381: RH201.1 174.51,125.51 173.94,126.08 v1(173.94,126.27) ; v1(133.7,141.17) 134.08,141.56 v2(134.08,141.89) 134.08,142.92 PC514.2 133.98,142.92 PR533.2
VCCSENSE: length 52.3
  IN2 w0.381: v1(154.76,123.73) 154.76,125.7 152.22,128.24 142.19,128.24 135.26,135.16 135.26,142.1 130.58,146.78 127.35,146.78 126.18,147.95 v1(126.18,148.45)
  BOTTOM w0.127: v1(126.18,148.45) 126.17,148.46 126.17,148.73 v2(126.44,149)
  BOTTOM w0.254: 154.52,120.96 154.26,120.7 154.26,119.83 154,119.56 CPU1.AG37
  BOTTOM w0.381: v1(126.18,148.45) 126.17,148.43 PC533.1 126.17,146.95 PR550.1 ; v1(154.76,123.73) 155.28,123.73 RH197.2 155.4,123.42 155.01,123.03 155.01,121.94 154.52,121.45 154.52,120.96
VDD_1.2V: length 4.9
  BOTTOM w0.203: 93.72,41.88 93.47,42.13 PU201.11
  BOTTOM w0.254: PR201.1 PR203.2 PC212.1 94.94,41.12 94.18,41.88 93.72,41.88
VDDC_FB_H: length 103.9
  IN3 w0.091: 261.19,69.73 262.67,69.73 266.33,66.07 272.34,66.07 273.25,65.16 273.25,59.44 277.06,55.63 277.06,52.17 277.82,51.4 278.96,51.4 280.23,50.13 280.23,48.67 281.63,47.28 284.33,47.28 284.34,47.27 286.35,47.27 288.11,49.03 288.11,49.75 288.55,50.2 290.46,50.2 290.9,50.64 290.9,51.53 292.43,53.05 292.43,61.82 v1(290.93,63.31)
  IN3 w0.102: 261.19,69.73 245.57,69.73 239.15,76.16 239.15,77.2 v1(238.39,77.96) 238.39,78.26 237.62,79.03 237.62,89.15 v1(238.02,89.55)
  BOTTOM w0.089: PR6037.2 239.59,77.76 238.59,77.76 v1(238.39,77.96)
  BOTTOM w0.1: v1(238.02,89.55) 237.87,89.55 UG1.AL21
  BOTTOM w0.254: v1(290.93,63.31) 290.9,63.28 PR6039.1
VDDC_FB_L: length 104.6
  IN1 w0.097: v1(289.51,49.5) 289.51,51.15 292.57,54.22 292.57,60.47 294.19,62.08 v1(294.53,62.08)
  IN3 w0.091: v1(289.51,49.5) 289.06,49.94 288.62,49.94 288.36,49.69 288.36,48.9 286.51,47.05 281.54,47.05 280.01,48.58 280.01,50.04 278.87,51.18 277.73,51.18 276.84,52.07 276.84,55.55 273.02,59.36 273.02,65.03 272.23,65.82 266.2,65.82 262.62,69.4 261.08,69.4
  IN3 w0.102: v1(238.02,90.35) 237.41,89.74 237.41,78.61 237.75,78.26 v1(237.75,77.96) 238.92,76.79 238.92,76.06 245.58,69.4 261.08,69.4
  BOTTOM w0.089: v1(237.75,77.96) 238.21,77.5 239.15,77.5 239.52,77.13 PR6045.1
  BOTTOM w0.1: v1(238.02,90.35) 237.87,90.35 UG1.AK21
  BOTTOM w0.254: PR6041.1 v1(294.53,62.08)
VDDCI_FB: length 91.8
  TOP w0.089: PR6067.2 236.82,90.92 v1(236.82,90.35)
  TOP w0.254: v1(288.81,49.5) 288.31,49.99 PR6071.1
  IN3 w0.091: 261.65,69.18 261.35,69.18 261.34,69.17 ; v1(288.81,49.5) 288.81,49.03 286.61,46.83 281.38,46.83 279.74,48.47 279.74,49.93 278.76,50.91 277.62,50.91 276.57,51.96 276.57,55.51 272.8,59.27 272.8,64.93 272.23,65.5 266.2,65.5 262.53,69.18 262.02,69.18
  IN3 w0.102: 262.02,69.18 261.65,69.18 ; 261.34,69.17 245.49,69.17 241.33,73.32 238.75,73.32 238.3,73.78 238.3,76.78 237.33,77.74 237.33,78.18 236.42,79.09 236.42,89.95 v1(236.82,90.35)
  BOTTOM w0.1: UG1.AK23 236.67,90.35 v1(236.82,90.35)
VIN: length 124
  TOP w0.254: v1(54.3,26.32) 54.3,26.38 54.96,27.04 PR716.1 ; PR729.2 122.63,76.58 121.88,75.83 119.99,75.83 118.9,76.92 PR732.1 118.63,73.95 v1(116.09,71.41) ; 70.11,32.8 v4(69.29,31.97)
  IN1 w0.254: v1(116.09,71.41) 115.45,70.77 108.59,70.77 103.12,65.29 103.12,61.21 93.76,51.85 93.76,51 88.89,46.13 74.7,46.13 73.86,45.29 v1(73.86,33.75)
  IN1 w0.508: v1(71.32,32.48) 71.32,30.64 68.02,27.34 62.56,27.34 60.52,25.31 v1(60.52,25.05)
  IN3 w0.457: v1(59.13,19.97) 58.85,19.97
  IN3 w0.508: 58.85,19.97 58.27,20.55 58.25,20.55 57.9,20.91 57.9,21.42 58.25,21.77 58.77,21.77 59.19,22.19 59.19,23.53 58.75,23.97 57.6,23.97 57.22,24.35 54.81,24.35 54.3,24.86 v1(54.3,26.32)
  IN4 w0.508: v1(60.52,25.05) 60.52,25.18 59.76,25.94 58.3,25.94 57.92,26.32 v1(54.3,26.32)
  BOTTOM w0.457: v1(59.13,19.97) 58.82,19.67 PD700.3
  BOTTOM w0.508: PD101.2 56.08,17.37 55.15,18.29 55.15,19.42 55.7,19.97 58.07,19.97 PD700.3
  vias: v1(71.32,33.75) v1(71.32,33.12) v1(71.95,33.75) v1(71.95,33.12) v1(71.95,32.48) v1(72.59,33.75) v1(72.59,33.12) v1(72.59,32.48) v1(73.22,33.75) v1(73.22,33.12) v1(73.22,32.48) v1(73.86,33.12) v4(76.72,38.32) v4(76.72,34.83)
VSSGT_SENSE: length 50.7
  TOP w0.127: v2(121.23,141) 121.43,140.8 v1(121.96,140.8)
  TOP w0.381: PC513.1 121.96,140.33 v1(121.96,140.8)
  IN2 w0.381: v1(121.96,140.8) 121.48,140.33 121.48,138.78 122.82,137.45 122.82,133.56 123.19,133.19 125.55,133.19 131.26,127.48 137.12,127.48 138.14,126.46 139.77,126.46 141.17,125.06 150.98,125.06 v1(152.12,123.92)
  BOTTOM w0.203: PU500.6 122.04,140.88 v1(121.96,140.8)
  BOTTOM w0.254: CPU1.AH37 153.17,119.56 153.48,119.87 153.48,120.44 152.96,120.96
  BOTTOM w0.381: 152.96,120.96 152.08,121.84 152.08,123.07 152.41,123.4 RH472.1 152.84,123.54 152.46,123.92 v1(152.12,123.92)
VSSIO_SENSE: length 65.1
  IN4 w0.254: 163.71,123.06 165.12,121.66 165.12,113.5 164.72,113.1 164.72,110.67 166.77,108.62 166.77,104.36 167.19,103.94 v1(167.19,102.6)
  IN4 w0.381: v1(130.94,122.91) 132.53,124.49 136.72,124.49 137.04,124.17 148.34,124.17 148.73,124.56 155.14,124.56 155.52,124.17 162.6,124.17 163.71,123.06
  BOTTOM w0.254: v1(167.19,102.6) 167.71,102.6 CPU1.J14
  BOTTOM w0.381: v1(130.94,122.91) 130.94,123.35 130.5,123.8 v2(128.6,123.8) 125.4,123.8 124.16,122.55 PR5018.1
VSSSA_SENSE: length 77.2
  TOP w0.254: PC515.1 131.39,139.8 131.74,140.15 131.74,140.51 v1(131.36,140.88)
  IN4 w0.381: v1(131.36,140.88) 131.39,140.88 132.41,139.87 132.41,135.29 131.07,133.95 131.07,128.56 131.09,128.54 131.09,128.42 133.49,126.02 137.42,126.02 137.74,125.7 147.52,125.7 147.9,126.08 156.95,126.08 157.3,125.72 160.25,125.72 160.61,126.08 168.66,126.08 168.76,125.98 170.48,125.98 170.58,126.08 172.86,126.08 v1(173.3,125.64)
  BOTTOM w0.203: v1(131.36,140.88) PU500.31
  BOTTOM w0.254: 173.6,124.76 173.11,124.76 172.72,124.37 165.62,124.37 164.66,123.41 v2(164.66,122.9) 164.66,121.12 165.29,120.5 165.29,119.93 CPU1.M37
  BOTTOM w0.381: v1(173.3,125.64) 173.3,125.44 173.6,125.14 173.6,124.76 RH469.1
VSSSENSE: length 49
  TOP w0.381: v1(126.08,145.39) 126.08,145.18 126.64,144.62 PC534.1
  IN2 w0.381: v1(126.08,145.39) 126.08,145.6 126.5,146.02 130.26,146.02 134.37,141.91 134.37,134.97 141.87,127.48 151.65,127.48 153.87,125.25 153.87,124.15 v1(153.73,124.01)
  BOTTOM w0.203: PU500.18 126.27,145.19 v1(126.08,145.39)
  BOTTOM w0.254: CPU1.AG38 153.84,121.16
  BOTTOM w0.381: v1(153.73,124.01) RH466.1 153.95,123.4 154.44,122.9 154.44,122.19 153.84,121.6 153.84,121.16
+CODEC_AVDD2: length 14.4
  TOP w0.508: v1(29.1,22.94) 29.1,22.83 28.98,22.7 27.57,22.7 27.06,23.21 v2(27.06,23.84) 27.06,24.35 27.63,24.92 CA17.1 29.41,24.92 CA16.1
  IN4 w0.508: v1(29.1,22.94) 29.1,23.97 v1(30.88,25.75)
  BOTTOM w0.203: UA1.24 31.22,26.08 v1(30.88,25.75)
  BOTTOM w0.356: LA4.1 30.83,22.26 RA12.1
  BOTTOM w0.508: LA4.1 30.29,21.76 v1(29.1,22.94)
+EC_VCCA: length 25.5
  TOP w0.109: v4(287.41,27.36) 287.6,27.17 LE1.2
  TOP w0.508: CE33.1 v1(286.84,11.08)
  IN1 w0.508: v1(293.75,9.43) 293.46,9.14 288.78,9.14 v1(286.84,11.08)
  BOTTOM w0.508: v1(286.84,11.08) 287.73,11.97 287.73,13.3 287.45,13.59 287.45,24.9 v1(286.67,25.67)
+FBA_VREFCH: length 5.7
  TOP w0.089: v2(229.34,137.48) 229.16,137.48 229.07,137.57 v1(229.07,138)
  TOP w0.508: v1(229.07,138) 229.08,138 230.02,138.94 CG145.1 RG101.1 RG99.2 CG143.2
  BOTTOM w0.305: v1(229.07,138) 229.47,137.6 UG14.J14
+FBA_VREFCL: length 5.5
  BOTTOM w0.305: UG13.J14 205.04,137.64 v2(203.59,137.64) 203.31,137.91 CG144.1
  BOTTOM w0.508: CG144.1 RG100.1 RG98.2 CG142.2
+FBA_VREFDH: length 26.5
  BOTTOM w0.107: v2(227.59,128.97) CG140.1
  BOTTOM w0.305: CG138.2 224.55,130.54 224.86,130.84 225.92,130.84 UG14.A10 225.99,131.49 225.25,131.49 224.63,132.1 224.63,137.36 223.88,138.12 223.88,140.6 223.94,140.65 223.94,144.01 224.31,144.39 RG94.2 ; 224.92,146.17 225.94,145.14 225.94,144.33 UG14.U10
  BOTTOM w0.381: 224.92,146.17 RG94.2
  BOTTOM w0.508: CG138.2 224.58,128.96 RG97.1 225.45,128.97 CG140.1
+FBA_VREFDL: length 20.8
  BOTTOM w0.305: RG96.1 v2(209.55,129.83) 209.55,130.69 209.21,131.03 208.44,131.03 UG13.U10 208.3,131.2 208.34,131.24 208.34,131.27 209.3,132.24 209.3,143.77 208.96,144.11 208.39,144.11 UG13.A10
  BOTTOM w0.508: CG139.2 CG141.1 RG96.1 RG95.2
+FBB_VREFCH: length 5.3
  BOTTOM w0.305: UG16.J14 v2(258.96,137.6) 259.65,138.29 CG186.1
  BOTTOM w0.508: CG184.2 RG112.2 RG114.1 CG186.1
+FBB_VREFCL: length 12.7
  TOP w0.107: v2(232.23,145.76) 232.32,145.67 v1(232.86,145.67)
  TOP w0.508: CG187.1 233.41,138.06 v1(233.47,138) ; v1(232.86,145.67) 233.33,145.2 RG115.1 RG113.2 CG185.2
  IN4 w0.508: v1(232.86,145.67) 232.86,138.6 233.46,138 v1(233.47,138)
  BOTTOM w0.305: UG15.J14 v1(233.47,138)
+FBB_VREFDH: length 22
  TOP w0.305: v1(253.89,131.63) 251.84,133.68 251.84,134.85 251.28,135.41 v2(251.28,138.65) 251.28,141.32 253.4,143.44 253.4,143.91 v1(253.88,144.39)
  BOTTOM w0.305: UG16.U10 v1(253.88,144.39) 253.88,144.94 253.86,144.96 RG108.2 ; CG182.1 254.33,129.95 254.1,130.18 254.1,131.02 UG16.A10 253.89,131.59 v1(253.89,131.63)
  BOTTOM w0.508: CG182.1 RG110.1 CG180.2
+FBB_VREFDL: length 19.4
  TOP w0.089: v1(236.55,144.43) 236.23,144.11 v2(236.23,143.99)
  TOP w0.508: v1(236.55,144.43) 236.5,144.47 236.5,144.73 236.36,144.87 CG183.1 RG111.1 RG109.2 CG181.2
  BOTTOM w0.305: UG15.U10 237.14,132.07 237.14,133.6 237.94,134.4 237.94,139.35 237.25,140.04 237.25,144.23 237.05,144.43 v1(236.55,144.43) 236.5,144.39 236.5,144.23 UG15.A10
+FBC_VREFCH: length 5.9
  TOP w0.107: v2(279.37,99.22) 279.14,99.22 RG127.2
  TOP w0.457: CG229.1 276.54,101 v1(275.72,101.81)
  TOP w0.508: CG229.1 RG129.1 277.42,100.02 CG227.2 RG127.2
  BOTTOM w0.305: v1(275.72,101.81) 275.32,101.41 UG18.J14
+FBC_VREFCL: length 5.3
  BOTTOM w0.305: UG17.J14 275.39,125.88 v2(275.39,127.35) CG228.1
  BOTTOM w0.508: CG228.1 RG128.1 RG126.2 CG226.2
+FBC_VREFDH: length 19.9
  BOTTOM w0.305: UG18.U10 281.72,104.61 281.79,104.68 281.79,105.29 281.16,105.92 280.01,105.92 279.65,106.28 270.67,106.28 269,104.61 UG18.A10 268.77,104.61 267.85,105.53 v2(267.66,105.53) CG224.1
  BOTTOM w0.508: CG222.2 RG123.2 RG124.1 CG224.1
+FBC_VREFDL: length 20.1
  TOP w0.305: v1(282.12,122.21) 281.54,121.63 v2(271.6,121.63) 269.35,121.63 v1(268.92,122.07)
  BOTTOM w0.305: UG17.U10 268.92,122.07 v1(268.92,122.07) 268.71,121.86 267.64,121.86 CG225.1 ; UG17.A10 v1(282.12,122.21)
  BOTTOM w0.508: CG223.2 RG122.2 RG125.1 CG225.1
+FBD_VREFCH: length 4.8
  TOP w0.508: RG143.1 RG141.2 CG269.2 CG271.1 276.79,72.74 276.29,73.24 276.28,73.24 275.95,73.58 275.95,73.58 v1(275.72,73.81)
  BOTTOM w0.305: UG20.J14 275.32,73.41 v1(275.72,73.81)
+FBD_VREFCL: length 4.1
  BOTTOM w0.107: v1(285.39,96.36) v2(286.11,96.36)
  BOTTOM w0.305: UG19.J14 275.32,97.81 v1(275.72,97.41)
  BOTTOM w0.508: CG270.1 283.81,99.22 v1(283.23,99.22) ; v1(285.39,96.36) RG140.2 CG268.2 ; v1(283.23,98.33) 283.81,98.33 RG142.1
+FBD_VREFDH: length 20.9
  BOTTOM w0.305: CG267.1 v2(267.66,77.49) 267.93,77.49 268.81,76.61 UG20.A10 269.04,76.61 271.07,78.65 281.12,78.65 282.08,77.69 282.08,76.97 UG20.U10
  BOTTOM w0.508: CG267.1 RG139.1 RG137.2 CG265.2
+FBD_VREFDL: length 21.6
  BOTTOM w0.305: CG266.1 v2(267.66,94.61) 267.77,94.61 267.83,94.54 268.85,94.54 UG19.U10 271.62,91.92 281.19,91.92 282.14,92.87 282.14,94.2 UG19.A10
  BOTTOM w0.508: CG266.1 RG138.1 RG136.2 CG264.2
+HDMI_5V_OUT:
  vias: v2(220.9,168.93)
+INV_PWR_SRC:
  vias: v1(157.17,171.72) v1(157.79,171.74) v1(158.37,171.74) v1(158.77,179.22) v1(158.95,171.74) v1(170.06,182.79) v1(170.65,182.79) v1(171.23,182.79) v1(171.81,182.79) v4(171.32,182.21)
+LAN_IO: length 61.9
  TOP w0.508: CL16.1 238.26,151.92 CL17.1 238.97,152.75 v1(239.44,153.22)
  TOP w1.016: 257.95,159.61 256.23,157.89 256.23,151.23 253.06,148.05 248.8,148.05 245.12,151.73 v4(245.12,161.63) 245.12,164.69 244.74,165.07
  IN1 w1.016: 232.93,159.86 232.72,160.07 231.47,160.07 231.39,159.99 230.92,159.99 230.26,160.65 230.26,163.33 231.02,164.09 231.02,165.22 231.97,166.17 237.8,166.17 239.1,167.47 240.61,167.47 241.61,166.47 242.32,166.47
  BOTTOM w0.203: v1(239.44,153.22) UL1.16
  BOTTOM w0.508: v1(234.5,159.42) 234.57,159.35 RL2.1 RL1.1
  vias: v1(231.09,150.97) v1(231.72,150.97) v1(232.33,157.18) v1(233.89,159.42) v1(243.72,165.7) v1(243.72,165.07) v1(258.77,160.88) v1(258.77,160.24) v1(260.3,162.27) v1(260.93,162.27)
+LCDVDD:
  vias: v1(163.62,181.26) v1(164.22,181.26) v1(164.41,170.21) v1(164.41,169.58) v1(164.41,168.94) v1(164.8,181.26) v4(164.27,168.08)
+RBIAS: length 3.8
  BOTTOM w0.102: RL3.1 v2(240.03,155.85)
  BOTTOM w0.203: UL1.10 237.89,156.43 238.28,156.82 238.73,156.82
  BOTTOM w0.508: 238.73,156.82 239.29,156.82 239.31,156.84 RL3.1
+RTC_CELL: length 347.8
  TOP w0.102: v4(214.16,29.21) 214.16,29.71 v1(214.08,29.79)
  TOP w0.356: v1(39.49,28.29) 39.06,28.29 38.55,28.79 RA25.1
  TOP w0.381: RH83.1 215.93,34.15 RH531.2
  TOP w0.508: v1(214.08,29.79) 213.72,29.79 212.99,29.06 CH80.1 CH173.1 ; RH84.1 216.13,35.88 215.05,35.88 v1(215.03,35.86) 215.01,35.84 215.01,35.58 215.69,34.9 RH531.2
  IN2 w0.508: v1(214.08,29.79) 214,29.79 212.15,27.94 211.55,27.94 211.21,27.61 211.21,26.58 210.37,25.74 209.04,25.74 208.61,25.31 206.51,25.31 206.14,24.93 206.14,24.43 205.57,23.86 204.53,23.86 203.75,24.63 202.78,24.63 201.66,25.75 194.89,25.75 192.73,27.91 187.97,27.91 186.16,29.72 177.69,29.72 168.02,20.06 119.97,20.06 119.11,19.2 103.32,19.2 102.85,18.74 101.3,18.74 99.7,17.14 97.78,17.14 96.52,15.88 85.02,15.88 83.59,14.45 69.35,14.45 67.76,12.86 63.09,12.86 62.76,13.19 56.89,13.19 54.48,15.6 46.48,15.6 45.83,16.25 44.68,16.25 39.73,21.2 34.58,21.2 33.8,21.98 33.8,23.6 34.4,24.2 34.98,24.2 37.07,26.29 37.07,26.98 38.38,28.29 v1(39.49,28.29) ; v1(293.76,17.48) 278.84,17.48 274.48,21.84 272.59,21.84 271.6,22.82 268.43,22.82 267.98,23.27 264.99,23.27 264.74,23.53 262.59,23.53 258.15,19.08 254.1,19.08 253.62,19.56 252.65,19.56 252.07,18.98 233.53,18.98 229.61,22.9 229.23,22.9 226.34,25.8 226.34,26.71 226.85,27.23 226.85,28.33 226.32,28.86 225.4,28.86 224.48,29.78 224.48,30.51 222.78,32.21 220.21,32.21 218.88,33.54 216.69,33.54 215.91,34.32 215.91,34.98 v1(215.03,35.86)
  IN3 w0.381: v1(214.08,29.79) 215.91,31.61 215.91,34.98 v1(215.03,35.86)
  BOTTOM w0.203: UH1.BA22 214.51,29.4 214.26,29.75 v1(214.08,29.79)
  BOTTOM w0.508: PD5.1 284.34,32.93 284.34,34.19 284.45,34.3 284.45,35.54 284.94,36.02 284.94,37.03 285.57,37.66 287.95,37.66 289.53,36.08 290.1,36.08 291.66,34.52 291.66,30.19 294.59,27.27 294.59,23.34 293.76,22.51 v1(293.76,17.48)
+TBTA_VBUS: length 2.9
  BOTTOM w0.254: v1(202.8,159.44) 202.66,159.59 UT4.A10 UT4.B10 ; v1(194.11,178.88) 194.11,178.98 193.85,179.24 JUSBC1.B4 ; v1(191.19,178.79) 191.19,179.08 191.35,179.24 JUSBC1.B9
  vias: v1(191.65,177.03) v1(191.65,176.45) v1(193.68,176.9) v1(193.68,176.31) v1(203.12,158.95) v1(203.77,164.66) v1(203.77,164.03) v1(204.35,164.66) v1(204.35,164.03) v2(205.3,164.24)
+TSVDD: length 8.4
  TOP w0.3: CG43.1 232.58,82.99 232.58,84.03 232.48,84.13 v2(232.48,84.55) 232.49,84.56 232.49,85.92 232.06,86.35 v1(232.02,86.35)
  TOP w0.305: CG43.1 CG42.1 231.05,79.7 LG1.2
  BOTTOM w0.4: v1(232.02,86.35) 232.17,86.35 UG1.AR26
+V_DDR_REFA: length 6.7
  TOP w0.127: v2(155.33,50.26) 155.11,50.04 v1(154.63,50.04)
  TOP w0.508: CD18.1 154.45,50.22 v1(154.63,50.04) ; CD18.1 RH209.1 RH484.2 ; CD18.1 RH206.2
  BOTTOM w0.305: JDIMM1.164 154.44,50.8 154.37,50.73 154.37,50.3 v1(154.63,50.04)
+V_DDR_REFA_R: length 65.3
  TOP w0.089: v1(134.63,102.05) 134.38,102.05 v2(134.11,101.77)
  TOP w0.508: CH101.1 155.95,53.57 v1(156.36,53.16) 156.47,53.04 156.47,52.77 156.23,52.53 RH484.1
  IN3 w0.508: v1(134.63,102.05) 134.4,102.05 134.05,101.7 134.05,100.97 134.69,100.34 134.69,97.7 135.26,97.13 140.4,97.13 141.04,96.49 141.04,74.35 152.94,62.45 153.49,62.45 155.07,60.87 155.07,53.63 155.65,53.05 156.25,53.05 v1(156.36,53.16)
+V_DDR_REFB: length 5.6
  TOP w0.508: v1(154.29,40.6) 154.44,40.45 CD29.1 RH210.1 RH485.2 RH207.2
  BOTTOM w0.305: JDIMM2.164 154.44,40.44 v1(154.29,40.6)
+V_DDR_REFB_R: length 78.2
  TOP w0.127: v1(152.66,36.94) 152.33,36.61 v2(152.03,36.61)
  TOP w0.508: RH485.1 CH100.1 v1(152.66,36.94)
  IN3 w0.508: v1(152.66,36.94) 152.66,38.13 152.09,38.7 152.09,43.66 151.77,43.97 151.77,48.23 151.39,48.61 151.39,52.36 151.77,52.74 151.77,62.18 140.02,73.93 140.02,84.72 136.4,88.34 136.4,90.17 138.02,91.78 138.02,93.19 137.63,93.57 135.13,93.57 133.81,94.9 133.81,98.42 132.81,99.42 132.81,100.73 v1(133.33,101.25)
+VGA_CORE: length 232.4
  TOP w0.254: 241.18,89.95 241.39,89.95 241.58,90.14 241.59,90.14 242.06,90.62 242.06,90.98 241.6,91.44 CG108.1
  TOP w0.381: CG106.1 228.98,94.4 228.99,94.39
  BOTTOM w0.4: v1(234.42,91.05) UG1.AJ25
  BOTTOM w0.5: UG1.AE17 v1(242.32,95.1) ; UG1.AE17 v1(241.32,96.1) UG1.AD17 ; UG1.AE17 242.32,96.1 ; v1(242.32,95.1) UG1.AE16 242.32,96.1 ; v1(242.32,95.1) UG1.AF16 v1(242.32,94.1) ; v1(242.32,95.1) UG1.AF17 ; v1(230.32,100.1) UG1.AA29 v1(230.32,99.1) ; v1(230.32,100.1) UG1.Y29 230.32,101.1 ; v1(230.32,100.1) UG1.Y28 ; v1(230.32,100.1) UG1.AA28 ; UG1.AC24 234.97,97.75 234.97,98.45 UG1.AB24 ; UG1.AC24 234.32,98.1 ; UG1.AC24 234.32,97.1 ; UG1.U20 v1(239.32,104.1) UG1.T20 238.32,104.1 ; UG1.U20 238.32,104.1 ; UG1.U20 v1(238.32,103.1) ; v1(234.32,103.1) UG1.V24 ; v1(234.32,103.1) UG1.U25 ; v1(234.32,103.1) UG1.U24 ; v1(234.32,103.1) UG1.V25 ; UG1.V24 v1(234.32,102.1) ; UG1.V24 v1(235.32,103.1) UG1.U24 ; v1(230.32,98.1) UG1.AB28 ; v1(230.32,98.1) UG1.AC28 ; v1(230.32,98.1) UG1.AB29 v1(230.32,99.1) ; v1(230.32,98.1) UG1.AC29 v1(230.32,97.1) ; UG1.AB28 v1(231.33,99.11) 231.31,99.11 UG1.AA28 ; UG1.AB28 231.04,98.38 231.04,97.82 UG1.AC28 ; UG1.AB28 v1(230.32,99.1) ; 238.32,93.1 UG1.AG21 ; 238.32,93.1 UG1.AH21 ; 238.32,93.1 UG1.AH20 ; 238.32,93.1 UG1.AG20 ; UG1.AG21 v1(237.32,93.1) ; UG1.AG21 238.32,94.1 ; UG1.AG21 237.34,94.08 ; v1(230.32,92.1) UG1.AH29 v1(230.32,93.1) ; v1(230.32,92.1) UG1.AJ28 230.85,91.6 v1(231.34,92.1) ; v1(230.32,92.1) UG1.AH28 ; v1(235.32,92.1) UG1.AH24 ; v1(235.32,92.1) UG1.AJ23 v1(236.32,92.1) ; v1(235.32,92.1) UG1.AH23 ; v1(235.32,92.1) UG1.AJ24 ; UG1.AH24 234.32,92.1 ; UG1.AH24 v1(235.32,93.1) ; UG1.AH24 v1(234.32,93.1) ; UG1.W17 v1(241.32,102.1) UG1.V17 ; UG1.W17 242.32,102.1 ; UG1.W17 v1(242.32,101.1) ; UG1.W17 v1(241.32,101.1) UG1.Y17 ; UG1.AF25 v1(234.32,94.1) ; UG1.AF25 v1(233.32,94.1) UG1.AG25 ; UG1.AF25 v1(234.32,95.1) ; UG1.AF25 v1(233.32,95.1) UG1.AE25 ; v1(234.32,94.1) UG1.AG24 ; v1(234.32,94.1) UG1.AG25 ; v1(234.32,94.1) UG1.AF24 v1(234.32,95.1) ; v1(242.32,94.1) UG1.AG17 ; v1(242.32,94.1) UG1.AF17 ; UG1.AG17 v1(241.32,93.1) UG1.AH18 v1(240.32,92.1) ; UG1.AG17 v1(241.32,94.1) UG1.AF17 ; 237.34,94.08 v1(237.35,94.08) ; 237.34,94.08 237.3,94.08 UG1.AF21 238.32,94.1 ; v1(242.32,100.1) UG1.Y16 v1(242.32,101.1) ; v1(242.32,100.1) UG1.Y17 ; v1(242.32,100.1) UG1.AA16 v1(242.32,99.1) ; v1(242.32,100.1) UG1.AA17 ; v1(238.32,103.1) UG1.V21 ; v1(238.32,103.1) UG1.V20 v1(238.32,102.1) ; v1(238.32,103.1) UG1.U21 ; UG1.V21 237.37,102.15 v1(237.37,102.08) 237.37,102.05 UG1.W21 ; UG1.V21 v1(237.32,103.1) UG1.U21 ; UG1.V21 v1(238.32,102.1) ; v1(237.32,93.1) UG1.AH21 ; v1(237.32,93.1) UG1.AH22 ; v1(234.32,99.03) 234.25,99.03 UG1.AB25 ; v1(234.32,99.03) 234.82,99.52 UG1.AA24 234.32,100.1 ; v1(234.32,99.03) 234.39,99.03 UG1.AB24 ; v1(234.32,99.03) 233.82,99.53 UG1.AA25 ; 238.32,100.1 UG1.Y21 ; 238.32,100.1 UG1.Y20 v1(238.32,101.1) ; 238.32,100.1 UG1.AA20 ; 238.32,100.1 UG1.AA21 ; UG1.Y21 v1(238.32,101.1) ; UG1.Y21 237.33,100.11 ; UG1.Y21 v1(237.32,101.1) UG1.W21 ; 230.32,101.1 UG1.W28 230.97,101.75 230.97,102.45 UG1.V28 ; 230.32,101.1 UG1.W29 ; 230.32,101.1 UG1.Y28 ; v1(240.32,92.1) UG1.AJ19 v1(239.32,92.1) ; v1(240.32,92.1) UG1.AH19 ; v1(239.32,92.1) UG1.AH20 ; v1(239.32,92.1) UG1.AH19 ; v1(239.32,92.1) UG1.AJ20 v1(238.32,92.1) ; UG1.AC17 242.32,98.1 ; UG1.AC17 v1(241.32,98.1) UG1.AB17 ; UG1.AC17 v1(241.32,97.1) UG1.AD17 ; UG1.AC17 v1(242.32,97.1) ; 242.32,98.1 UG1.AB16 v1(242.32,99.1) ; 242.32,98.1 UG1.AB17 ; 242.32,98.1 UG1.AC16 ; 238.32,96.1 UG1.AE20 v1(239.32,95.1) UG1.AF20 ; 238.32,96.1 UG1.AD20 238.32,97.1 ; 238.32,96.1 UG1.AE21 ; 238.32,96.1 UG1.AD21 ; 237.33,100.11 237.31,100.11 UG1.AA21 ; 237.33,100.11 v1(237.36,100.11) ; UG1.AH26 232.32,92.1 ; UG1.AH26 v1(232.32,93.1) UG1.AH27 ; UG1.AH26 v1(233.32,93.1) ; 232.32,92.1 UG1.AJ27 v1(231.34,92.1) ; 232.32,92.1 UG1.AH27 ; UG1.AB21 237.62,98.4 237.62,97.8 UG1.AC21 ; UG1.AB21 v1(237.32,99.1) UG1.AA21 ; UG1.AB21 238.32,98.1 ; UG1.AD28 231.29,97.07 v1(231.35,97.07) UG1.AC28 ; UG1.AD28 230.32,96.1 ; UG1.AD28 v1(230.32,97.1) ; UG1.V25 v1(233.32,102.1) UG1.W25 ; UG1.V25 v1(234.32,102.1) ; UG1.V25 v1(233.32,103.1) UG1.U25 ; UG1.U25 234.32,104.1 ; UG1.AJ24 234.32,92.1 ; UG1.AJ24 v1(234.42,91.05) ; 234.32,92.1 UG1.AJ25 233.82,91.69 v1(233.4,92.11) 232.89,91.6 UG1.AJ26 ; 234.32,92.1 UG1.AH25 ; v1(231.34,92.1) 231.82,92.57 UG1.AH27 ; v1(231.34,92.1) UG1.AH28 ; UG1.AH20 v1(238.32,92.1) ; UG1.AH20 v1(239.32,93.1) ; 242.32,102.1 UG1.V16 v1(242.32,103.1) ; 242.32,102.1 UG1.W16 v1(242.32,101.1) ; 242.32,102.1 UG1.V17 ; v1(230.32,95.1) UG1.AF29 230.32,94.1 ; v1(230.32,95.1) UG1.AE29 230.32,96.1 ; v1(230.32,95.1) UG1.AF28 ; v1(230.32,95.1) UG1.AE28 ; UG1.AH28 v1(231.33,93.13) ; UG1.AH28 v1(230.32,93.1) ; UG1.Y17 v1(242.32,101.1) ; 230.32,94.1 UG1.AG28 ; 230.32,94.1 UG1.AF28 ; 230.32,94.1 UG1.AG29 v1(230.32,93.1) ; UG1.AG28 v1(231.32,94.1) UG1.AF28 ; UG1.AG28 v1(230.32,93.1) ; UG1.AG28 230.85,93.6 v1(231.33,93.13) ; UG1.AB17 v1(241.32,99.1) UG1.AA17 ; UG1.AB17 v1(242.32,99.1) ; 242.32,96.1 UG1.AD17 ; 242.32,96.1 UG1.AD16 ; UG1.AD17 v1(242.32,97.1) ; v1(238.32,101.1) UG1.W20 v1(238.32,102.1) ; v1(238.32,101.1) UG1.W21 ; 242.32,104.1 UG1.T17 v1(241.32,104.1) UG1.U17 ; 242.32,104.1 UG1.U16 v1(242.32,103.1) ; 242.32,104.1 UG1.U17 ; 242.32,104.1 UG1.T16 ; UG1.AH19 v1(239.32,93.1) ; UG1.AH21 v1(237.32,92.1) ; UG1.AH21 v1(238.32,92.1) ; v1(238.32,92.1) UG1.AJ21 v1(237.32,92.1) ; 234.32,97.1 UG1.AD24 234.32,96.1 ; 234.32,97.1 UG1.AD25 ; 234.32,97.1 UG1.AC25 ; UG1.AH25 v1(233.32,93.1) ; UG1.AH25 v1(234.32,93.1) ; v1(233.32,93.1) UG1.AG25 ; v1(242.32,97.1) UG1.AD16 ; v1(242.32,97.1) UG1.AC16 ; UG1.AD16 v1(243.32,97.1) UG1.AC16 ; v1(235.32,105.1) UG1.T24 234.32,104.1 ; v1(242.32,99.1) UG1.AA17 ; 238.32,104.1 UG1.U21 ; 238.32,104.1 UG1.T21 v1(237.32,104.1) UG1.U21 ; UG1.W21 v1(238.32,102.1) ; 234.32,104.1 UG1.U24 ; 234.32,104.1 UG1.T25 ; UG1.AE28 v1(231.32,95.1) UG1.AF28 ; UG1.AE28 230.32,96.1 ; UG1.U17 v1(242.32,103.1) ; UG1.AB24 234.32,98.1 ; UG1.AB24 v1(235.32,99.1) ; v1(230.32,99.1) UG1.AA28 ; 230.32,96.1 UG1.AD29 v1(230.32,97.1) ; 234.32,98.1 UG1.AC25 ; 234.32,98.1 UG1.AB25 ; UG1.AC25 233.67,97.75 233.67,98.45 UG1.AB25 ; UG1.AC25 233.31,97.09 v1(233.31,97.06) 233.36,97.06 UG1.AD25 ; 238.32,97.1 UG1.AC20 238.32,98.1 ; 238.32,97.1 UG1.AC21 ; 238.32,97.1 UG1.AD21 ; UG1.AC21 v1(237.32,97.1) UG1.AD21 ; UG1.AC21 238.32,98.1 ; v1(242.32,103.1) UG1.V17 ; UG1.AH22 v1(236.32,92.1) ; UG1.AH22 v1(237.32,92.1) ; v1(236.32,92.1) UG1.AH23 ; v1(236.32,92.1) UG1.AJ22 v1(237.32,92.1) ; 238.32,94.1 UG1.AG20 ; 238.32,94.1 UG1.AF20 ; UG1.AD25 234.32,96.1 ; UG1.AD25 v1(233.32,96.1) UG1.AE25 ; v1(230.32,97.1) UG1.AC28 ; v1(234.32,101.1) UG1.Y24 234.32,100.1 ; v1(234.32,101.1) UG1.W25 ; v1(234.32,101.1) UG1.Y25 ; v1(234.32,101.1) UG1.W24 v1(234.32,102.1) ; v1(234.32,102.1) UG1.W25 ; UG1.Y28 v1(231.32,100.1) UG1.AA28 ; UG1.AG25 v1(234.32,93.1) ; v1(234.32,95.1) UG1.AE25 ; v1(234.32,95.1) UG1.AE24 234.32,96.1 ; UG1.AF20 v1(239.32,94.1) UG1.AG20 ; UG1.AB20 238.32,98.1 ; v1(234.32,93.1) UG1.AG24 ; UG1.AG24 v1(235.32,93.1) ; UG1.AE25 234.32,96.1 ; v1(235.32,93.1) UG1.AH23 ; UG1.Y25 v1(233.32,101.1) UG1.W25 ; UG1.Y25 234.32,100.1 ; v1(239.32,93.1) UG1.AG20 ; v1(231.33,93.13) 231.82,92.63 UG1.AH27
  BOTTOM w0.508: RG516.1 263.07,50.04 263.07,62.14 262.23,62.99 ; 240.42,74.64 240.42,75.91 PR6037.1
  vias: v1(211.31,69) v1(212.29,68.68) v1(212.29,67.98) v1(212.92,68.68) v1(212.92,67.98) v1(213.56,70.58) v1(213.56,69.95) v1(213.56,69.31) v1(213.56,68.68) v1(213.56,67.98) v1(214.19,70.58) v1(214.19,69.95) v1(214.19,69.31) v1(214.19,68.68) v1(214.19,67.98) v1(214.83,70.58) v1(214.83,69.95) v1(214.83,69.31) v1(214.83,68.68) v1(215.46,70.58) v1(215.46,69.95) v1(215.46,69.31) v1(215.46,68.68) v1(216.1,70.58) v1(216.1,69.95) v1(216.1,69.31) v1(216.1,68.68) v1(216.73,69.5) v1(216.73,68.87) v1(217.37,69.5) v1(217.37,68.87) v1(218,69.5) v1(218,68.87) v1(218.64,69.5) v1(218.64,68.87) v1(218.64,68.17) v1(218.64,67.53) v1(219.27,69.5) v1(219.27,68.87) v1(219.27,68.17) v1(219.27,67.53) v1(219.97,69.5) v1(219.97,68.87) v1(219.97,68.17) v1(219.97,67.53) v1(220.61,69.5) v1(220.61,68.87) v1(220.61,68.17) v1(220.61,67.53) v1(221.24,69.5) v1(221.24,68.87) v1(221.24,68.17) v1(221.24,67.53) v1(221.88,69.5) v1(221.88,68.87) v1(221.88,68.17) v1(221.88,67.53) v1(222.51,69.5) v1(222.51,68.87) v1(222.51,68.17) v1(222.51,67.53) v1(223.21,69.5) v1(223.21,68.87) v1(223.85,70.77) v1(223.85,70.14) v1(223.85,69.5) v1(223.85,68.87) v1(224.48,70.77) v1(224.48,70.14) v1(224.48,69.5) v1(224.48,68.87) v1(225.12,70.77) v1(225.12,70.14) v1(225.12,69.5) v1(225.12,68.87) v1(225.75,70.77) v1(225.75,70.14) v1(225.75,69.5) v1(225.75,68.87) v1(226.39,71.41) v1(226.39,70.77) v1(226.39,70.14) v1(226.39,69.5) v1(226.39,68.87) v1(226.83,64.55) v1(226.96,69.76) v1(226.96,69.17) v1(227.21,68.2) v1(227.44,68.84) v1(227.54,69.76) v1(227.85,68.2) v1(227.95,69.33) v1(228.04,68.76) v1(228.35,69.76) v1(228.48,68.2) v1(228.66,64.55) v1(228.69,69.28) v1(228.82,68.71) v1(229.05,69.76) v1(229.12,68.2) v1(229.37,69.26) v1(229.44,68.68) v1(229.74,73.18) v1(230.07,72.53) v1(230.06,68.78) v1(230.01,68.2) v1(230.37,73.18) v1(230.45,64.55) v1(230.64,68.78) v1(230.64,68.2) v1(230.7,72.53) v1(231.01,73.18) v1(231.34,72.53) v1(231.28,68.78) v1(231.28,68.2) v1(231.59,73.16) v1(231.78,64.42) v1(231.96,72.55) v1(231.91,68.78) v1(231.91,68.2) v1(232.23,73.16) v1(232.42,64.42) v1(232.55,68.78) v1(232.55,68.2) v1(232.6,72.55) v1(233.23,72.55) v1(233.18,68.78) v1(233.18,68.2) v1(233.82,72.55) v1(233.82,71.91) v1(233.82,71.28) v1(233.82,70.64) v1(233.82,70.01) v1(233.82,69.37) v1(233.82,68.78) v1(233.82,68.2) v1(234.45,72.55) v1(234.45,71.91) v1(234.45,71.28) v1(234.45,70.64) v1(234.45,70.01) v1(234.45,69.37) v1(234.45,68.78) v1(234.45,68.2) v1(235.09,72.55) v1(235.09,71.91) v1(235.09,71.28) v1(235.09,70.64) v1(235.09,70.01) v1(235.09,69.37) v1(235.09,68.78) v1(235.09,68.2) v1(235.72,72.55) v1(235.72,71.91) v1(235.72,71.28) v1(235.72,70.64) v1(235.72,70.01) v1(235.72,69.37) v1(235.72,68.78) v1(235.72,68.2) v1(235.71,64.48) v1(236.36,73.25) v1(236.36,72.55) v1(236.36,71.91) v1(236.36,71.28) v1(236.36,70.64) v1(236.36,70.01) v1(236.36,69.37) v1(236.36,68.78) v1(236.36,68.2) v1(236.99,74.07) v1(236.99,72.55) v1(236.99,68.78) v1(236.99,68.2) v1(237.54,64.48) v1(237.63,68.78) v1(237.63,68.2) v1(237.69,72.55) v1(238.26,68.78) v1(238.26,68.2) v1(238.32,94.96) v1(238.32,72.55) v1(238.96,72.55) v1(238.9,68.78) v1(238.9,68.2) v1(239.37,64.55) v1(239.53,68.78) v1(239.53,68.2) v1(239.59,72.55) v1(240.17,68.78) v1(240.17,68.2) v1(240.23,72.55) v1(240.67,64.42) v1(240.86,72.55) v1(240.8,68.78) v1(240.8,68.2) v1(241.31,64.42) v1(241.44,68.78) v1(241.44,68.2) v1(242.07,68.78) v1(242.07,68.2) v1(242.71,68.78) v1(242.71,68.2) v1(243.34,68.78) v1(243.34,68.2) v1(243.98,69.37) v1(243.98,68.78) v1(243.98,68.2) v1(244.31,64.51) v1(244.61,68.78) v1(244.61,68.2) v1(245.25,68.2) v1(246.15,64.51) v1(247.72,68.23) v1(247.98,64.51) v1(249.31,64.36) v1(249.31,63.72) v1(249.91,64.36) v1(249.91,63.72) v1(250.33,68) v1(250.96,68) v1(251.6,68) v1(251.79,64.36) v1(251.79,63.72) v1(252.23,68) v1(252.38,64.36) v1(252.38,63.72) v1(252.87,68) v1(252.99,64.36) v1(252.99,63.72) v1(253.5,68) v1(253.59,64.36) v1(253.59,63.72) v1(254.14,68) v1(254.2,64.36) v1(254.2,63.72) v1(254.77,68) v1(254.8,64.36) v1(254.8,63.72) v1(255.41,68) v1(255.41,64.36) v1(255.41,63.72) v1(256.04,68) v1(256,64.36) v1(256,63.72) v1(256.61,64.36) v1(256.61,63.72) v1(256.68,68) v1(257.21,64.36) v1(257.21,63.72) v1(257.31,68) v1(257.82,64.36) v1(257.82,63.72) v1(257.95,68) v1(258.45,64.36) v1(258.45,63.72) v1(258.58,68) v1(259.22,68) v1(259.85,68) v1(260.1,64.36) v1(260.1,63.72) v1(260.49,68) v1(260.7,64.36) v1(260.7,63.72) v1(261.12,68) v1(261.31,64.36) v1(261.31,63.72) v1(261.76,68) v1(261.91,64.36) v1(261.91,63.72) v1(262.39,68) v1(262.52,64.36) v1(262.52,63.72) v1(263,68) v1(263.15,64.36) v1(263.15,63.72) v4(209.19,69.18)
+VGA_PCIE: length 9.7
  TOP w0.381: v1(228.57,92.6) 227.55,92.6
  BOTTOM w0.4: UG1.AJ30 228.57,92.45 v1(228.57,92.6) ; v1(223.77,89) 223.77,89.15 UG1.AM36 ; UG1.AK35 224.57,90.35 v1(224.57,90.2) ; v1(223.8,96.15) 223.8,96.38 UG1.AD36 ; v1(224.57,95) 224.57,95.15 UG1.AE35 ; v1(224.57,98.6) 224.57,98.75 UG1.AA35 ; v1(224.57,87.8) 224.57,87.92 225.02,88.37 ; UG1.AF35 224.57,93.95 v1(224.57,93.8) ; v1(224.57,91.4) 224.57,91.55 UG1.AJ35 ; v1(225.37,98.6) 225.37,98.75 UG1.AA34 ; v1(223.77,92.6) 223.77,92.75 UG1.AG36
  BOTTOM w0.406: UG1.AN35 225.02,88.37
  vias: v1(200.35,84.5) v1(200.35,83.92) v1(200.35,83.33) v4(215.53,85.06)
+VGA_PCIEP: length 17.9
  BOTTOM w0.254: PR804.1 193.05,77.49 PC809.1 192.04,77.49 190.72,78.81 190.72,84.77 191.46,85.5 196.03,85.5 196.29,85.76 196.29,87.22 196.56,87.49 PC804.1
  vias: v2(198.38,87.6)
AC_BATT#: length 42.5
  IN2 w0.091: v1(213.18,116.11) 209.66,112.59 209.66,102.48 210.37,101.77 v1(211.34,101.77)
  IN3 w0.089: 215.91,96.6 215.91,97.82 215.65,98.08
  IN3 w0.091: v1(225.37,91.4) 224.73,92.04 220.47,92.04 215.91,96.6 ; 215.65,98.08 213.75,99.98 212.54,99.98 211.34,101.18 v1(211.34,101.77)
  BOTTOM w0.107: RG40.1 214.26,119.36 214.26,117.09 UG4.4 213.39,116.52 213.18,116.3 v1(213.18,116.11) 213.18,115.98 213.65,115.51 RG39.1
  BOTTOM w0.135: v1(225.37,91.4) 225.37,91.55 UG1.AJ34
AC_PRESENT: length 10.1
  BOTTOM w0.089: 218.97,31.66 218.48,32.15 216.69,32.15 216.51,32.33 215.81,32.33 215.72,32.43 215.35,32.43 215.14,32.64 UH1.BB15
  BOTTOM w0.107: 218.97,31.66 v2(220.05,30.59) 220.13,30.5 RH533.1 222.7,30.5 DH1.2
ACDET_CHG: length 5.2
  TOP w0.254: PU700.6 56.64,24.74 55.95,25.43 v1(55.83,25.43) 55.58,25.43 55.08,25.93 PR716.2
  BOTTOM w0.107: v1(55.83,25.43) v2(55.32,25.94)
  BOTTOM w0.254: PR719.1 56.32,24.87 PC719.1 56.34,24.92 v1(55.83,25.43)
ACDRV_CHG: length 4.6
  TOP w0.107: PR705.2 57.07,26.4 56.42,27.04 56.42,27.6 v2(55.79,28.24)
  TOP w0.203: PR705.2 57.07,25.52 57.44,25.15 PU700.4
ACIN#: length 35.6
  TOP w0.107: v1(323.35,46.12) 323.77,46.54 324.71,46.54 RE17.2 325.18,46.07 QE3.3 ; UE1.24 313.8,18.73 v1(314.14,19.08)
  IN3 w0.091: v1(314.14,19.08) 315.37,20.31 315.37,26.35 319.38,30.36 319.38,33.92 321.64,36.18 321.64,44.61 323.15,46.12 v1(323.35,46.12)
AD0_0: length 2.4
  TOP w0.107: UE3.31 221.56,157.83 222.03,157.36 v2(222.21,157.36) 222.83,157.36 RE43.2
AD0_1: length 1.6
  TOP w0.107: RE27.1 186.6,24.04 UE4.31
AD0_2: length 2.4
  BOTTOM w0.107: UE8.31 287.99,44.55 v2(287.77,44.77) 287.42,45.12 RE164.1
AD1_0: length 2.4
  TOP w0.107: UE3.32 222,158.33 222.26,158.59 v2(222.26,158.64) 222.26,159.22 RE40.2
AD1_1: length 2.8
  TOP w0.107: v2(184.67,24.35) 184.96,24.06 RE26.2 186.1,23.59 UE4.32
AD1_2: length 2.8
  BOTTOM w0.107: UE8.32 288.52,45.05 288.31,45.26 288.31,45.6 v2(287.78,46.13) RE163.1
AD2_0: length 2.8
  TOP w0.107: UE3.1 220.31,159.47 v2(221.24,160.39) 221.29,160.45 221.29,161.39 RE42.1
AD2_1: length 2.8
  TOP w0.107: v2(183.78,23.27) 183.87,23.18 RE29.1 184.34,21.69 UE4.1
AD2_2: length 1.5
  BOTTOM w0.107: RE165.2 289.71,47.25 UE8.1
AD3_0: length 3
  TOP w0.107: RE44.1 220.91,161.06 220.91,160.49 219.81,159.39 UE3.2
AD3_1: length 2.6
  TOP w0.107: v2(183.52,20.16) 183.87,20.5 RE30.1 183.89,21.19 UE4.2
AD3_2: length 2.7
  BOTTOM w0.107: UE8.2 290.21,46.89 RE162.1 v2(291.65,47.33)
AD_BID: length 9.7
  TOP w0.107: v2(289.19,6.32) 288.92,6.59 RE64.1 288.1,6.6 RE66.2 288.62,8.03 289.51,8.03 CE28.1 290.97,7.53 292.74,9.3 293.25,9.3 293.54,9.02 UE5.66
ADP_I: length 284.5
  TOP w0.107: v1(279.02,25.36) 279.02,24.75 279.6,24.17 279.6,19.2 283.94,14.86 283.94,6.39 285.21,5.11 289.93,5.11 v2(290.67,5.85) 291.13,6.32 PR23.2 292.28,6.32 292.65,6.68 292.65,6.92 293.14,7.41 UE5.65 ; v1(52.97,26.32) PR717.1
  IN2 w0.091: v1(52.97,26.32) 55,24.29 56.65,24.29 59,21.94 62.14,21.94 65.41,18.67 74.04,18.67 75.34,17.37 79.55,17.37 80.05,17.87 80.05,18.76 80.79,19.5 96.12,19.5 97.86,21.24 101.67,21.24 102.03,20.88 117.9,20.88 120.14,23.12 168.35,23.12 176.91,31.67 191.35,31.67 194.95,35.28 203.21,35.28 203.72,35.78 203.72,37.03 204.81,38.12 205.95,38.12 206.05,38.02 207.38,38.02 207.59,38.24 208.44,38.24 208.68,37.99 211.52,37.99 212.84,39.32 217.01,39.32 217.33,39 217.98,39 218.46,38.51 218.95,38.51 219.82,37.65 219.82,34.83 220.75,33.9 221.6,33.9 222.26,34.56 223.37,34.56 224.12,35.32 224.12,35.81 224.86,36.55 231.46,36.55 232.1,35.91 234.2,35.91 234.45,36.16 239.52,36.16 239.97,35.71 257.15,35.71 265.42,27.44 277.56,27.44 279.02,25.98 v1(279.02,25.36)
ADPIN: length 4.2
  TOP w0.107: v1(84.12,35.47) v4(82.56,35.47) ; v1(84.12,35.47) v4(84.12,36.9) ; v1(84.12,35.47) v4(84.12,34.3)
ALIEN_LED_B_DRV#: length 14.2
  TOP w0.127: v2(223.88,164.21) 224.24,164.57 v1(224.35,164.57)
  TOP w0.254: UE3.5 218.31,159.83 218.03,160.11 v1(218.03,160.57)
  TOP w0.457: JLOGO.5 225.92,165.24 225.58,164.9 224.68,164.9 v1(224.35,164.57)
  IN2 w0.381: v1(224.35,164.57) 222.49,162.72 222.19,162.72 221,161.53 221,160.6 220.3,159.9 218.43,159.9 218.03,160.29 v1(218.03,160.57)
ALIEN_LED_G_DRV#: length 13.6
  TOP w0.109: v1(219.54,161.48) v2(219.54,162.05)
  TOP w0.254: v1(219.54,161.48) 219.56,161.48 219.98,161.06 219.98,160.52 219.67,160.21 219.25,160.21 218.81,159.78 UE3.4
  TOP w0.457: v1(224.99,167.51) 224.92,167.44 JLOGO.4
  IN2 w0.381: v1(219.54,161.48) 219.54,161.5 221.85,163.81 222.02,163.81 224.99,166.78 v1(224.99,167.51)
ALIEN_LED_R_DRV#: length 9.9
  TOP w0.254: v1(220.46,160.83) 220.46,160.47 219.83,159.83 219.57,159.83 219.31,159.58 UE3.3
  TOP w0.457: JLOGO.3 223.92,165.46 223.84,165.38 v1(223.84,164.86)
  IN2 w0.381: v1(223.84,164.86) 222.28,163.3 222.06,163.3 220.46,161.7 v1(220.46,160.83)
  BOTTOM w0.109: v2(223.84,164.25) v1(223.84,164.86)
AMD#_NV: length 36.2
  TOP w0.107: v1(328.17,29.57) 327.58,29.57 319.86,21.85 319.86,19.46 319.4,19 UE1.17 ; v1(328.43,43.85) 328.49,43.85 328.89,43.45 UE6.20
  IN1 w0.097: v1(328.43,43.85) 328.68,43.85 329.11,43.43 329.11,40.31 329.26,40.16 329.45,40.16 330.84,38.77 332.41,38.77 333.13,38.05 333.13,34.54 v1(328.17,29.57)
AMP_ASEL: length 2.3
  TOP w0.107: v1(35.26,14.26) 35.45,14.07 UA4.18
  BOTTOM w0.107: v2(36.33,13.62) 35.69,14.26 v1(35.26,14.26)
AMP_I2S_BCLK: length 339.1
  TOP w0.107: JIO.15 326.59,16.85 v1(327.09,16.36) ; v1(38.87,36.36) 38.12,37.1 36.27,37.1 CA38.1 35.82,36.66 RA29.2 ; v1(38.57,11.15) 38.36,11.15 38.02,10.81 UA4.10
  IN2 w0.091: v1(38.57,11.15) 39.62,11.15 40.17,11.69 40.17,13.06 41.19,14.08 53.85,14.08 56.26,11.67 62.13,11.67 62.46,11.34 68.39,11.34 69.98,12.93 84.22,12.93 84.51,13.22 85.64,14.35 97.14,14.35 98.41,15.62 100.33,15.62 101.25,16.54 183.74,16.54 184.06,16.22 184.49,16.22 185.27,15.44 189.93,15.44 194.42,10.95 201.58,10.95 202.13,10.41 203.59,10.41 204,10.82 206.19,10.82 207.2,11.83 212.97,11.83 215.32,14.18 226.44,14.18 227.92,12.7 230.5,12.7 231.47,13.66 233.84,13.66 234.27,13.23 255.74,13.23 256.7,14.2 266.64,14.2 267.65,15.21 274.64,15.21 276.47,13.38 290.05,13.38 291.24,12.19 296.05,12.19 296.27,11.97 301.04,11.97 302.29,10.72 312.73,10.72 313,10.45 319.12,10.45 324.4,15.74 326.47,15.74 v1(327.09,16.36)
  IN4 w0.097: v1(38.57,11.15) 38.36,11.15 37.79,11.71 37.79,13.18 39.34,14.73 39.34,27.06 37.98,28.42 37.98,35.47 v1(38.87,36.36)
AMP_I2S_BCLK_R: length 2.1
  TOP w0.107: v1(35.38,33.81) 35.82,34.25 RA29.1
  BOTTOM w0.107: UA1.56 34.82,33.68 34.94,33.55 35.12,33.55 v1(35.38,33.81)
AMP_I2S_MCLK: length 334.4
  TOP w0.107: UA4.9 38.02,10.41 38.32,10.72 38.75,10.72 39.32,11.29 v1(39.32,11.59) ; v1(38.87,35.76) 38.45,35.34 CA39.1 RA27.2 ; JIO.14 v1(326.45,16.36)
  IN2 w0.091: v1(39.32,11.59) 39.32,11.91 39.95,12.54 39.95,13.15 41.1,14.3 53.94,14.3 56.35,11.89 62.22,11.89 62.55,11.56 68.3,11.56 69.89,13.15 84.13,13.15 84.42,13.44 85.55,14.57 97.05,14.57 98.32,15.84 100.24,15.84 101.16,16.76 183.83,16.76 184.15,16.44 184.58,16.44 184.6,16.42 185.37,15.65 190.02,15.65 194.51,11.17 201.67,11.17 202.22,10.62 203.5,10.62 203.91,11.04 206.1,11.04 207.11,12.05 212.88,12.05 215.23,14.4 226.53,14.4 228.01,12.92 230.41,12.92 231.51,14.02 231.51,14.64 231.72,14.84 232.05,14.84 232.65,14.25 233.84,14.25 234.63,13.45 255.65,13.45 256.61,14.41 266.55,14.41 267.56,15.43 274.73,15.43 276.56,13.6 290.14,13.6 291.33,12.41 296.14,12.41 296.36,12.19 302.21,12.19 303.06,11.34 311.22,11.34 311.54,11.66 313.73,11.66 314.71,10.67 319.03,10.67 324.31,15.95 326.05,15.95 v1(326.45,16.36)
  IN4 w0.097: v1(39.32,11.59) 39.32,11.91 40.24,12.83 40.24,28.15 40.57,28.47 40.57,31.09 40.33,31.32 40.33,34.3 v1(38.87,35.76)
AMP_I2S_MCLK_R: length 5.6
  TOP w0.107: RA27.1 37.26,34.45 v1(36.58,34.45) 36.14,34 v2(36.14,33.62)
  BOTTOM w0.107: v1(36.58,34.45) 36.48,34.45 36.2,34.17 36.2,33.52 36.07,33.39 35.3,33.39 35.11,33.2 34.54,33.2 34.42,33.33 UA1.55
AMP_LDO_A1.5V: length 1.4
  BOTTOM w0.107: v2(33.28,13.18) 33.28,13.57 v1(33.98,14.26)
AUD_HP_OUT_L_CN: length 27.7
  TOP w0.107: v1(17.71,18.51) v2(17.71,17.66)
  IN4 w0.254: JACK1.1 15.58,4.3 16.52,5.24 16.52,17.95 17.08,18.51 v1(17.71,18.51)
  BOTTOM w0.254: LA9.1 24.52,19.15 24.01,19.65 CA42.1 23.67,19.81 23.25,20.23 20.71,20.23 20.37,19.88 DA4.3 18.07,19.16 17.71,18.8 v1(17.71,18.51)
AUD_HP_OUT_R_CN: length 28
  TOP w0.254: v1(19.02,15.15) 19.02,15.03 18.33,14.34 17.18,14.34 16.45,15.07 v2(16.45,18.18) 16.45,20.25 16.87,20.67 v1(17.45,20.67)
  IN1 w0.254: v1(17.19,17.88) 16.94,17.88 16.62,17.56 16.52,17.56 13.97,15.01 9.53,15.01 8.32,13.8 JACK1.2
  BOTTOM w0.254: LA10.1 v1(17.45,20.67) ; v1(17.19,17.88) 17.6,17.88 18.02,17.46 20.14,17.46 DA4.2 20.37,16.17 19.91,15.71 CA43.1 v1(19.02,15.15)
AUDIO_IRQ: length 3
  TOP w0.107: v2(36.01,30.58) 36.35,30.91 v1(36.84,30.91) 37.38,31.46 RA24.2
  BOTTOM w0.107: v1(36.84,30.91) 36.38,30.91 36.18,31.11 UA1.6
B+: length 971.7
  TOP w0.508: v1(74.85,9.63) 74.52,9.3 PC10.1 73.8,10.07 73.94,10.2 PR12.1 73.94,12.05 71.79,14.19 70.8,14.19 70.44,13.83 PQ3.4 ; v1(96.16,8.53) 97.35,8.53 101.29,12.48 101.61,12.48
  TOP w1.016: 291.98,83.79 291.98,85.76 286.9,90.84 286.9,99.16 285.89,100.17 285.02,100.17 284.49,100.7 284.49,121.91 284.04,122.36 284.04,161.63 281.81,163.86 279.73,163.86 279.03,164.56 278.27,164.56
  TOP w1.524: 154,157.07 154,156.24 151.71,153.96 142.28,153.96 138.5,150.18 138.5,146.97 136.41,144.88 136.41,135.92 ; 206.89,4.99 229.55,4.99 232.13,7.57 232.13,8.47 234.54,10.88 236.99,10.88 238.91,12.8 244.44,12.8 244.74,12.5 250,12.5
  TOP w2.54: 101.51,65.08 103.07,66.64
  TOP w3.048: 186.9,8.29 189.44,5.75 205.18,5.75
  TOP w3.556: 130.49,131.86 125.34,126.71 118.31,126.71 115.39,123.8 115.39,83.79 103.07,71.47 103.07,66.64
  IN1 w1.016: 292.17,83.6 292.17,85 286.9,90.27 286.9,99.16 285.89,100.17 285.05,100.17 284.49,100.73 284.49,122.7 283.96,123.23 283.96,127.34 284.49,127.87 284.49,160.69 280.62,164.56 ; 292.74,81.06 294.08,79.72 294.08,74.07 298.59,69.56 298.59,66.33
  IN1 w1.524: 224.06,4.99 206.89,4.99
  IN1 w2.54: 116.75,9.84 121.1,5.49 152.98,5.49 160.98,13.5 174.19,13.5 174.19,13.49 ; 113.74,12.86 113.74,13.24 107.15,19.82
  IN1 w3.048: 184.79,7.84 186.89,5.75 205.18,5.75 ; 298.66,48.1 298.66,49.73 301.6,52.67 301.6,56.98 298.87,59.71 298.87,61.45
  IN2 w1.524: 223.38,8.06 208.64,8.06 207.34,6.77 207.34,6.76 ; 224.06,4.99 206.89,4.99
  IN2 w3.048: 184.79,8.29 187.33,5.75 205.18,5.75
  IN3 w1.016: 177.49,28.1 177.62,28.1 177.62,30.51 179.9,32.8 182.32,32.8 183.9,34.39 183.9,51.74 182.91,52.73 182.91,68.33 179.71,71.53 179.71,80.07 180.73,81.09 181.49,81.09
  IN3 w1.524: 224.06,4.99 206.89,4.99
  IN3 w3.048: 184.79,8.29 187.33,5.75 205.18,5.75
  IN4 w1.016: 293.25,81.31 294.08,80.49 294.08,74.07 298.59,69.56 298.59,66.33 ; 292.43,83.73 292.43,84.74 288.74,88.42 288.74,92.93 286.9,94.77 286.9,99.16 285.89,100.17 285.01,100.17 284.49,100.69 284.49,122.14 283.61,123.02 283.61,127.06 284.49,127.93 284.49,160.69 280.62,164.56
  IN4 w1.524: 224.06,4.99 206.89,4.99 ; 223.66,8.1 208.29,8.1 207.34,7.14 206.89,7.14
  IN4 w3.048: 205.18,5.75 187.33,5.75 184.79,8.29
  BOTTOM w0.508: v1(96.16,8.53) 94.07,6.45 77.11,6.45 74.85,8.71 v1(74.85,9.63)
  BOTTOM w1.016: 196.97,71.64 190.91,71.64 189.38,73.17 189.38,76.85 185.87,80.36
  BOTTOM w3.048: 281.42,40.31 278.47,37.37 274.33,37.37 268.42,31.46
  BOTTOM w3.378: 115.29,121.98 115.28,121.97 ; 101.67,65.45 101.67,68.83 105.48,72.64 105.48,74.11 112.27,80.9 112.27,87.45 115.28,90.46 115.28,121.97 ; 115.28,121.97 115.28,123.75 115.39,123.86
  BOTTOM w3.556: 130.68,130.72 127.25,127.29 118.82,127.29 115.39,123.86
  vias: v1(55.44,34.07) v1(55.44,33.48) v1(55.44,32.86) v1(55.76,34.64) v1(55.83,30.96) v1(56.08,34.13) v1(56.08,33.55) v1(56.08,32.86) v1(56.08,32.23) v1(56.1,31.59) v1(56.21,35.08) v1(56.46,30.96) v1(56.71,35.4) v1(56.71,34.77) v1(56.71,34.13) v1(56.71,33.5) v1(56.71,32.86) v1(56.71,32.23) v1(56.71,31.59) v1(57.1,30.96) v1(57.35,32.86) v1(57.35,32.23) v1(57.35,31.59) v1(57.73,30.96) v1(57.98,32.86) v1(57.98,32.23) v1(57.98,31.59) v1(58.37,30.96) v1(58.62,32.86) v1(58.62,32.23) v1(58.62,31.59) v1(59.25,32.86) v1(59.25,32.23) v1(59.25,31.59) v1(87.96,31.59) v1(87.96,30.96) v1(87.96,30.32) v1(87.96,29.69) v1(87.96,29.05) v1(87.96,28.42) v1(88.59,30.96) v1(88.59,30.32) v1(88.59,29.69) v1(88.59,29.05) v1(88.59,28.42) v1(89.23,30.96) v1(89.23,30.32) v1(89.23,29.69) v1(89.23,29.05) v1(89.23,28.42) v1(94.62,51.05) v1(94.62,50.45) v1(95.26,51.66) v1(95.26,51.05) v1(95.26,50.45) v1(95.87,52.25) v1(95.87,51.66) v1(95.87,51.05) v1(95.87,50.45) v1(96.19,52.83) v1(96.47,52.25) v1(96.47,51.66) v1(96.47,51.05) v1(96.47,50.45) v1(96.78,52.83) v1(97.05,52.2) v1(97.48,52.76) v1(97.93,53.18) v1(100.24,63.41) v1(100.24,62.82) v1(100.87,63.41) v1(100.87,62.82) v1(103.15,22.85) v1(103.15,22.24) v1(103.65,23.19) v1(103.65,22.55) v1(103.65,21.92) v1(104.24,23.19) v1(104.24,22.56) v1(104.24,21.92) v1(104.85,23.19) v1(104.85,22.55) v1(104.85,21.92) v1(105.46,23.2) v1(105.46,22.57) v1(105.46,21.93) v1(106.09,22.57) v1(106.09,21.93) v1(116.53,12.22) v1(116.53,11.59) v1(117.17,12.22) v1(117.17,11.59) v1(117.8,12.22) v1(117.8,11.59) v1(118.44,12.22) v1(118.44,11.59) v1(132.78,133.06) v1(132.78,132.47) v1(132.78,131.86) v1(132.78,131.25) v1(133.41,133.06) v1(133.41,132.47) v1(133.41,131.86) v1(133.41,131.25) v1(134.05,133.06) v1(134.05,132.47) v1(134.05,131.86) v1(134.05,131.25) v1(138.21,140.24) v1(138.21,139.61) v1(138.21,138.97) v1(138.21,138.34) v1(138.85,140.24) v1(138.85,139.61) v1(138.85,138.97) v1(138.85,138.34) v1(154,158.15) v1(154,157.51) v1(154.63,158.15) v1(154.63,157.51) v1(157.11,167.75) v1(157.11,167.16) v1(157.74,167.63) v1(157.74,167.05) v1(173.73,11.5) v1(173.73,10.74) v1(173.73,10.04) v1(174.43,11.5) v1(174.43,10.74) v1(174.43,10.04) v1(175.13,11.5) v1(175.13,10.74) v1(175.13,10.04) v1(176.98,26.89) v1(177.68,26.89) v1(182,11.46) v1(182,10.83) v1(182.62,11.21) v1(182.62,10.62) v1(183.32,11.21) v1(183.32,10.62) v1(183.32,10.04) v1(183.73,81.31) v1(183.74,80.68) v1(184.02,10.62) v1(184.02,10.04) v1(254.76,31.44) v1(254.76,30.85) v1(254.76,30.27) v1(255.01,32.01) v1(255.08,29.72) v1(255.39,31.44) v1(255.39,30.85) v1(255.39,30.27) v1(255.65,32.01) v1(255.71,29.72) v1(255.84,8.01) v1(255.84,7.37) v1(256.03,31.44) v1(256.03,30.85) v1(256.03,30.27) v1(256.04,6.45) v1(256.04,5.75) v1(256.22,8.5) v1(256.28,32.01) v1(256.35,29.72) v1(256.54,8.01) v1(256.54,7.37) v1(256.55,6.76) v1(256.56,6.1) v1(256.66,31.44) v1(256.66,30.85) v1(256.66,30.27) v1(256.57,5.49) v1(256.92,32.01) v1(256.93,8.54) v1(257.18,7.97) v1(257.17,7.37) v1(257.17,6.74) v1(257.17,6.1) v1(257.17,5.47) v1(257.31,31.46) v1(257.31,30.83) v1(257.31,30.19) v1(257.56,32.04) v1(257.84,31.21) v1(266.19,30.93) v1(266.19,30.35) v1(266.82,30.93) v1(266.82,30.35) v1(267.46,30.93) v1(267.46,30.35) v1(276.81,165.01) v1(276.81,164.37) v1(276.81,163.74) v1(277.44,165.01) v1(277.44,164.37) v1(277.44,163.74) v1(283.47,42.37) v1(283.47,41.79) v1(284.05,42.37) v1(284.05,41.79) v1(284.63,42.37) v1(284.63,41.79) v1(292.05,82.71) v1(292.05,82.07) v1(292.68,82.71) v1(292.68,82.07) v1(299.03,65.55) v1(299.03,64.85) v1(299.03,64.15) v1(299.73,65.55) v1(299.73,64.85) v1(299.73,64.15) v4(109.06,17.24)
