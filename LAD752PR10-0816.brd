# Allegro board LAD752PR10-0816.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
CLKREQ_PCIE#3: length 158.1
  IN1 w0.097: v1(216.94,27.91) 216.59,27.91 215.67,28.83 215.67,30.45 214.79,31.33 214.28,31.33 213.94,31.66 213.31,31.66 211.53,33.44 211.53,34.07 210.51,35.09 210.51,36.81 210.58,36.87 210.58,39.22 210.69,39.33 210.69,41.84 208.52,44.01 208.52,49.93 206.37,52.07 203.56,52.07 202.03,53.59 202.03,57.4 202.54,57.91 202.54,63.99 v1(201.88,64.65)
  IN2 w0.091: v1(177.55,151.29) 177.96,151.69 184.75,151.69 185.37,151.08 187.19,151.08 194.64,143.63 194.64,113.78 192.84,111.98 192.84,111.01 190.04,108.22 190.04,106.15 189.98,106.08 189.98,98.06 189.45,97.53 189.45,93.88 190.3,93.03 190.3,73.46 192.59,71.17 192.59,70.48 195.56,67.5 196.7,67.5 199.34,64.87 201.66,64.87 v1(201.88,64.65)
  BOTTOM w0.089: UH1.BD25 216.11,27.79 216.82,27.79
  BOTTOM w0.107: RT2.2 RT24.1 177.33,152.03 177.55,151.8 v1(177.55,151.29)
  BOTTOM w0.127: 216.82,27.79 v1(216.94,27.91)
CLKREQ_PCIE#3_R: length 8.7
  TOP w0.089: UT1.AC5 177.76,159.47
  TOP w0.102: 177.76,159.47 176.72,158.43 176.68,158.43 176.08,157.83 176.08,156.22 v1(175.78,155.92)
  BOTTOM w0.107: v1(175.78,155.92) 175.78,155.8 177.54,154.03 RT20.2 176.93,153.27 RT2.1
CLKREQ_PCIE#4: length 191.3
  IN1 w0.097: v1(226.85,160.17) 227.15,160.17 227.49,159.83 229.03,159.83 230.43,158.43 234.72,158.43 235.02,158.73 235.02,159.48 234.32,160.18 v1(234.07,160.18) ; v1(218.16,27.6) 217.86,27.6 217.18,28.29 216.47,28.29 215.85,28.91 215.85,30.53 214.87,31.51 214.35,31.51 214.02,31.85 213.38,31.85 212.29,32.94 212.29,34.34 212.08,34.56 211.73,34.56 210.7,35.59 210.7,36.73 210.76,36.8 210.76,39.15 210.91,39.3 210.91,41.93 208.74,44.11 208.74,50.02 206.47,52.3 203.65,52.3 202.26,53.69 202.26,57.31 202.76,57.82 202.76,64.36 202.22,64.9 202.22,66.23 205.3,69.3 205.3,73.32 204.87,73.75 204.87,77.61 v1(205.55,78.3)
  IN2 w0.091: v1(205.55,78.3) 205.99,78.74 205.99,84.69 204.97,85.71 204.97,90.59 204.62,90.93 204.62,97.23 203.46,98.39 203.46,110.7 203.13,111.03 203.13,119.98 201.15,121.96 201.15,146.03 203.95,148.83 210.84,148.83 211.42,149.4 215.22,149.4 217.02,151.2 225.56,151.2 227.2,152.83 227.2,158.15 226.75,158.6 226.75,159.77 226.85,159.87 v1(226.85,160.17)
  IN3 w0.091: v1(234.07,160.18) 234.31,160.18 234.9,159.58 234.9,158.61 234.81,158.52 234.81,157.74 v1(235.48,157.07)
  BOTTOM w0.089: UH1.BB24 215.26,28.36 215.74,28.36 215.84,28.46 216.15,28.46 216.15,28.47 216.26,28.36 216.51,28.36 216.6,28.45 217.67,28.45 217.96,28.17 217.96,27.81 v1(218.16,27.6)
  BOTTOM w0.107: UL1.4 235.49,157.06 v1(235.48,157.07) ; v1(218.16,27.6) 218.78,28.22 219.35,28.22 219.62,27.95 RP3.8
CLKREQ_PCIE#5: length 119.3
  IN1 w0.097: v1(219.23,24.29) 220.83,22.69 220.83,18.29 221.59,17.53 223.11,17.53 223.51,17.13 226.04,17.13 227.42,18.51 228.03,18.51 230.02,20.49 233.45,20.49 234.21,19.73 235.2,19.73 237.07,21.6 238.05,21.6 238.68,22.23 249.28,22.23 249.28,22.22 249.34,22.22 249.59,21.97 250.61,21.97 252.67,24.03 255.07,24.03 263,31.96 271.1,31.96 271.82,31.24 277.26,31.24 278.14,32.12 279.36,32.12 280.24,31.24 283.94,31.24 284.3,31.6 287.04,31.6 289.47,34.04 289.47,34.61 291.78,36.92 300.23,36.92 300.74,36.42 312.96,36.42 313.5,35.88 v1(313.5,34.76)
  BOTTOM w0.089: 219.18,24.34 218.87,24.65 218.47,24.65 218.19,24.92 218.19,26.39 217.09,27.49 216.62,27.49 216.57,27.55 UH1.BE25
  BOTTOM w0.107: JWLAN.45 313.32,34.58 v1(313.5,34.76) ; RP5.6 219.78,23.97 219.53,24.22 219.3,24.22 v1(219.23,24.29) 219.18,24.34
CLKREQ_PCIE#7: length 54.3
  TOP w0.089: v1(211.26,24.04) v2(210.79,23.57) 210.68,23.46 210.07,23.46 209.88,23.27 209.88,22.96 209.62,22.7 208.8,22.7 208.34,23.16 208.34,24.6 207.83,25.11 R366.1
  IN4 w0.097: v1(238.76,16.14) 238.76,16.16 238.38,15.78 237.9,15.78 236.28,17.4 227.82,17.4 223.68,21.54 223.68,22.76 222.7,23.74 221.44,23.74 219.11,26.06 218.5,26.06 217.6,25.17 216.33,25.17 215.64,24.48 211.69,24.48 v1(211.26,24.04)
  BOTTOM w0.089: UH1.AR31 211.26,24.43 v1(211.26,24.04)
  BOTTOM w0.107: v1(238.76,16.14) 238.25,15.63 238.25,10.93 237.85,10.53 237.85,7.57 238.6,6.83 240.89,6.83 241.27,6.44 JSSD3.52
CLKRUN#: length 7.2
  TOP w0.089: v1(213.8,28.79) 214.14,28.46 217.28,28.46 217.39,28.56 v2(218.08,28.56) 219.18,28.56
  TOP w0.107: 219.18,28.56 219.37,28.56 RH85.1
  BOTTOM w0.089: UH1.AW22 213.75,28.85 v1(213.8,28.79)
CMSRC_CHG: length 2.1
  TOP w0.203: PR706.2 58.29,25.93 57.84,25.48 PU700.3
CODEC_MUTE#: length 337.4
  TOP w0.107: JIO.19 324.9,18.85 324.77,18.73 324.49,18.73 v1(324.04,18.27) ; DA3.1 v1(35.14,40.59) ; v2(38.49,14.38) 38.38,14.38 v1(38.06,14.7) 38.06,15.11 RA70.2 36.96,14.55 36.96,14.01 36.65,13.7 UA4.15
  IN2 w0.089: 214.75,15.16 214.86,15.27 219.18,15.27
  IN2 w0.091: 219.18,15.27 226.89,15.27 228.38,13.79 230.05,13.79 230.64,14.38 230.64,15.21 231.15,15.72 232.42,15.72 233.01,15.12 241.78,15.12 242.44,14.46 246.98,14.46 247.8,15.29 264.73,15.29 267.38,17.93 268.36,17.93 268.95,18.52 271.89,18.52 272,18.42 273.87,18.42 277.82,14.47 290.5,14.47 291.69,13.28 296.5,13.28 296.72,13.06 301.7,13.06 302.11,13.47 303.21,13.47 304.47,12.21 308.95,12.21 309.85,13.11 319.89,13.11 324.04,17.27 v1(324.04,18.27) ; 214.75,15.16 212.51,12.92 206.75,12.92 206.32,12.5 204.62,12.5 204.3,12.17 197.27,12.17 196.33,13.11 193.8,13.11 190.39,16.53 185.73,16.53 184.94,17.32 184.51,17.32 184.2,17.63 100.8,17.63 99.88,16.71 97.95,16.71 96.7,15.46 85.2,15.46 83.76,14.02 69.52,14.02 67.93,12.43 62.91,12.43 62.58,12.76 56.72,12.76 54.3,15.18 38.33,15.18 38.06,14.91 v1(38.06,14.7)
  IN4 w0.097: v1(38.06,14.7) 38.06,17.3 36.48,18.89 36.48,22.03 35.32,23.19 35.32,26.21 35.1,26.43 35.1,27.39 35.86,28.15 35.86,37.07 35.14,37.79 v1(35.14,40.59)
CPU_24MHZ_N: length 99.4
  IN1 w0.097: v1(187.65,56.11) 187.4,56.36 187.14,56.36 185.75,57.76 185.75,60.8 185.95,61 185.95,64.79 185.75,65 185.75,68.14 186.4,68.79 186.4,73.49 188.17,75.26 188.17,93.19 179.73,101.63 179.73,114.13 179.22,114.65 172.73,114.65 172.41,114.97 172.41,116.62 171.84,117.19 170.89,117.19 170.46,116.77 170.46,116.6 170.46,115.81 v1(170.7,115.57)
  BOTTOM w0.089: v1(170.7,115.57) 171.03,115.91 CPU1.D31
  BOTTOM w0.099: UH1.F1 197.31,39.61 197.31,39.89 196.42,40.78 196.42,43.6 196.82,44 196.82,46.87 189.24,54.45 189.24,56.19 189.11,56.31 187.85,56.31 v1(187.65,56.11)
CPU_24MHZ_P: length 100
  IN1 w0.097: v1(170.05,115.58) 170.29,115.82 170.29,116.6 170.29,116.84 170.82,117.36 171.91,117.36 172.58,116.69 172.58,115.04 172.8,114.82 179.29,114.82 179.9,114.21 179.9,101.7 188.34,93.27 188.34,75.19 186.57,73.42 186.57,68.72 185.92,68.07 185.92,65.07 186.13,64.87 186.13,60.93 185.92,60.73 185.92,57.83 187.22,56.54 187.49,56.54 v1(187.65,56.7)
  BOTTOM w0.089: v1(170.05,115.58) 170.38,115.91 CPU1.E31
  BOTTOM w0.099: UH1.G1 197.5,39.59 197.5,39.75 197.5,39.75 197.5,39.97 196.61,40.86 196.61,43.52 197.01,43.92 197.01,46.95 189.43,54.53 189.43,56.27 189.19,56.51 187.85,56.51 v1(187.65,56.7)
CPU_B+: length 17.3
  TOP w0.508: PR506.2 127.97,135.27 127.99,135.26 128.09,135.26 128.73,134.61 v1(129.93,134.61)
  IN3 w0.508: v1(129.93,134.61) 129.93,134.69 130.02,134.78 130.53,135.29 131.64,135.29 133.3,136.94 135.35,136.94 136.37,137.95 136.37,143.19 136.98,143.8 v1(137.71,143.8)
  vias: v1(138.06,144.3) v1(138.38,143.8) v1(138.69,144.3) v1(139.26,144.43) v1(139.26,143.85) v1(139.26,143.26) v1(139.26,142.67) v1(139.26,142.06) v1(139.9,143.99) v1(139.9,143.4) v1(139.9,142.82) v1(139.9,142.23) v1(139.9,141.64) v1(143.07,156.05) v1(143.71,156.05) v1(146.19,156.05) v1(146.82,156.05) v1(147.73,147.82) v1(147.73,147.23) v1(147.73,146.65) v1(148.32,147.84) v1(148.32,147.26) v1(148.32,146.67) v1(148.98,156.05) v1(149.61,156.05) v1(150.25,156.05) v1(150.88,156.05) v1(155.98,147.88) v1(155.98,147.3) v1(155.98,146.71) v1(156.58,147.91) v1(156.58,147.32) v1(156.58,146.74) v1(163.67,144.64) v1(163.67,144.06) v1(163.67,143.47) v1(164.33,144.67) v1(164.33,144.08) v1(164.33,143.5) v1(172.05,144.45) v1(172.05,143.87) v1(172.05,143.28) v1(172.64,144.48) v1(172.64,143.89) v1(172.64,143.31) v1(179.84,143.42) v1(179.84,142.78) v1(180.24,144.52) v1(180.24,143.93) v1(180.48,143.39) v1(180.48,142.78) v1(186,142.34) v1(186,141.7) v2(186.83,144.24)
CPU_DDC1CLK: length 164.8
  TOP w0.099: UT1.Y5 v1(178.05,161.2)
  IN1 w0.097: v1(215.2,37.26) 215.03,37.33 214.63,37.33 214.39,37.57 214.39,40.08 216.12,41.81 216.12,45.87 213.33,48.66 213.33,51.39 209.27,55.46 205.42,55.46 204.68,56.2 204.68,64.14 205.24,64.7 205.24,68.42 205.77,68.95 205.77,73.52 205.35,73.94 205.35,77.42 206.09,78.16 206.09,81.1 207.78,82.79 207.78,97.6 204.62,100.77 204.62,102.45 198.89,108.19 198.89,108.73 195.9,111.72 195.9,122.77 195.35,123.31 195.35,148 193.13,150.22 193.13,151.35 192.65,151.83 192.65,155.16 191.6,156.21 191.6,157.95 191.26,158.3 189.98,158.3 189.22,159.06 187.57,159.06 186.92,159.71 178.08,159.71 175.92,161.87 175.92,162.96 v1(174.89,163.99)
  IN3 w0.099: v1(174.89,163.99) 175.01,163.99 176.41,162.59 176.41,161.2 176.86,160.75 177.6,160.75 v1(178.05,161.2)
  BOTTOM w0.089: UH1.BA5 215.09,37.37 v1(215.2,37.26)
  BOTTOM w0.099: RPT1.3 174.45,163.68 174.76,163.99 v1(174.89,163.99)
CPU_DDC1DATA: length 162
  TOP w0.089: UT1.R4 v1(177.4,163.81)
  IN1 w0.097: v1(177.4,163.81) 176.36,163.81 176.09,163.54 176.09,161.94 178.15,159.88 186.99,159.88 187.65,159.23 189.29,159.23 190.05,158.47 191.33,158.47 191.77,158.02 191.77,156.28 192.82,155.23 192.82,151.9 193.3,151.42 193.3,150.29 195.52,148.07 195.52,123.39 196.07,122.84 196.07,111.79 199.06,108.8 199.06,108.26 204.79,102.53 204.79,100.84 207.95,97.68 207.95,82.72 206.26,81.03 206.26,78.09 205.52,77.35 205.52,74.02 205.95,73.59 205.95,68.88 205.41,68.35 205.41,64.63 204.85,64.07 204.85,56.27 205.49,55.63 209.34,55.63 213.51,51.46 213.51,48.73 216.29,45.94 216.29,41.74 214.56,40.01 214.56,37.64 214.7,37.5 214.86,37.5 v1(214.98,37.78)
  BOTTOM w0.089: UH1.BC4 215.09,37.89 v1(214.98,37.78)
  BOTTOM w0.099: RPT1.4 174.33,163.18 174.63,163.48 v2(175.59,163.48) 176.35,163.48 176.67,163.81 v1(177.4,163.81)
CPU_DDC2CLK: length 167.7
  TOP w0.089: v1(180.03,162.51) 180.02,162.5 179.52,162.5 179.33,162.3 179.33,161.18 UT1.Y8
  IN1 w0.097: v1(215.4,38.33) 215.75,38.33 217.1,39.68 217.1,41.01 216.77,41.33 216.77,46.14 213.98,48.93 213.98,51.66 209.54,56.11 205.69,56.11 205.33,56.47 205.33,63.87 205.89,64.43 205.89,68.15 206.74,69 206.74,80.83 208.82,82.91 208.82,97.49 205.49,100.81 205.49,102.5 200.83,107.17 200.83,108.95 196.55,113.23 196.55,123.04 196,123.58 196,148.27 193.78,150.49 193.78,151.61 193.3,152.1 193.3,155.43 192.25,156.48 192.25,158.25 191.56,158.95 190.25,158.95 189.49,159.71 188,159.71 186.07,161.64 184.35,161.64 183.73,162.26 183.73,164.1 183.62,164.21 182.97,164.21 182.32,163.56 181.77,163.56 181.12,162.91 180.29,162.91 180.03,162.65 v1(180.03,162.51)
  IN4 w0.097: v1(174.25,165.18) 174.25,165.18 174.25,163.67 174.38,163.54 175.65,163.54 176.86,162.34 176.86,161.07 177.17,160.75 179.27,160.75 179.46,160.94 179.46,162.27 179.69,162.51 v1(180.03,162.51)
  BOTTOM w0.089: v1(215.4,38.33) 215.19,38.33 214.91,38.61 UH1.BB3
  BOTTOM w0.099: v1(174.25,165.18) 174.38,165.18 174.51,165.06 174.51,164.88 174.3,164.68 RPT1.1
CPU_DDC2DATA: length 161.7
  TOP w0.099: UT1.N4 v1(177.4,164.46)
  IN1 w0.097: v1(177.4,164.46) 178.31,163.55 178.31,162.98 178.63,162.66 179.5,162.66 179.93,163.08 181.05,163.08 181.7,163.73 182.25,163.73 182.9,164.38 183.69,164.38 183.9,164.17 183.9,162.33 184.42,161.81 186.15,161.81 188.08,159.88 189.56,159.88 190.32,159.12 191.63,159.12 192.42,158.33 192.42,156.55 193.47,155.5 193.47,152.17 193.95,151.69 193.95,150.56 196.17,148.34 196.17,123.65 196.72,123.11 196.72,113.3 201,109.02 201,107.24 205.67,102.57 205.67,100.88 208.99,97.56 208.99,82.84 206.91,80.76 206.91,68.93 206.06,68.08 206.06,64.36 205.5,63.8 205.5,56.54 205.76,56.28 209.61,56.28 214.16,51.73 214.16,49 216.94,46.21 216.94,41.41 217.27,41.08 217.27,39.61 215.87,38.22 v1(215.87,37.89)
  BOTTOM w0.089: UH1.BD6 215.92,37.31 215.92,37.85 v1(215.87,37.89)
  BOTTOM w0.099: v1(177.4,164.46) 177.36,164.5 v2(176.48,164.5) 176.09,164.5 175.84,164.75 174.89,164.75 174.31,164.18 RPT1.2
CPU_DDI1HPD: length 169
  TOP w0.102: UT1.AA2 176.15,160.41 175.63,160.41 175.37,160.16
  TOP w0.127: 175.37,160.16 175.37,159.97 v1(174.69,159.29) 174.19,158.78 v2(173.81,158.78) 173.1,158.78 RT38.1
  IN1 w0.089: v1(213.14,37.36) 213.14,37.37 213.02,37.49 213.02,39.05 213.34,39.37 213.34,42.08
  IN1 w0.097: 213.34,42.08 213.34,42.7 213.55,42.91 213.55,43.73 213.31,43.97 212.15,43.97 212.06,44.07 212.06,44.83 210.78,46.11 210.78,50.25 207.13,53.9 204.39,53.9 204.09,54.21 204.09,54.69 202.87,55.91 202.87,57.29 203.21,57.63 203.21,64.21 204.12,65.13 204.12,65.86 203.9,66.08 v1(203.85,66.08)
  IN2 w0.091: v1(203.85,66.08) 203.55,66.37 200.48,66.37 199.24,67.62 199.24,70.04 199.03,70.24 199.03,73.68 198.76,73.95 198.76,75.28 199.5,76.01 199.5,80.23 199.26,80.47 199.26,87.43 195.27,91.41 195.27,93.58 193.02,95.82 193.02,103.16 194.12,104.26 194.12,108.63 197.52,112.03 197.52,144.15 191.78,149.89 191.78,151.57 189.02,154.32 177.08,154.32 176.66,153.91 174.25,153.91 172.32,155.84 172.32,156.53 171.12,157.73 171.12,159.99 171.66,160.53 173.74,160.53 174.69,159.58 v1(174.69,159.29)
  BOTTOM w0.089: v1(213.14,37.36) 213.14,37.4 UH1.AW4
CPU_DDI2HPD: length 158.8
  TOP w0.102: v1(178.7,161.2) UT1.Y6
  IN1 w0.089: v1(213.5,38.41) 213.5,38.53 213.58,38.61 213.58,42.05 213.56,42.07
  IN1 w0.097: 213.56,42.07 213.56,42.61 213.96,43.01 213.96,44.85 211.01,47.8 211.01,50.34 206.37,54.98 205.22,54.98 203.68,56.53 203.68,64.32 204.67,65.31 v1(204.67,66.45)
  IN2 w0.091: v1(204.67,66.45) 204.31,66.81 200.67,66.81 199.68,67.8 199.68,70.29 199.47,70.5 199.47,73.37 200.08,73.98 200.08,80.26 199.7,80.65 199.7,89.3 198.69,90.3 198.69,92.96 200.06,94.33 200.06,95.78 199.93,95.91 199.93,108.09 197.96,110.07 197.96,144.33 192.21,150.07 192.21,151.75 188.11,155.86 184.98,155.86 183.88,154.76 176.9,154.76 176.48,154.34 174.5,154.34 174.25,154.59 174.25,155.42 174.46,155.63 174.46,156.2 177.05,158.78 177.05,159.61 178.64,161.2 v1(178.7,161.2)
  BOTTOM w0.089: v1(213.5,38.41) 213.98,38.9 UH1.AY2
  BOTTOM w0.107: v1(178.7,161.2) 178.72,161.18 RT39.1
CPU_DISPA_BCLK: length 102.7
  IN4 w0.097: v1(180.48,64.99) 179.92,65.55 179.92,79.64 177.75,81.82 177.75,90.66 177.27,91.13 172.73,95.68 172.73,103.79 172.33,104.19 168.61,104.19 168.19,104.61 168.19,112.84 v1(169.43,114.08)
  BOTTOM w0.076: CPU1.G27 169.43,113.21 v1(169.43,114.08)
  BOTTOM w0.107: RH38.1 211.02,45.75 212.67,47.4 v2(212.67,47.97) 212.67,48.6 212.05,49.22 211.38,49.22 210.45,50.14 210.25,50.14 206.35,54.04 206.35,54.83 204.75,56.43 204.75,57.76 201.2,61.31 196.7,61.31 192.62,65.39 180.87,65.39 v1(180.48,64.99)
CPU_DISPA_BCLK_R: length 6
  BOTTOM w0.089: 210.38,40.8 210.38,39.85 210.38,39.85 210.38,39.29 210.02,38.93 UH1.AM2
  BOTTOM w0.107: RH38.2 211.02,44 210.51,43.49 v2(210.51,42.07) 210.51,40.93 210.38,40.8
CPU_DISPA_SDI: length 100.9
  IN2 w0.089: 176.92,91.1 176.92,93.57 178.63,95.28 178.63,97.7 179.08,98.14
  IN2 w0.091: 176.92,91.1 176.92,86.39 184.35,78.96 184.35,75.53 183.4,74.58 183.4,72.67 183.65,72.42 183.65,69.12 185.3,67.47 185.75,67.47 186.5,66.71 187.53,66.71 190.24,64 192.67,64 197.14,59.54 199.25,59.54 201.04,57.76 203.84,57.76 204.16,57.44 v1(204.16,57.06) ; v1(175.21,112.37) 176.34,112.37 176.92,111.79 178.76,111.79 179.08,111.47 179.08,98.14
  IN3 w0.091: v1(204.16,57.06) 204.93,56.29 204.93,53.81 208.73,50.01 208.73,45.94 210.13,44.54 v1(211.65,44.54)
  BOTTOM w0.076: v1(175.21,112.37) 175.21,113.17 RC66.2
  BOTTOM w0.089: 211.16,42.08 211.16,41.95 210.8,41.59 210.8,40.95 210.61,40.76 210.61,39.27 210.5,39.16 UH1.AN2
  BOTTOM w0.107: 211.16,42.08 211.16,42.44 211.78,43.07 211.78,44.41 v1(211.65,44.54)
CPU_DISPA_SDI_R: length 7.3
  BOTTOM w0.076: CPU1.G29 169.36,114.72 173.89,114.72 174.45,115.28 v2(174.7,115.28) 175.03,115.28 RC66.1
CPU_DISPA_SDO: length 99.1
  IN4 w0.097: v1(181.09,64.98) 180.14,65.93 180.14,79.73 178.13,81.75 178.13,90.7 172.98,95.85 172.98,104.49 172.51,104.96 168.63,104.96 168.38,105.22 168.38,111.36 v1(168.7,111.68)
  BOTTOM w0.076: v1(168.7,111.68) 168.7,111.67 CPU1.G25
  BOTTOM w0.107: v1(181.09,64.98) 192.7,64.98 196.6,61.08 201.1,61.08 203.73,58.45 203.73,56.48 204.92,55.29 204.92,53.88 205.36,53.44 206.58,53.44 210.12,49.9 210.36,49.9 211.28,48.98 211.95,48.98 212.28,48.65 212.28,47.47 RH39.1
CPU_DISPA_SDO_R: length 5.1
  BOTTOM w0.089: UH1.AM1 210.19,39.49 210.19,40.87 210.27,40.94 210.27,41.62 210.13,41.75 210.13,42.08
  BOTTOM w0.107: RH39.2 v2(210.13,43.34) 210.13,42.08
CPU_DP1_AUXN: length 68.8
  IN4 w0.097: v1(189.4,149.8) 189.4,150.09 189.58,150.27 190.51,150.27 192.66,148.13 192.66,138.79 191.67,137.81 191.67,125.48 191.11,124.92 190.17,124.92 186.97,121.72 186.97,121.36 186.58,120.98 186.12,120.98 184.88,119.74 184.88,119.18 184.08,118.38 183.52,118.38 181.8,116.66 175.13,116.66 172.47,114.01 172.47,113.81 171.53,112.87 170.62,112.87 170.18,112.43 v1(170.06,112.43)
  BOTTOM w0.089: CPU1.E27 170.38,112.75 v1(170.06,112.43)
  BOTTOM w0.099: CT26.1 178.82,151.87 179.01,151.67 179.01,151.21 180.62,149.6 183.94,149.6 183.97,149.58 184.6,149.58 184.63,149.6 187.84,149.6 188.13,149.32 188.92,149.32 v1(189.4,149.8)
CPU_DP1_AUXN_C: length 12.2
  TOP w0.089: UT1.W11 v1(180,161.86)
  BOTTOM w0.099: RT76.1 178.8,153.26 CT26.2 178.82,154.25 179.03,154.46 179.65,154.46 179.68,154.49 180.26,154.49 180.29,154.46 180.44,154.46 180.54,154.56 180.54,155.29 180.03,155.8 180.03,155.8 179.17,156.65 v3(179.17,158.15) 179.17,161.16 179.59,161.58 179.72,161.58 v1(180,161.86)
CPU_DP1_AUXP: length 68.8
  IN4 w0.097: v1(170.7,112.43) 170.7,112.5 170.89,112.7 171.6,112.7 172.65,113.74 172.65,113.94 175.2,116.49 181.87,116.49 183.59,118.21 184.15,118.21 185.05,119.1 185.05,119.66 186.19,120.8 186.65,120.8 187.14,121.29 187.14,121.64 190.25,124.75 191.18,124.75 191.84,125.41 191.84,137.74 192.83,138.72 192.83,148.2 190.58,150.45 189.51,150.45 189.28,150.21 v1(188.98,150.21)
  BOTTOM w0.089: CPU1.D27 171.03,112.76 v1(170.7,112.43)
  BOTTOM w0.099: v1(188.98,150.21) 188.99,150.2 188.99,149.66 188.84,149.51 188.21,149.51 187.92,149.8 v3(184.29,149.8) 180.7,149.8 179.21,151.29 179.21,151.75 179.01,151.95 179.01,152.17 179.08,152.24 179.32,152.24 179.39,152.31 CT25.1
CPU_DP1_AUXP_C: length 12.1
  TOP w0.094: v1(180,161.21) UT1.Y11
  BOTTOM w0.099: v1(180,161.21) 180,161.28 179.91,161.38 179.67,161.38 179.37,161.08 179.37,158.46 179.4,158.44 179.4,157.86 179.37,157.83 179.37,156.73 180.11,155.99 180.11,155.99 180.73,155.37 180.73,154.48 180.52,154.27 v3(179.97,154.27) 179.11,154.27 179.01,154.17 179.01,153.86 179.11,153.77 179.26,153.77 179.39,153.64 CT25.2 179.41,153.26 RT78.1
CPU_DP1_N0: length 65.4
  TOP w0.089: v1(177.99,156.83) 177.81,157.01 177.81,157.24 CT7.1
  IN4 w0.097: v1(177.99,156.83) 177.99,156.5 178.13,156.37 178.39,156.37 179.26,157.24 181.13,157.24 181.5,156.87 181.5,153.4 183.19,151.7 183.19,150.72 188.74,145.17 188.74,140.2 187.94,139.39 187.94,128.08 183.29,123.43 171.41,123.43 170.79,122.81 170.41,122.81 168.68,121.08 167.52,121.08 167.28,121.32 166.91,121.32 v1(166.81,121.22)
  BOTTOM w0.076: v1(166.81,121.22) 166.81,121.3 167.14,121.63 167.41,121.63 167.54,121.5 167.54,119.29 167.45,119.19 167.27,119.19 167.2,119.27 167.2,119.53 CPU1.K37
CPU_DP1_N0_C: length 2.7
  TOP w0.099: CT7.2 177.99,158.63 178.64,159.28 178.76,159.28 178.91,159.43 178.91,159.84 178.82,159.93 178.76,159.93 178.68,159.84 UT1.AC7
CPU_DP1_N1: length 79.9
  TOP w0.099: CT9.1 178.76,157.23 178.76,156.52 178.49,156.25 177.64,156.25 177.3,155.9 177.3,155.67 v1(177.07,155.44)
  IN4 w0.097: v1(177.07,155.44) 177.07,155.77 176.83,156.01 176.52,156.01 176.22,156.31 176.22,157.57 177.03,158.38 184.1,158.38 184.28,158.21 186.13,158.21 186.7,157.64 186.7,155.87 186.45,155.62 185.26,155.62 184.6,154.97 184.6,153.05 185.14,152.51 185.14,151.53 190.69,145.98 190.69,139.39 189.89,138.58 189.89,127.27 182.31,119.68 168.93,119.68 168.66,119.42 168.66,117.53 168.43,117.3 v1(167.64,117.3)
  BOTTOM w0.076: CPU1.J34 167.7,117.3 v1(167.64,117.3)
CPU_DP1_N1_C: length 2.6
  TOP w0.099: CT9.2 178.94,158.39 178.94,159.09 179.37,159.52 179.37,159.86 179.43,159.93 179.5,159.93 179.6,159.83 UT1.AC9
CPU_DP1_N2: length 59.7
  TOP w0.089: 179.91,156.97 179.91,157.22 CT23.1
  TOP w0.099: 179.91,156.97 179.46,156.51 179.46,156.07 179.14,155.75 179.14,155.33 v1(178.97,155.16)
  IN4 w0.097: v1(178.97,155.16) 179.39,154.75 179.39,152.44 187.26,144.57 187.26,140.79 186.47,140 186.47,136.81 185.55,135.89 185.55,130.79 186.47,129.88 186.47,128.69 182.72,124.94 170.44,124.94 169.15,123.64 169.15,123.06 168.78,122.7 168.67,122.7 v1(168.4,122.96)
  BOTTOM w0.076: CPU1.H36 169.12,119.23 169.12,119.69 168.9,119.91 168.9,121.45 169.24,121.78 169.24,122.47 168.95,122.76 168.61,122.76 v1(168.4,122.96)
CPU_DP1_N2_C: length 2.4
  TOP w0.099: UT1.AC11 180.52,159.81 180.46,159.88 180.39,159.88 180.3,159.79 180.3,159.52 180.34,159.47 180.34,159.39 180.18,159.23 180.18,158.68 180.09,158.58 180.09,158.39 CT23.2
CPU_DP1_N3: length 59.8
  TOP w0.089: CT24.1 181.05,157.23 181.04,157.23 181.04,157.1 180.95,157 180.79,157 180.56,156.77 180.56,156.56 180.41,156.41
  TOP w0.099: 180.41,156.41 v1(180.34,156.34)
  IN4 w0.097: v1(167.31,122.8) 168.1,122.01 168.73,122.01 171.01,124.28 182.98,124.28 187.12,128.42 187.12,132.47 186.55,133.04 186.55,135.82 187.12,136.39 187.12,139.73 187.91,140.52 187.91,144.84 180.09,152.65 180.09,155.34 180.64,155.89 180.64,156.03 v1(180.34,156.34)
  BOTTOM w0.076: CPU1.J38 168.46,120.4 168.46,120.61 168.38,120.68 168.28,120.68 168.19,120.78 168.19,121.86 167.31,122.73 v1(167.31,122.8)
CPU_DP1_N3_C: length 2.3
  TOP w0.099: CT24.2 180.85,158.08 181.24,158.46 181.24,159.45 181.21,159.48 181.21,159.71 181.34,159.84 181.44,159.84 UT1.AC13
CPU_DP1_P0: length 65.4
  TOP w0.089: CT6.1 177.63,157.22 177.63,157.05 v1(177.41,156.83)
  IN4 w0.097: v1(177.41,156.83) 177.42,156.83 178.05,156.2 178.46,156.2 179.33,157.07 181.06,157.07 181.32,156.8 181.32,153.32 183.02,151.63 183.02,150.65 188.57,145.1 188.57,140.27 187.77,139.46 187.77,128.15 183.22,123.6 171.34,123.6 170.72,122.98 170.34,122.98 168.61,121.25 167.59,121.25 167.35,121.49 167.12,121.49 v1(166.8,121.81)
  BOTTOM w0.076: CPU1.K36 167.34,119.02 167.52,119.02 167.71,119.21 167.71,121.57 167.48,121.8 166.81,121.8 v1(166.8,121.81)
CPU_DP1_P0_C: length 2.7
  TOP w0.099: CT6.2 177.8,158.39 177.8,158.71 178.45,159.36 178.45,159.95 UT1.AB7
CPU_DP1_P1: length 79.8
  TOP w0.099: CT8.1 178.95,157.24 178.95,156.44 178.57,156.05 177.72,156.05 177.49,155.82 177.49,155.6 v1(177.65,155.44)
  IN4 w0.097: v1(167.64,117.95) 167.79,118.1 168,118.1 168.09,118.01 168.09,117.57 168.19,117.47 168.36,117.47 168.49,117.6 168.49,119.49 168.86,119.86 182.24,119.86 189.72,127.34 189.72,138.66 190.52,139.46 190.52,145.91 184.97,151.46 184.97,152.44 184.43,152.98 184.43,155.04 185.18,155.8 186.38,155.8 186.53,155.94 186.53,157.57 186.06,158.04 184.2,158.04 184.03,158.21 177.1,158.21 176.39,157.5 176.39,156.38 176.59,156.18 176.9,156.18 177.64,155.44 v1(177.65,155.44)
  BOTTOM w0.076: v1(167.64,117.95) 167.84,117.95 168.02,118.12 CPU1.J35
CPU_DP1_P1_C: length 2.6
  TOP w0.099: CT8.2 179.14,159.01 179.54,159.42 179.69,159.42 179.83,159.55 179.83,159.89 179.82,159.89 179.82,159.9 179.6,160.12 UT1.AB9
CPU_DP1_P2: length 59.7
  TOP w0.089: 180.09,156.89 180.09,157.24 CT10.1
  TOP w0.099: 180.09,156.89 180.09,156.88 179.65,156.43 179.65,155.99 179.33,155.67 179.33,155.39 v1(179.56,155.16)
  IN4 w0.097: v1(168.42,122.4) 168.55,122.52 168.86,122.52 169.32,122.99 169.32,123.57 170.51,124.76 182.79,124.76 186.64,128.62 186.64,129.95 185.72,130.86 185.72,135.82 186.64,136.74 186.64,139.93 187.43,140.72 187.43,144.65 179.56,152.51 v1(179.56,155.16)
  BOTTOM w0.076: CPU1.H37 168.81,119.28 168.73,119.21 168.49,119.21 168.41,119.29 168.41,119.73 168.73,120.05 168.73,121.52 169.07,121.85 169.07,122.4 168.88,122.59 168.61,122.59 v1(168.42,122.4)
CPU_DP1_P2_C: length 2.5
  TOP w0.099: CT10.2 180.28,158.5 180.37,158.6 180.37,159.15 180.75,159.52 180.75,159.91 180.52,160.14 UT1.AB11
CPU_DP1_P3: length 59.8
  TOP w0.089: CT11.1 181.23,157.23 181.23,157.02 181.02,156.81 180.86,156.81 180.75,156.7 180.75,156.49 180.74,156.48 180.82,156.41
  TOP w0.099: v1(180.92,156.34) 180.89,156.34 180.82,156.41
  IN4 w0.097: v1(167.3,122.23) 167.63,122.23 168.03,121.84 168.8,121.84 171.08,124.11 183.05,124.11 187.29,128.35 187.29,132.54 186.72,133.11 186.72,135.75 187.29,136.32 187.29,139.66 188.08,140.45 188.08,144.91 180.27,152.73 180.27,155.27 180.82,155.82 180.82,156.23 v1(180.92,156.34)
  BOTTOM w0.076: v1(167.3,122.23) 167.58,122.23 167.99,121.81 167.99,119.59 CPU1.J37
CPU_DP1_P3_C: length 2.4
  TOP w0.099: UT1.AB13 181.67,159.95 181.67,159.55 181.43,159.31 181.43,158.38 181.42,158.38 CT11.2
CPU_DP2_AUXN: length 69.5
  IN4 w0.097: v1(170.06,111.67) 170.29,111.89 172.37,111.89 173.16,112.67 173.16,113.74 175.22,115.81 182.11,115.81 183.86,117.56 184.42,117.56 185.7,118.83 185.7,119.25 186.61,120.15 186.92,120.15 187.22,120.45 187.95,120.45 190.92,123.41 191.51,123.41 192.84,124.74 192.84,137.81 193.48,138.45 193.48,148.47 190.61,151.33 188.45,151.33 188.25,151.14 188.25,151.13 v1(188.01,151.13)
  BOTTOM w0.089: CPU1.E26 170.38,111.99 v1(170.06,111.67)
  BOTTOM w0.099: CT36.1 181.94,152.36 181.84,152.27 181.62,152.27 181.55,152.2 181.55,151.33 182.48,150.39 187.83,150.39 188.01,150.58 v1(188.01,151.13)
CPU_DP2_AUXN_C: length 10.3
  TOP w0.089: UT1.W12 v1(180.65,161.86)
  BOTTOM w0.099: RT77.1 182.56,153.27 CT36.2 181.95,154.33 181.49,154.78 v3(181.49,155.23) 181.49,155.74 181.56,155.8 181.56,156.56 181.4,156.71 181.4,160.52 181.27,160.65 181.27,161.32 180.73,161.86 v1(180.65,161.86)
CPU_DP2_AUXP: length 69.5
  IN4 w0.097: v1(188.43,150.72) 188.43,151.07 188.52,151.16 190.54,151.16 193.31,148.4 193.31,138.52 192.67,137.88 192.67,124.81 191.44,123.59 190.84,123.59 187.88,120.62 187.14,120.62 186.85,120.33 186.53,120.33 185.53,119.32 185.53,118.91 184.35,117.73 183.79,117.73 182.04,115.98 175.15,115.98 172.98,113.81 172.98,112.74 172.3,112.06 169.94,112.06 169.54,111.67 v1(169.43,111.67)
  BOTTOM w0.089: v1(169.43,111.67) 169.73,111.97 CPU1.F26
  BOTTOM w0.099: v1(188.43,150.72) 187.91,150.2 182.4,150.2 181.35,151.25 CT35.1
CPU_DP2_AUXP_C: length 10.3
  TOP w0.089: UT1.Y12 v1(180.65,161.21)
  BOTTOM w0.099: RT79.1 181.34,153.26 CT35.2 181.35,153.67 181.45,153.77 181.65,153.77 181.75,153.86 181.75,154.25 181.3,154.7 181.3,154.91 181.27,154.94 181.27,155.52 181.3,155.54 181.3,155.82 181.36,155.88 181.36,156.48 181.21,156.63 181.21,160.44 181.08,160.57 181.08,161.22 180.89,161.41 180.75,161.41 180.65,161.31 v1(180.65,161.21)
CPU_DP2_N0: length 66.9
  TOP w0.099: v1(187.09,155.06) 187.09,154.36 186.74,154.02 182.36,154.02 181.74,154.64 181.74,156.43 182,156.68 CT28.1
  IN4 w0.097: v1(187.09,155.06) 187.09,151.43 191.99,146.52 191.99,138.85 191.19,138.04 191.19,126.73 181.67,117.21 172.75,117.21 172.47,116.94 171.18,116.94 170.93,116.68 169.5,116.68 v1(169.31,116.49)
  BOTTOM w0.076: v1(169.31,116.49) 169.31,116.55 168.89,116.96 CPU1.H33
CPU_DP2_N0_C: length 2.4
  TOP w0.099: UT1.AC15 182.36,159.81 182.29,159.87 182.2,159.88 182.13,159.8 182.13,159.54 182.31,159.36 182.31,158.94 182.31,158.78 182.31,158.67 182.19,158.54 182.19,158.2 CT28.2
CPU_DP2_N1: length 57
  TOP w0.089: CT30.1 183.35,157.22 183.35,157 183.33,156.98 v1(183.16,156.81)
  IN4 w0.097: v1(183.16,156.81) 183.57,156.4 183.57,156.15 183.1,155.68 183.1,152.47 183.67,151.9 183.67,150.92 189.22,145.37 189.22,140 188.42,139.19 188.42,127.88 183.06,122.52 170.89,122.52 170.65,122.29 170.65,121.71 170.55,121.62 170.41,121.62 170.08,121.94 v1(170.08,121.94)
  BOTTOM w0.076: CPU1.G38 169.26,120.21 169.08,120.39 169.08,120.56 169.15,120.63 169.36,120.63 169.41,120.68 169.41,121.62 169.57,121.77 170,121.77 170.08,121.85 v1(170.08,121.94)
CPU_DP2_N1_C: length 2.4
  TOP w0.099: CT30.2 183.14,158.3 183.24,158.4 183.33,158.4 183.39,158.46 183.39,158.69 183.27,158.82 183.27,159.29 183.05,159.51 183.05,159.79 183.13,159.86 183.21,159.86 183.28,159.79 UT1.AC17
CPU_DP2_N2: length 60.3
  TOP w0.099: CT32.1 184.54,157.17 184.54,156.44 184.7,156.27 185.43,155.55 185.43,155.2 v1(185.24,155.02)
  IN4 w0.097: v1(185.24,155.02) 185.66,154.6 185.66,151.69 191.17,146.18 191.17,139.19 190.37,138.39 190.37,127.07 181.38,118.08 175.77,118.08 175.27,118.59 172.8,118.59 171.91,117.69 170.82,117.69 170.55,117.43 169.82,117.43 169.62,117.62 169.62,117.95 169.74,118.08 169.9,118.08 169.99,117.99 v1(169.99,117.96)
  BOTTOM w0.076: CPU1.F35 169.9,117.96 v1(169.99,117.96)
CPU_DP2_N2_C: length 2.4
  TOP w0.099: UT1.AC19 184.2,159.76 184.1,159.86 184.03,159.86 183.97,159.79 183.97,159.51 184.11,159.36 184.17,159.36 184.24,159.3 184.24,159.07 184.48,158.83 184.48,158.21 CT32.2
CPU_DP2_N3: length 59.3
  TOP w0.089: CT34.1 185.62,157.23 185.62,156.78 v1(185.48,156.64)
  IN4 w0.097: v1(171.21,121.25) 171.62,121.66 183.36,121.66 189.24,127.54 189.24,138.85 190.04,139.66 190.04,145.71 184.49,151.26 184.49,152.24 183.95,152.78 183.95,155.34 184.67,156.05 184.67,157.15 184.86,157.34 185.73,157.34 185.83,157.24 185.83,156.98 185.49,156.64 v1(185.48,156.64)
  BOTTOM w0.076: v1(171.21,121.25) 170.97,121.25 170.57,120.85 170.57,120.04 170.67,119.94 170.67,119.45 170.38,119.16 CPU1.E36
CPU_DP2_N3_C: length 2.5
  TOP w0.099: CT34.2 185.61,158.2 185.61,158.72 185.24,159.1 185.24,159.29 185.18,159.35 184.96,159.35 184.89,159.42 184.89,159.74 184.96,159.81 185.03,159.81 185.12,159.72 UT1.AC21
CPU_DP2_P0: length 66.8
  TOP w0.099: CT27.1 182.57,157.06 182.51,157 182.29,157 182.19,156.9 182.19,156.6 181.94,156.35 181.94,154.72 182.44,154.21 186.66,154.21 186.89,154.44 186.89,154.68 186.51,155.06 v1(186.41,155.06)
  IN4 w0.097: v1(186.41,155.06) 186.52,155.06 186.91,154.66 186.91,151.35 191.82,146.45 191.82,138.92 191.02,138.12 191.02,126.8 181.6,117.38 172.68,117.38 172.4,117.11 171.11,117.11 170.86,116.85 169.58,116.85 169.34,117.09 v1(169.33,117.09)
  BOTTOM w0.076: v1(169.33,117.09) CPU1.H34
CPU_DP2_P0_C: length 2.4
  TOP w0.099: CT27.2 182.38,158.2 182.38,158.46 182.51,158.59 182.51,158.78 182.51,158.94 182.51,159.41 182.59,159.49 182.59,159.87 182.37,160.18 UT1.AB15
CPU_DP2_P1: length 57
  TOP w0.089: CT29.1 183.71,157.42 183.52,157.24 183.52,157.04 v1(183.74,156.82)
  IN4 w0.097: v1(183.74,156.82) 183.74,156.08 183.27,155.61 183.27,152.54 183.84,151.97 183.84,150.99 189.39,145.44 189.39,139.93 188.59,139.12 188.59,127.81 183.13,122.35 170.96,122.35 170.82,122.22 170.82,121.64 170.63,121.44 170.27,121.44 v1(170.13,121.31)
  BOTTOM w0.076: v1(170.13,121.31) 170.13,121.4 169.95,121.58 169.66,121.58 169.6,121.53 169.6,120.02 169.59,120.01 CPU1.F37
CPU_DP2_P1_C: length 2.4
  TOP w0.099: CT29.2 183.59,158.13 183.59,158.77 183.46,158.9 183.46,159.5 183.51,159.55 183.51,159.87 183.29,160.18 UT1.AB17
CPU_DP2_P2: length 60.2
  TOP w0.099: CT31.1 184.73,157.3 184.73,156.52 185.62,155.63 185.62,155.23 v1(185.83,155.02)
  IN4 w0.097: v1(185.83,155.02) 185.83,151.76 191.34,146.25 191.34,139.12 190.54,138.31 190.54,127 181.45,117.91 175.7,117.91 175.2,118.41 172.87,118.41 171.98,117.52 170.89,117.52 170.62,117.25 169.74,117.25 169.44,117.55 169.44,117.69 v1(169.2,117.93)
  BOTTOM w0.076: CPU1.F34 169.52,117.61 v1(169.2,117.93)
CPU_DP2_P2_C: length 2.4
  TOP w0.099: UT1.AB19 184.43,159.95 184.43,159.15 184.67,158.91 184.67,158.2 CT31.2
CPU_DP2_P3: length 59.3
  TOP w0.089: v1(186.07,156.64) 185.8,156.91 185.8,157.23 CT33.1
  IN4 w0.097: v1(186.07,156.64) 186,156.71 186,157.31 185.8,157.51 184.79,157.51 184.49,157.22 184.49,156.12 183.78,155.41 183.78,152.71 184.32,152.17 184.32,151.19 189.87,145.64 189.87,139.73 189.07,138.93 189.07,127.61 183.29,121.83 v1(171.21,121.83)
  BOTTOM w0.076: CPU1.E37 170.44,119.62 170.44,119.9 170.39,119.94 170.39,120.93 170.76,121.3 170.76,121.75 170.84,121.83 v1(171.21,121.83)
CPU_DP2_P3_C: length 2.5
  TOP w0.099: CT33.2 185.81,158.2 185.81,158.8 185.43,159.18 185.43,159.4 185.35,159.48 185.35,159.95 UT1.AB21
CPU_EDP_AUX: length 36.4
  IN4 w0.097: v1(192.03,121.48) 192.37,121.82 192.37,122.11 192.27,122.21 190.63,122.21 188.11,119.68 187.4,119.68 187,119.28 187,118.28 184.82,116.11 183.33,116.11 182.25,115.03 176.98,115.03 175.01,113.06 175.01,112.75 174.39,112.12 174.39,111.98 174.54,111.82 174.68,111.82 v1(174.8,111.95)
  BOTTOM w0.076: CPU1.C26 171.82,111.94 171.82,111.83 172.02,111.62 173.1,111.62 173.48,111.25 174.34,111.25 174.56,111.47 174.56,111.71 v1(174.8,111.95)
  BOTTOM w0.099: CV434.2 189.35,123.2 189.2,123.35 189.2,123.46 189.04,123.63 189.04,124.11 189.93,125 191.14,125 192.29,123.86 192.29,121.74 v1(192.03,121.48)
CPU_EDP_AUX#: length 36.5
  IN4 w0.097: v1(174.02,111.95) 174.21,112.14 174.21,112.19 174.26,112.23 174.84,112.82 174.84,113.13 176.91,115.2 182.18,115.2 183.26,116.28 184.75,116.28 186.83,118.36 186.83,119.35 187.33,119.86 188.04,119.86 190.56,122.38 192.34,122.38 192.54,122.18 192.54,121.55 v1(192.61,121.48)
  BOTTOM w0.076: CPU1.B26 172.27,112.14 172.11,112.14 171.99,112.02 171.99,111.9 172.09,111.79 173.17,111.79 173.55,111.42 174.27,111.42 174.39,111.54 174.39,111.86 174.3,111.95 v1(174.02,111.95)
  BOTTOM w0.099: CV435.2 188.85,124.19 189.85,125.19 191.22,125.19 192.48,123.94 192.48,123.81 192.49,123.81 192.49,123.81 192.49,121.6 v1(192.61,121.48)
CPU_EDP_AUX#_C: length 2.4
  BOTTOM w0.099: CV435.1 189.11,122.35 189.11,122.01 189.08,121.99 189.08,121.41 189.11,121.38 189.11,121.12 188.99,121 UV21.29
CPU_EDP_AUX_C: length 2.4
  BOTTOM w0.099: UV21.30 189.39,121.04 189.3,121.13 v3(189.3,121.7) 189.3,122.1 189.8,122.6 CV434.1
CPU_EDP_N0_C: length 4.2
  BOTTOM w0.099: UV21.12 184.55,116.54 184.44,116.43 183.9,116.43 183.44,116.9 183.25,116.9 183.22,116.93 182.64,116.93 182.6,116.9 182.27,116.9 182.24,116.87 181.65,116.87 CV427.1
CPU_EDP_N1_C: length 2.3
  BOTTOM w0.099: CV429.1 183.28,118.28 183.49,118.08 183.71,118.08 184.15,117.64 184.4,117.64 184.4,117.64 184.48,117.64 184.58,117.74 UV21.15
CPU_EDP_N2_C: length 4.4
  BOTTOM w0.099: CV431.1 181.72,119.35 v3(182.11,119.35) 183.34,119.35 184.25,118.43 184.57,118.43 184.68,118.54 UV21.17
CPU_EDP_N3_C: length 2.7
  BOTTOM w0.099: CV433.1 183.68,120.62 183.91,120.62 184.16,120.37 184.16,119.95 184.43,119.67 184.51,119.67 184.58,119.74 UV21.20
CPU_EDP_P0_C: length 4.2
  BOTTOM w0.099: CV426.1 181.73,116.68 182.32,116.68 182.35,116.7 v3(182.93,116.7) 183.36,116.7 183.82,116.24 184.47,116.24 184.57,116.14 UV21.11
CPU_EDP_P1_C: length 2.3
  BOTTOM w0.099: UV21.14 184.59,117.34 184.49,117.45 184.32,117.45 184.32,117.45 184.07,117.45 183.66,117.86 183.38,117.86 183.28,117.76 CV428.1
CPU_EDP_P2_C: length 4.4
  BOTTOM w0.099: UV21.16 184.73,118.14 184.63,118.23 184.57,118.23 184.57,118.23 184.17,118.23 183.26,119.15 182.44,119.15 182.4,119.12 181.82,119.12 181.79,119.15 181.67,119.15 CV430.1
CPU_EDP_P3_C: length 2.7
  BOTTOM w0.099: CV432.1 183.64,120.43 183.83,120.43 183.97,120.29 183.97,119.87 184.35,119.48 184.51,119.48 184.51,119.48 184.51,119.48 184.65,119.34 UV21.19
CPU_EDP_TX0N: length 16.2
  IN3 w0.099: v1(177.67,118.56) 177.67,118.96 177.28,119.35 176.02,119.35 174.11,117.44 173.35,117.44 172.28,116.37 172.28,115.98 171.24,114.94 171,114.94 170.71,114.65 170.71,114.08 v1(170.71,114.08)
  BOTTOM w0.076: CPU1.E29 170.54,114.44 170.71,114.27 170.71,114.08 v1(170.71,114.08)
  BOTTOM w0.099: v1(177.67,118.56) 177.59,118.56 177.47,118.44 177.47,118.23 177.47,117.2 177.91,116.76 180.63,116.76 180.73,116.86 CV427.2
CPU_EDP_TX0P: length 16.2
  IN3 w0.099: v1(171.42,114.04) 171.4,114.06 171.25,114.06 170.9,114.41 170.9,114.57 171.07,114.75 171.31,114.75 172.47,115.91 172.47,116.3 173.43,117.25 174.19,117.25 176.1,119.16 177.21,119.16 177.39,118.98 177.39,118.8 177.15,118.56 v1(177,118.56)
  BOTTOM w0.076: CPU1.D29 171.11,114.44 171.42,114.13 v1(171.42,114.04)
  BOTTOM w0.099: v1(177,118.56) 177.01,118.56 177.24,118.33 177.24,117.16 177.83,116.57 180.42,116.57 CV426.2
CPU_EDP_TX1N: length 16.9
  IN3 w0.099: v1(178.81,118.56) 178.61,118.36 178.61,118.1 178.52,118.01 178.52,118.01 178.41,117.9 178.36,117.9 178.35,117.9 178.04,117.9 178.04,117.89 176.8,117.89 172.13,113.23 171.24,113.23 171.16,113.15 171.16,112.89 171.09,112.81 170.83,112.81 170.72,112.92 v1(170.72,113.24)
  BOTTOM w0.076: v1(170.72,113.24) 170.38,113.58 CPU1.E28
  BOTTOM w0.099: CV429.2 182.7,118.15 182.6,118.06 179.86,118.06 179.7,117.89 178.82,117.89 178.57,118.14 178.57,118.36 178.78,118.56 v1(178.81,118.56)
CPU_EDP_TX1P: length 16.8
  IN3 w0.099: v1(178.27,118.56) 178.43,118.4 178.43,118.18 178.34,118.08 178.04,118.08 178.04,118.08 176.72,118.08 172.05,113.41 171.24,113.41 171.23,113.41 171.16,113.41 171.16,113.42 171.14,113.42 170.93,113.63 170.47,113.63 v1(170.08,113.24)
  BOTTOM w0.076: v1(170.08,113.24) 169.73,113.58 CPU1.F28
  BOTTOM w0.099: CV428.2 182.36,117.86 179.94,117.86 179.78,117.7 178.74,117.7 178.38,118.06 178.38,118.45 v1(178.27,118.56)
CPU_EDP_TX2N: length 13.1
  IN3 w0.099: v1(179.33,119.22) 179.33,119 179.18,118.84 179.18,117.73 178.74,117.29 177.52,117.29 174.63,114.4 174.63,114.08 v1(174.51,113.95)
  BOTTOM w0.076: CPU1.B29 172.48,114.44 172.56,114.36 172.56,114.07 172.68,113.95 173.33,113.95 173.5,114.13 174.11,114.13 174.38,114.4 174.64,114.4 174.73,114.31 174.73,114.13 174.55,113.95 v1(174.51,113.95)
  BOTTOM w0.099: CV431.2 180.72,119.75 180.38,119.41 179.86,119.41 179.67,119.22 v1(179.33,119.22)
CPU_EDP_TX2P: length 13
  IN3 w0.099: v1(179.71,118.78) 179.61,118.88 179.47,118.88 179.37,118.77 179.37,117.65 178.82,117.11 177.6,117.11 174.82,114.33 174.82,114.23 v1(175.09,113.95)
  BOTTOM w0.076: CPU1.A29 172.81,114.44 172.73,114.36 172.73,114.22 172.81,114.14 173.25,114.14 173.41,114.31 174.02,114.31 174.3,114.59 174.68,114.59 174.89,114.38 174.89,114.1 175.04,113.95 v1(175.09,113.95)
  BOTTOM w0.099: CV430.2 180.73,118.92 180.43,119.22 179.94,119.22 179.71,119 v1(179.71,118.78)
CPU_EDP_TX3N: length 18.6
  IN3 w0.099: v1(179.77,120.3) 179.83,120.24 179.83,119.62 180.12,119.32 180.12,116.59 179.45,115.91 177.64,115.91 175.31,113.58 174.3,113.58 174.09,113.38 174.09,113.15 173.92,112.98 v1(173.79,112.98)
  BOTTOM w0.076: v1(173.79,112.98) 173.98,112.98 174.1,113.1 174.1,113.29 173.98,113.4 173.84,113.4 173.82,113.39 173.63,113.39 173.45,113.21 173.35,113.21 173.22,113.34 172.18,113.34 172.01,113.5 172.01,113.63 172.12,113.73 172.26,113.73 CPU1.B28
  BOTTOM w0.099: v1(179.77,120.3) 180,120.53 180,120.71 180.22,120.94 180.93,120.94 181,120.87 181.36,120.87 181.39,120.9 181.97,120.9 182,120.87 182.55,120.87 CV433.2
CPU_EDP_TX3P: length 18.6
  IN3 w0.099: v1(174.44,112.97) 174.38,112.97 174.28,113.07 174.28,113.3 174.38,113.4 175.38,113.4 177.72,115.73 179.52,115.73 180.3,116.51 180.3,119.4 180.01,119.69 180.01,119.97 180.34,120.3 v1(180.35,120.3)
  BOTTOM w0.076: CPU1.C28 171.8,113.54 171.8,113.45 171.82,113.43 171.82,113.42 172.1,113.15 173.14,113.15 173.27,113.02 173.27,112.99 173.64,112.62 174.1,112.62 v1(174.44,112.97)
  BOTTOM w0.099: CV432.2 182.7,120.37 182.38,120.68 v3(181.68,120.68) 180.92,120.68 180.85,120.75 180.3,120.75 180.19,120.63 180.19,120.46 v1(180.35,120.3)
CPU_FAN_FB: length 221
  TOP w0.107: v1(105.04,52.8) 104.6,53.23 104.6,53.74 104.85,53.98 105.57,53.98 106.05,54.46 106.05,56.07 105.03,57.1 RF1.1 104.47,57.31 104.14,57.63 DF1.2 ; UE5.28 294.74,24.99 295.1,25.36 295.1,27.72 v2(294.45,28.37) 293.66,29.17 v1(293.66,29.31)
  IN2 w0.091: v1(293.66,29.31) 293.66,29.46 287.93,35.19 284.48,35.19 283.98,35.68 273.16,35.68 263.84,45 229.1,45 228.04,46.07 217.39,46.07 216.49,46.96 214.89,46.96 214.54,47.32 209.98,47.32 209.38,47.92 209.38,50.29 206.86,52.81 203.11,52.81 199.24,48.95 196.64,48.95 192.88,52.71 184.71,52.71 182.89,50.88 180.89,50.88 178.47,48.46 177.43,48.46 175.9,50 175.29,50 172.83,52.46 149.82,52.46 149.06,51.69 148.23,51.69 147.85,52.07 105.76,52.07 v1(105.04,52.8)
CPU_FAN_PWM: length 223.3
  TOP w0.107: UE5.26 295.54,24.94 295.67,25.07 295.67,26.9 v2(295.67,27.02) 295.67,27.96 294.61,29.01 v1(294.61,29.31)
  TOP w0.254: JFAN1.2 105.62,62.69 105.04,62.11 RF2.1 105.24,61.2 105.8,60.64 105.8,59.21 105.55,58.96 v1(105.23,58.96)
  IN2 w0.091: v1(105.23,58.96) 106.18,58.01 106.18,53.02 106.9,52.29 147.94,52.29 148.32,51.91 148.97,51.91 149.73,52.67 173.75,52.67 177.74,48.68 178.38,48.68 180.8,51.1 182.8,51.1 184.62,52.93 194.71,52.93 196.14,51.5 199.57,51.5 201.74,53.67 206.31,53.67 209.6,50.38 209.6,48.01 210.07,47.54 214.63,47.54 214.99,47.18 216.59,47.18 217.48,46.29 228.13,46.29 229.2,45.22 263.93,45.22 273.25,35.9 284.07,35.9 284.57,35.4 288.03,35.4 293.42,30.01 293.91,30.01 v1(294.61,29.31)
CPU_ID: length 3.1
  TOP w0.089: RH23.1 RH24.1 209.91,24.2 209.69,23.97 209.69,23.46 209.29,23.06 v1(209.18,23.06)
  BOTTOM w0.089: UH1.AL35 209.65,22.74 209.37,23.02 209.22,23.02 v1(209.18,23.06)
CPU_TRIGGER: length 103.7
  TOP w0.107: RH192.1 176.05,109.72 176.05,108.76 175.07,107.79 v2(174.44,107.79) 173.62,107.79 173.24,107.41 173.24,105.25 173.62,104.87 176.22,104.87 176.73,104.36 179.6,104.36 180.51,103.45 v1(180.51,97.63)
  IN1 w0.097: v1(204.03,71.72) 203.34,71.72 202.71,71.09 202.71,69.41 200.64,67.34 200.64,59.21 201.01,58.84 201.01,54.75 197.52,51.27 197.52,50.65 199.36,48.82 199.36,46.46 203.7,42.11 206.1,42.11 206.97,41.24 v1(208.1,41.24)
  IN4 w0.097: v1(204.03,71.72) 203.62,72.14 203.3,72.14 199.97,75.47 199.71,75.47 197.94,77.24 197.94,85.79 195.5,88.23 192.79,88.23 187.74,93.29 187.74,94.52 184.62,97.63 v1(180.51,97.63)
  BOTTOM w0.089: UH1.AK1 208.92,39.45 208.92,39.96 209.06,40.1 209.06,40.62 208.83,40.85 208.62,40.85 208.23,41.24 v1(208.1,41.24)
CPU_XDP_TRST#: length 313
  TOP w0.107: v4(129.74,157.13) 129.24,157.63 RH497.2 129.24,158.37 128.76,158.85 126.44,158.85 125.53,159.76 124.99,159.76 124.1,160.64 122.87,160.64 122.47,161.05 118.59,161.05 118.21,160.67 v1(118.21,160.02) 118.21,159.77 JPCMC.28
  IN1 w0.097: v1(213.79,36.67) 214.13,37.02 214.13,40.29 215.64,41.8 215.64,42.59 215.09,43.14 215.09,45.3 212.86,47.53 212.86,51.19 209.07,54.98 v1(208.01,54.98) ; v1(130.58,115.85) 130.53,115.85 130.18,116.2 130.18,121.52 129.57,122.13 129.57,123.92 129.13,124.37 129.13,125.7 125.97,128.86 120.66,128.86 117.87,131.64 117.87,147.05 120.81,149.99 121.2,149.99 121.66,150.44 122.16,150.44 122.67,150.95 122.67,152.03 123.61,152.96 123.61,154.29 124.48,155.16 124.48,158.33 123.75,159.06 119.3,159.06 118.34,160.02 v1(118.21,160.02)
  IN3 w0.091: v1(113.18,36.61) 113.18,37.63 110.61,40.2 109.36,40.2 108.28,41.29 108.08,41.48 108.08,57.34 108.28,57.54 108.28,61.11 108.08,61.31 108.08,65 108.28,65.19 120.74,77.66 120.74,81.55 125.89,86.7 125.89,98.04 128.87,101.02 128.87,102.42 132,105.54 132,110.85 131.33,111.52 131.33,112.19 130.8,112.72 130.8,113.02 130.43,113.38 130.43,115.65 130.58,115.8 v1(130.58,115.85)
  IN4 w0.097: v1(208.01,54.98) 207.61,54.98 206.07,56.52 202.15,56.52 199.56,59.11 196.27,59.11 192.69,55.52 188.44,55.52 185.96,53.04 185.96,42.72 179.31,36.08 166.17,36.08 161.4,31.31 135.96,31.31 130.22,37.06 122.78,37.06 122.55,37.29 113.87,37.29 v1(113.18,36.61)
  BOTTOM w0.076: CPU1.BP30 133.36,115.29 133,115.29 132.84,115.45 131.05,115.45 130.7,115.8 130.64,115.8 v1(130.58,115.85)
  BOTTOM w0.089: UH1.AY5 214.16,37.04 v1(213.79,36.67)
CRX_N8: length 40.5
  IN4 w0.097: v1(135.82,161.26) 135.82,159.56 136.68,158.71 138.01,158.71 139.16,159.86 144.44,159.86 146.24,161.66 146.24,166.91 149.05,169.72 151.63,169.72 156.39,174.48 157.62,174.48 158.56,175.42 158.56,175.77 v1(158.74,175.94)
  BOTTOM w0.099: UM8.42 134.61,159.38 134.75,159.53 134.75,160.05 135.46,160.75 135.82,160.75 135.96,160.9 135.96,161.12 v1(135.82,161.26) ; JCDRA.16 158.62,176.8 158.41,176.6 158.41,176.27 v1(158.74,175.94)
CRX_N9: length 48.6
  IN4 w0.097: v1(159.91,175.87) 159.9,175.87 159.71,176.06 159.71,176.7 159.85,176.84 160.4,176.84 160.62,176.62 160.62,173.78 159.52,172.68 159.52,170.55 157.47,168.5 155.8,168.5 155.41,168.1 155.41,167.17 147.63,159.39 139.36,159.39 138.2,158.23 136.48,158.23 134.31,160.4 134.31,160.93 133.57,161.67 132.65,161.67 132.21,161.23 132.21,159.89 132.11,159.8 131.87,159.8 131.78,159.89 v1(131.78,160.03)
  BOTTOM w0.099: JCDRA.19 159.82,176.73 159.71,176.63 159.71,176.07 v1(159.91,175.87) ; UM8.37 132.11,159.84 131.92,160.03 v1(131.78,160.03)
CRX_N10: length 47.1
  IN4 w0.097: v1(132.83,160.56) 133.01,160.38 133.01,159.9 134.8,158.11 134.8,157.47 135.19,157.08 138.39,157.08 139.45,158.14 143.4,158.14 143.55,158.29 145.39,158.29 145.54,158.14 148.02,158.14 155.86,165.98 157.5,165.98 160.09,168.57 160.09,169.96 160.79,170.66 160.79,172.64 161.31,173.16 161.69,173.16 163.08,174.55 v1(163.08,175.36)
  BOTTOM w0.099: UM8.39 133.11,159.42 133.23,159.54 133.23,159.84 133.07,160 133.07,160.32 v1(132.83,160.56) ; JCDRA.25 162.22,176.81 162.15,176.74 162.15,176.54 162.76,175.93 162.76,175.61 163.01,175.36 v1(163.08,175.36)
CRX_N11: length 43.2
  IN4 w0.097: v1(164.71,176.19) 164.63,176.27 164.63,176.85 163.73,177.75 158.24,177.75 157.15,176.66 157.15,176.41 151.47,170.72 148.85,170.72 145.41,167.28 145.41,162 144.54,161.13 139.26,161.13 138.12,159.99 v1(136.91,159.99)
  BOTTOM w0.099: v1(136.91,159.99) 135.92,159.99 135.71,159.78 135.71,159.57 135.61,159.47 UM8.44 ; v1(164.71,176.19) 164.51,176.39 164.51,176.6 164.62,176.71 JCDRA.31
CRX_P8: length 40.5
  IN4 w0.097: v1(136.41,161.26) 136.39,161.26 136,160.86 136,159.64 136.75,158.88 137.93,158.88 139.09,160.04 144.37,160.04 146.06,161.73 146.06,166.98 148.98,169.89 151.56,169.89 156.32,174.66 157.55,174.66 158.39,175.49 158.39,175.74 158.21,175.92 158.07,175.92 158.02,175.86 v1(157.87,175.86)
  BOTTOM w0.099: v1(157.87,175.86) 158.22,176.21 JCDRA.15 ; v1(136.41,161.26) 136.16,161.01 136.16,160.82 135.9,160.56 135.54,160.56 134.95,159.97 134.95,159.57 135.11,159.41 UM8.43
CRX_P9: length 48.6
  IN4 w0.097: v1(132.61,159.99) 132.38,160.22 132.38,161.15 132.72,161.5 133.5,161.5 134.14,160.86 134.14,160.33 136.41,158.06 138.28,158.06 139.43,159.21 147.7,159.21 155.58,167.1 155.58,168.03 155.87,168.32 157.54,168.32 159.69,170.48 159.69,172.61 160.79,173.7 160.79,176.69 160.47,177.01 159.78,177.01 159.54,176.77 159.54,176.08 v1(159.33,175.87)
  BOTTOM w0.099: v1(159.33,175.87) 159.52,176.06 159.52,176.53 159.42,176.63 JCDRA.18 ; v1(132.61,159.99) 132.5,159.99 132.3,159.8 132.3,159.65 132.61,159.34 UM8.38
CRX_P10: length 47.1
  IN4 w0.097: v1(133.47,160.52) 133.35,160.52 133.19,160.36 133.19,159.97 134.97,158.18 134.97,157.54 135.26,157.25 138.31,157.25 139.38,158.31 143.33,158.31 143.48,158.46 145.46,158.46 145.61,158.31 147.95,158.31 155.78,166.15 157.43,166.15 159.92,168.64 159.92,170.03 160.62,170.73 160.62,172.71 161.24,173.33 161.62,173.33 162.89,174.6 162.89,174.99 162.66,175.22 162.66,175.22 162.51,175.37 162.37,175.37 v1(162.29,175.29)
  BOTTOM w0.099: UM8.40 133.61,159.36 133.42,159.54 133.42,159.93 133.26,160.08 133.26,160.4 133.38,160.52 v1(133.47,160.52) ; JCDRA.24 161.82,176.87 161.83,176.86 161.83,176.77 161.95,176.65 161.95,176.47 162.57,175.85 162.57,175.57 v1(162.29,175.29)
CRX_P11: length 43.1
  IN4 w0.097: v1(164.13,176.19) 164.45,176.51 164.45,176.78 163.66,177.58 158.31,177.58 157.32,176.59 157.32,176.33 151.54,170.55 148.92,170.55 145.58,167.21 145.58,161.93 144.62,160.96 139.34,160.96 138.19,159.82 137.34,159.82 136.91,159.39 v1(136.91,159.35)
  BOTTOM w0.099: JCDRA.30 164.22,176.63 164.28,176.56 164.28,176.31 164.16,176.19 v1(164.13,176.19) ; UM8.45 136.11,159.37 135.9,159.58 135.9,159.7 136,159.8 136.53,159.8 136.91,159.42 v1(136.91,159.35)
CS1: length 3.6
  BOTTOM w0.203: PU100.1 53.06,47.61 52.79,47.89 51.75,47.89 51.46,47.59 v2(51.13,47.59) 51.13,47.61 50.88,47.86 PR106.2
CS2: length 3.5
  BOTTOM w0.107: v2(56.65,47.59) 56.65,48.14 PR105.2
  BOTTOM w0.203: PU100.5 54.66,47.58 54.88,47.79 55.39,47.79 PR105.2
CS_1.2V: length 7.6
  IN3 w0.254: v1(92.85,41.56) 92.91,41.62 94.62,41.62 95.67,40.58 95.67,39.81 96.27,39.21 v1(97.29,39.21)
  BOTTOM w0.203: v1(92.85,41.56) 92.85,41.73 92.67,41.9 PU201.13
  BOTTOM w0.254: v1(97.29,39.21) 97.35,39.28 PR201.2
CSN1: length 50.4
  TOP w0.107: v1(251.47,62.51) 251.47,62.52 v2(252.17,62.52)
  IN3 w0.254: v1(277.85,66.81) 275.85,64.82 275.85,58.39 278.14,56.1 v1(278.14,55.28)
  IN4 w0.254: v1(277.85,66.81) 278.37,66.28 278.37,65.92 276.17,63.72 273.56,63.72 272.45,62.61 251.57,62.61 v1(251.47,62.51)
  BOTTOM w0.254: v1(277.85,66.81) 277.85,67.09 279.69,68.93 PR6057.1 ; v1(251.47,62.51) 251.47,62.52 250.8,63.19 PL6101.3 ; PR6013.2 v1(278.14,55.28)
CSN2: length 66.7
  IN1 w0.254: v1(242.23,63.28) 242.23,63.63 243.6,64.99 274.52,64.99 275.38,64.13 283.63,64.13 285.05,65.55 285.05,69.3 v1(285.44,69.69) 285.48,69.73 285.84,69.73 286.08,69.5 286.08,66.04 280.67,60.64 v1(278.14,60.64)
  BOTTOM w0.254: PR6054.1 285.63,69.5 v1(285.44,69.69) ; PL6200.3 v1(242.23,63.28) ; v1(278.14,60.64) 278.71,60.64 PR6033.2
CSN3: length 61.2
  TOP w0.107: v1(233.66,63.28) v2(233.66,63.93)
  IN1 w0.254: v1(233.66,63.28) 233.66,64.1 235.87,66.31 275.6,66.31 276.42,65.5 278.11,65.5 279.38,66.77 v1(279.6,66.77)
  IN3 w0.254: v1(279.6,66.77) 279.14,66.77 278.58,66.21 278.58,64.76 278.62,64.73 278.62,59.37 v1(278.15,58.9)
  BOTTOM w0.254: PR6020.2 v1(278.15,58.9) ; v1(279.6,66.77) 279.62,66.75 280.17,66.75 PR6058.1 ; PL6201.3 v1(233.66,63.28)
CSN4: length 73.5
  TOP w0.107: v1(224.96,64.26) v2(224.2,64.26)
  IN1 w0.254: v1(224.96,64.26) 225.11,64.11 225.47,64.11 225.86,64.51 225.86,65.44 227.68,67.25 275.69,67.25 276.11,67.67 281.45,67.67 283.37,69.59 v1(283.47,69.59)
  IN3 w0.254: v1(280.17,63.09) 280.17,66.13 283.47,69.44 v1(283.47,69.59)
  BOTTOM w0.254: PR6026.2 v1(280.17,63.09) ; PR6055.1 v1(283.47,69.59) ; PL6300.3 v1(224.96,64.26)
CSN_VDDCI: length 22.6
  TOP w0.254: v1(281.24,51.13) 283.21,51.13 PR6064.1
  IN1 w0.254: v1(281.24,51.13) 280.18,51.13 279.64,51.67 276.63,51.67 275.57,52.72 275.57,57 275.36,57.21 275.36,60.72 v1(274.97,61.11)
  BOTTOM w0.254: PL6400.3 272.58,62.52 272.84,62.26 273.82,62.26 v1(274.97,61.11)
CSON_1: length 41.3
  TOP w0.107: v1(55.95,16.35) 55.44,15.84 v2(55.44,15.72)
  TOP w0.254: PR723.2 57.48,16.81 PC717.2 56.6,16.8 PC721.1 56.41,16.81 v1(55.95,16.35)
  IN3 w0.254: v1(55.95,16.35) 56.02,16.42 58.34,16.42 60.21,18.28 63.14,18.28 65.67,15.75 65.67,15.46 66.56,14.57 78.04,14.57 81.59,18.12 81.59,19.29 81.96,19.67 81.96,21.33 v1(79.51,23.78)
  BOTTOM w0.254: v1(79.51,23.78) 79.51,23.74 79.83,23.43 PR712.3
