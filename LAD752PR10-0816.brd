# Allegro board LAD752PR10-0816.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
FBB_D39: length 21.1
  IN4 w0.089: 244.49,114.65 244.99,114.15 v1(245.22,114.15)
  IN4 w0.119: 244.49,114.65 244.49,116.43 246.77,118.71 247.34,118.71 248.8,120.17 248.96,120.17 249.66,120.88 249.66,130.59 v1(249.87,130.8)
  BOTTOM w0.089: UG16.A4 249.47,131.2 v1(249.87,130.8) ; UG1.E14 245.07,114.15 v1(245.22,114.15)
FBB_D40: length 32.4
  IN4 w0.089: v1(246.42,110.85) 246.84,111.26
  IN4 w0.119: 246.84,111.26 246.84,116.11 248.99,118.27 250.45,118.27 250.81,118.63 250.81,118.64 252.72,120.55 252.73,120.55 255.23,123.06 255.23,123.78 254.52,124.49 254.52,129.46 253.25,130.73 253.25,130.74 253.24,130.74 253.24,133.73 253.25,133.73 253.25,134.73 253.73,135.21 254.28,135.21 v1(254.67,135.6)
  BOTTOM w0.089: UG16.F11 v1(254.67,135.6) ; v1(246.42,110.85) 246.27,110.85 UG1.J12
FBB_D41: length 24.7
  IN4 w0.089: 247.62,116.18 v1(247.62,114.15)
  IN4 w0.119: 247.62,116.18 249.01,117.57 250.51,117.57 251.06,118.13 251.65,118.13 256.18,122.66 256.18,129.13 254.98,130.33 254.61,130.33 254.29,130.64 254.29,131.22 v1(254.67,131.6)
  BOTTOM w0.089: UG1.E11 247.47,114.15 v1(247.62,114.15) ; UG16.B11 255.07,132 v1(254.67,131.6)
FBB_D42: length 29.2
  IN4 w0.089: v1(247.62,113.25) 247.22,113.65
  IN4 w0.119: 247.22,113.65 247.22,116.14 249.03,117.95 250.53,117.95 250.96,118.38 251.23,118.38 255.71,122.86 255.71,124.19 255.31,124.59 255.31,129.34 254.56,130.08 254.26,130.08 253.49,130.85 253.49,133.62 v1(254.67,134.8)
  BOTTOM w0.089: UG1.F11 247.47,113.25 v1(247.62,113.25) ; UG16.E11 v1(254.67,134.8)
FBB_D43: length 26.7
  IN4 w0.089: v1(247.62,111.65) 248.1,112.13
  IN4 w0.119: v1(254.67,130.8) 254.94,130.8 255.52,130.22 255.78,130.22 256.66,129.34 256.66,122.52 251.36,117.23 249.86,117.23 249.11,116.47 248.53,116.47 247.98,115.92 247.98,114.33 248.1,114.2 248.1,112.13
  BOTTOM w0.089: v1(254.67,130.8) 255.07,131.2 UG16.A11 ; UG1.H11 247.47,111.65 v1(247.62,111.65)
FBB_D44: length 23.6
  IN4 w0.089: v1(248.82,114.15) 248.23,114.74 248.23,115.34 248.52,115.63 248.58,115.63 249.09,115.63 249.82,116.36 251,116.36 251.02,116.39
  IN4 w0.119: v1(256.27,130.8) 257.13,129.94 257.13,122.27 254.52,119.65 254.52,119.31 252.58,117.37 252.28,117.37 251.29,116.39 251.02,116.39
  BOTTOM w0.089: v1(256.27,130.8) 256.67,131.2 UG16.A13 ; UG1.E9 248.67,114.15 v1(248.82,114.15)
FBB_D45: length 28.2
  IN4 w0.089: 250.39,115.5 250.38,115.5 249.34,115.5 249.25,115.41 248.97,115.41 248.61,115.41 248.46,115.26 248.46,114.9 248.71,114.65 249.06,114.65 249.18,114.52 249.18,113.01 v1(248.82,112.65)
  IN4 w0.119: v1(256.27,131.6) 256.65,131.22 257.18,131.22 258.44,129.97 258.44,125.05 257.66,124.27 257.66,121.87 256.29,120.5 256.29,120.41 254.48,118.61 254.34,118.61 252.87,117.13 252.87,116.76 252.43,116.33 252.13,116.33 251.3,115.5 250.39,115.5
  BOTTOM w0.089: v1(256.27,131.6) 256.67,132 UG16.B13 ; UG1.G9 248.82,112.6 v1(248.82,112.65)
FBB_D46: length 36.1
  IN4 w0.089: 249.3,111.85 v1(248.82,111.85)
  IN4 w0.119: v1(256.27,134.8) 256.65,134.42 259.44,134.42 261.78,132.08 261.78,124.2 260.63,123.04 260.63,122.03 260.63,122.03 260.63,120.64 257.66,117.68 257.29,117.68 255.79,116.19 255.79,115.35 255.27,114.83 254.81,114.83 254.63,114.65 254.09,114.65 253.73,114.3 253.73,114.08 253.03,113.38 252.13,113.38 251.26,112.5 249.96,112.5 249.3,111.85
  BOTTOM w0.089: v1(256.27,134.8) 256.67,135.2 UG16.F13 ; UG1.H9 248.82,111.8 v1(248.82,111.85)
FBB_D47: length 32.3
  IN4 w0.119: v1(256.27,134) 256.65,133.62 259.57,133.62 260.93,132.26 260.93,124.02 260.15,123.24 260.15,120.84 257.42,118.11 257.25,118.11 257.01,117.86 257.01,117.76 256.82,117.57 256.11,117.57 255.51,116.98 255.51,116.6 255.03,116.11 254.45,116.11 253.5,115.15 253.5,115.03 252.94,114.47 252.94,114.19 252.51,113.76 252.06,113.76 251.78,113.48 251.16,113.48 250.94,113.25 v1(250.02,113.25)
  BOTTOM w0.089: UG1.F8 249.87,113.25 v1(250.02,113.25) ; UG16.E13 256.67,134.4 v1(256.27,134)
FBB_D48: length 36.2
  IN1 w0.119: v1(249.87,144.4) 249.87,144.53 249.3,145.1 246.74,145.1 246.07,144.43 246.07,144.09 246.01,144.03 246.01,138.66 246.13,138.54 246.13,124.87 247.28,123.73 v1(247.91,123.73)
  BOTTOM w0.089: UG16.U4 v1(249.87,144.4) ; UG1.B15 243.87,116.85
  BOTTOM w0.135: 243.87,116.85 243.87,119.34 246.13,121.6 246.13,122.14 247.72,123.73 v1(247.91,123.73)
FBB_D49: length 34.6
  IN1 w0.119: v1(247.91,124.43) 246.56,125.78 246.56,130.12 246.64,130.21 246.64,138.38 246.34,138.69 246.34,138.88 246.26,138.96 246.26,143.92 247.12,144.78 247.89,144.78 v1(248.27,144.4)
  BOTTOM w0.089: UG1.C15 244.17,116.25 ; UG16.U2 v1(248.27,144.4)
  BOTTOM w0.135: v1(247.91,124.43) 248.04,124.43 248.42,124.05 248.42,123.16 244.27,119.01 244.27,117.7 244.17,117.6 244.17,116.25
FBB_D50: length 33.3
  IN1 w0.119: v1(247.91,125.76) 247.6,125.76 247.02,126.33 247.02,129.7 247.09,129.76 247.09,138.3 246.59,138.79 246.59,143.32 247.27,143.99 249.48,143.99 v1(249.87,143.6)
  BOTTOM w0.089: 244.67,118.68 244.62,118.63 UG1.A14 ; UG16.T4 v1(249.87,143.6)
  BOTTOM w0.135: v1(247.91,125.76) 248.04,125.76 248.87,124.94 248.87,122.88 v2(247.83,121.84) 244.67,118.68
FBB_D51: length 32.5
  IN1 w0.119: v1(247.91,126.4) 247.6,126.71 247.6,130.15 247.89,130.45 247.89,138.29 247.76,138.42 247.32,138.42 247.09,138.64 247.09,139.89 246.84,140.14 246.84,142.78 247.26,143.2 UG16.T2 v1(248.27,143.6)
  BOTTOM w0.089: UG16.T2 v1(248.27,143.6) ; UG1.B14 245.07,116.85
  BOTTOM w0.135: 245.07,116.85 245.07,118.16 245.56,118.65 245.56,118.84 249.44,122.72 249.44,125.19 v2(248.83,125.79) 248.23,126.4 v1(247.91,126.4)
FBB_D52: length 29.7
  IN1 w0.119: v1(248.34,120.77) 248.34,121.2 249.99,122.85 249.99,126.45 250.05,126.51 250.05,126.93 250.05,126.93 250.05,130.09 250.26,130.31 250.26,138.17 249.19,139.25 249.19,140.05 248.83,140.4 v1(248.27,140.4)
  BOTTOM w0.089: UG16.M2 v1(248.27,140.4) ; UG1.D12 246.57,115.35
  BOTTOM w0.135: v1(248.34,120.77) 248.34,120.12 248.22,120 248.22,119.27 247.4,118.45 246.88,118.45 246.57,118.14 246.57,115.35
FBB_D53: length 28.5
  IN1 w0.119: v1(250.57,123.41) 250.47,123.5 250.47,127.11 250.47,127.11 250.47,130.09 250.65,130.27 250.65,130.96 251.22,131.53 251.22,137.57 249.44,139.35 249.44,140.18 248.41,141.2 v1(248.27,141.2)
  BOTTOM w0.089: v1(248.27,141.2) UG16.N2 ; UG1.B11 247.47,116.85
  BOTTOM w0.135: 247.47,116.85 247.47,117.57 v2(249.24,119.34) 250.47,120.58 250.47,123.31 v1(250.57,123.41)
FBB_D54: length 28.1
  IN1 w0.119: v1(249.87,139.6) 250.25,139.22 251.15,139.22 251.47,138.91 251.47,131.43 250.9,130.86 250.9,127.29 250.9,127.28 250.9,124.01 v1(250.99,123.92)
  BOTTOM w0.089: UG1.C11 247.77,116.25 ; UG16.M4 v1(249.87,139.6)
  BOTTOM w0.135: 247.77,116.25 247.77,117.46 248.06,117.75 248.54,117.75 250.99,120.21 v2(250.99,121.06) v1(250.99,123.92)
FBB_D55: length 27.3
  IN1 w0.119: v1(249.87,140.4) 250.26,140.01 251.25,140.01 251.85,139.41 251.85,131.29 251.41,130.84 251.41,130.2 251.4,130.2 251.4,127.81 251.41,127.81 251.41,127.41 251.85,126.97 251.85,124.68 v1(251.53,124.37)
  BOTTOM w0.089: UG1.A9 248.84,117.3 ; UG16.N4 v1(249.87,140.4)
  BOTTOM w0.135: 248.84,117.3 251.51,119.97 v2(251.51,123.29) 251.51,124.34 v1(251.53,124.37)
FBB_D56: length 31.2
  IN1 w0.089: 250.42,116.35 v1(250.02,115.95)
  IN1 w0.119: v1(256.27,141.2) 255.85,140.78 253.72,140.78 253.71,140.77 253.69,140.77 253.32,140.4 253.32,129.06 254.08,128.3 254.08,124.57 250.35,120.84 250.35,117.74 250.42,117.67 250.42,116.35
  BOTTOM w0.089: v1(250.02,115.95) 249.87,115.95 UG1.C8 ; v1(256.27,141.2) 256.67,140.8 UG16.N13
FBB_D57: length 28.9
  IN1 w0.089: 250.82,115.85 v1(250.02,115.05)
  IN1 w0.119: 250.82,115.85 250.82,120.64 254.56,124.38 254.56,128.49 254.26,128.79 254.26,139.99 v1(254.67,140.4)
  BOTTOM w0.089: v1(254.67,140.4) 255.07,140.8 UG16.N11 ; UG1.D8 249.87,115.05 v1(250.02,115.05)
FBB_D58: length 28.5
  IN1 w0.089: v1(251.22,115.95) 251.96,116.69
  IN1 w0.119: 251.96,116.69 251.96,119.55 256.54,124.13 256.54,129.83 255.85,130.53 255.85,139.87 256.27,140.3 v1(256.27,140.4)
  BOTTOM w0.089: UG1.C6 251.07,115.95 v1(251.22,115.95) ; UG16.M13 256.67,140 v1(256.27,140.4)
FBB_D59: length 25.9
  IN1 w0.089: v1(251.22,116.85) 251.61,117.24
  IN1 w0.119: 251.61,117.24 251.61,117.91 251.53,117.99 251.53,120.68 255.09,124.24 255.09,139.18 v1(254.67,139.6)
  BOTTOM w0.089: v1(254.67,139.6) 255.07,140 UG16.M11 ; v1(251.22,116.85) 251.07,116.85 UG1.B6
FBB_D60: length 34.5
  IN1 w0.089: v1(252.42,115.1) 252.49,115.1 253.06,115.67
  IN1 w0.119: v1(256.27,143.6) 256.27,143.32 256.39,143.2 257.35,143.2 258.13,142.42 258.13,139.19 258.88,138.44 258.88,123.14 255.27,119.53 254.77,119.53 253.52,118.29 253.52,117.34 253.06,116.87 253.06,115.67
  BOTTOM w0.089: UG16.T13 256.67,143.2 v1(256.27,143.6) ; UG1.D5 252.32,115.1 v1(252.42,115.1)
FBB_D61: length 38
  IN1 w0.089: 254.62,116.87 v1(253.65,115.9)
  IN1 w0.119: v1(254.67,144.4) 255.3,145.03 257.33,145.03 260.55,141.82 260.55,123 257.23,119.68 256.87,119.68 255.32,118.13 254.96,118.13 254.62,117.78 254.62,116.87
  BOTTOM w0.089: UG1.C4 253.42,115.9 253.44,115.9 253.45,115.91 253.64,115.91 v1(253.65,115.9) ; UG16.U11 255.07,144 v1(254.67,144.4)
FBB_D62: length 35.1
  IN1 w0.119: v1(254.67,143.6) 255.06,143.99 257.21,143.99 257.61,143.59 257.61,143.29 258.39,142.52 258.39,139.55 259.53,138.4 259.53,123.18 255.32,118.97 254.7,118.97 253.82,118.08 253.82,116.76 v1(253.78,116.72)
  BOTTOM w0.089: UG16.T11 255.07,143.2 v1(254.67,143.6) ; UG1.B4 253.34,116.72 253.77,116.72 v1(253.78,116.72)
FBB_D63: length 33.6
  IN1 w0.119: v1(256.27,144.4) 256.65,144.78 257.23,144.78 257.87,144.14 257.87,143.49 258.69,142.67 258.69,140.03 259.94,138.78 260,138.78 260.12,138.65 260.12,123.17 257.19,120.24 257.06,120.24 255.3,118.48 254.75,118.48 v1(254.22,117.95)
  BOTTOM w0.089: v1(256.27,144.4) 256.67,144 UG16.U13 ; v1(254.22,117.95) 254.17,117.95 UG1.A3
FBB_DBI0#: length 22.8
  IN3 w0.089: 234.79,112.82 v1(234.42,112.45)
  IN3 w0.112: 234.79,112.82 234.79,125.47 235.15,125.82 235.15,130.15 234.65,130.65 234.65,132.68 234.27,133.05 v1(234.27,133.2)
  BOTTOM w0.089: v1(234.42,112.45) 234.57,112.45 UG1.G24 ; UG15.P13 233.87,133.6 v1(234.27,133.2)
FBB_DBI1#: length 25.5
  IN3 w0.089: 239.97,112.1 v1(240.42,111.65)
  IN3 w0.112: 241.56,119.48 241.77,119.69 241.77,125.37 243.45,127.05 243.45,129.85
  IN3 w0.119: 241.56,119.48 240.99,118.9 240.99,117.7 239.82,116.53 239.82,114.65 239.97,114.5 239.97,112.1 ; v1(242.27,133.2) 242.34,133.2 242.74,132.8 243.23,132.8 243.45,132.58 243.45,129.85
  BOTTOM w0.089: v1(240.42,111.65) 240.27,111.65 UG1.H19 ; v1(242.27,133.2) 242.67,133.6 UG15.P2
FBB_DBI2#: length 28.8
  IN1 w0.119: v1(242.27,142) 242.41,142 242.66,141.74 242.66,130.36 242.5,130.19 242.5,124.96 242.19,124.65 242.19,124.23 241.31,123.34 v1(241.31,122.08)
  BOTTOM w0.089: v1(242.27,142) 242.67,141.6 UG15.D2 ; UG1.C19 240.57,116.25
  BOTTOM w0.135: v1(241.31,122.08) 241.18,122.08 240.74,121.64 240.74,120.5 241.06,120.19 241.06,117.99 240.57,117.5 240.57,116.25
FBB_DBI3#: length 33.7
  IN1 w0.089: 234.77,120.87 v1(234.13,120.87)
  IN1 w0.119: 234.77,120.87 235.02,121.13 237.18,121.13 238.19,122.14 238.19,129.89 237.5,130.59 237.5,140.18 236.42,141.26 236.42,141.57 235.59,142.4 234.64,142.4 234.27,142.03 v1(234.27,142)
  BOTTOM w0.089: UG1.C24 234.57,115.95 ; UG15.D13 v1(234.27,142)
  BOTTOM w0.135: 234.57,115.95 234.57,120.44 v1(234.13,120.87)
FBB_DBI4#: length 26.9
  IN4 w0.089: 243.62,111.65 v1(242.82,110.85) ; v1(248.27,133.2) 247.88,132.81 247.28,132.81 247.09,132.62 247.09,130.46 247.49,130.06
  IN4 w0.119: 243.62,111.65 243.62,113.75 243.3,114.07 243.3,116.89 246.52,120.11 246.52,120.71 247.49,121.68 247.49,130.06
  BOTTOM w0.089: v1(248.27,133.2) 247.87,133.6 UG16.D2 ; v1(242.82,110.85) 242.67,110.85 UG1.J17
FBB_DBI5#: length 33.7
  IN4 w0.089: 248.29,111.52 v1(247.62,110.85)
  IN4 w0.119: v1(256.27,133.2) 256.69,132.78 258.18,132.78 260.25,130.71 260.25,124.3 259.47,123.52 259.47,121.12 256.24,117.89 255.79,117.89 255.64,117.74 255.64,117.72 255.29,117.37 255.06,117.37 254.56,116.87 254.56,116.68 254.18,116.3 253.44,116.3 253.25,116.11 253.25,115.22 252.7,114.67 252.36,114.67 251.46,113.77 249.89,113.77 249.5,113.38 249.5,112.68 249.06,112.24 248.61,112.24 248.29,111.92 248.29,111.52
  BOTTOM w0.089: v1(247.62,110.85) 247.47,110.85 UG1.J11 ; v1(256.27,133.2) 256.67,133.6 UG16.D13
FBB_DBI6#: length 30.1
  IN1 w0.089: v1(247.47,119.9) 247.47,120.36
  IN1 w0.119: v1(248.27,142) UG16.P2 247.87,140.22 248.1,139.99 248.48,139.99 248.93,139.54 248.93,139.2 248.69,138.96 248.69,138.64 248.92,138.42 249.18,138.42 249.45,138.16 249.45,130.64 249.44,130.63 249.44,130.26 249.37,130.2 249.37,126.79 249.31,126.73 249.31,123.24 247.47,121.39 247.47,120.36
  BOTTOM w0.089: UG16.P2 v1(248.27,142) ; UG1.C12 246.27,115.95
  BOTTOM w0.135: 246.27,115.95 246.27,118.28 246.89,118.9 247.17,118.9 247.47,119.2 v1(247.47,119.9)
FBB_DBI7#: length 28.3
  IN1 w0.089: v1(252.42,117.75) 252.42,119.03
  IN1 w0.119: v1(256.27,142) 256.69,141.58 256.69,138.44 257.63,137.51 257.63,130.38 257.22,129.97 257.22,123.83 252.42,119.03
  BOTTOM w0.089: v1(252.42,117.75) 252.27,117.75 UG1.A5 ; v1(256.27,142) 256.67,141.6 UG16.P13
FBB_EDC0: length 22.3
  IN3 w0.089: v1(234.42,113.25) 233.6,114.07
  IN3 w0.112: 232.68,121.22 232.68,126.18 234.32,127.83 234.32,129.89 233.88,130.33
  IN3 w0.119: 233.6,114.07 233.6,115.21 232.68,116.13 232.68,121.22 ; v1(234.27,132.4) 233.88,132.01 233.88,130.33
  BOTTOM w0.089: v1(234.27,132.4) 233.87,132.8 UG15.R13 ; v1(234.42,113.25) 234.57,113.25 UG1.F24
FBB_EDC1: length 24.8
  IN3 w0.089: v1(240.42,110.85) 239.62,111.65
  IN3 w0.112: 242.66,130.23 242.63,130.19 242.63,127.39 240.95,125.71 240.95,122.61 240.8,122.46 240.8,121.23
  IN3 w0.119: 240.8,121.23 240.8,120.18 240.42,119.8 240.42,117.51 239.47,116.56 239.47,114.55 239.62,114.4 239.62,111.65 ; v1(242.27,132.4) 242.66,132.01 242.66,130.23
  BOTTOM w0.089: v1(242.27,132.4) 242.67,132.8 UG15.R2 ; UG1.J19 240.27,110.85 v1(240.42,110.85)
FBB_EDC2: length 28.4
  IN1 w0.089: 241.73,121.23 241.38,120.87 v1(241.37,120.87)
  IN1 w0.119: 241.73,121.23 242.14,121.63 242.14,123 243.02,123.88 243.02,124.3 243.33,124.61 243.33,130.19 243.34,130.2 243.34,130.53 243.72,130.91 243.72,137.28 243.53,137.47 243.53,142.27 243.4,142.4 UG15.C2 v1(242.27,142.8)
  BOTTOM w0.089: v1(242.27,142.8) 242.67,142.4 UG15.C2 ; UG1.A18 241.63,117.91
  BOTTOM w0.135: 241.63,117.91 241.63,120.62 v1(241.37,120.87)
FBB_EDC3: length 37
  IN1 w0.089: v1(234.07,120.11) 234.64,119.54
  IN1 w0.119: v1(234.27,142.8) 234.28,142.8 234.64,143.16 234.9,143.16 234.92,143.18 235.23,143.18 235.25,143.16 235.4,143.16 236.86,141.7 236.86,141.32 238.07,140.11 238.07,131.1 239.02,130.14 239.02,121.79 238.54,121.31 237.56,120.33 237.56,119.83 237.34,119.61 236.84,119.61 236.77,119.54 234.64,119.54
  BOTTOM w0.089: UG15.C13 v1(234.27,142.8) ; UG1.D24 234.27,115.35
  BOTTOM w0.135: v1(234.07,120.11) 234.27,119.91 234.27,115.35
FBB_EDC4: length 22
  IN4 w0.089: v1(244.02,114.15) 243.74,114.43
  IN4 w0.119: 243.74,114.43 243.74,116.76 248.4,121.42 248.4,129.83 247.86,130.37 247.86,131.99 v1(248.27,132.4)
  BOTTOM w0.089: UG1.E15 243.87,114.15 v1(244.02,114.15) ; UG16.C2 247.87,132.8 v1(248.27,132.4)
FBB_EDC5: length 27.7
  IN4 w0.089: v1(248.82,115.05) 249.35,115.05 249.88,114.53
  IN4 w0.119: 249.88,114.53 251.31,114.53 252.26,115.48 252.48,115.48 252.93,115.92 252.93,116.36 253.18,116.62 253.18,116.94 253.46,117.21 254.01,117.21 254.93,118.13 255.2,118.13 258.57,121.5 258.57,123.9 259.35,124.68 259.35,130.33 257.7,131.98 256.69,131.98 v1(256.27,132.4)
  BOTTOM w0.089: UG1.D9 248.67,115.05 v1(248.82,115.05) ; v1(256.27,132.4) 256.67,132.8 UG16.C13
FBB_EDC6: length 29.3
  IN1 w0.089: v1(246.97,119.4) 246.56,119.81 246.56,121.23
  IN1 w0.119: 246.56,121.23 246.56,121.66 248.48,123.58 248.48,130.2 248.65,130.37 248.65,138.16 248.38,138.42 248.12,138.42 247.89,138.64 247.89,139.71 247.58,140.02 247.32,140.02 247.09,140.24 247.09,142.16 247.32,142.38 247.85,142.38 v1(248.27,142.8)
  BOTTOM w0.089: UG16.R2 v1(248.27,142.8) ; UG1.A12 245.82,118.25
  BOTTOM w0.135: 245.82,118.25 v1(246.97,119.4)
FBB_EDC7: length 31
  IN1 w0.089: 252.92,117.35 v1(252.42,116.85)
  IN1 w0.119: v1(256.27,142.8) 256.27,142.55 256.41,142.41 257.55,142.41 257.88,142.08 257.88,139.08 258.05,138.92 258.05,123.48 252.92,118.35 252.92,117.35
  BOTTOM w0.089: UG16.R13 256.67,142.4 v1(256.27,142.8) ; v1(252.42,116.85) 252.27,116.85 UG1.B5
FBB_MA0_H: length 42.4
  IN3 w0.089: 242.32,108.35 241.63,107.66 v1(241.63,107.66)
  IN3 w0.112: 242.32,108.35 242.32,115.71 245.63,119.01 247.18,119.01 251.55,123.38 v1(254.82,123.38)
  BOTTOM w0.089: v1(241.63,107.66) 241.62,107.65 UG1.N18
  BOTTOM w0.13: UG16.K4 249.87,138 250.59,138 251.64,136.96 251.64,131.91
  BOTTOM w0.135: 251.64,131.91 251.73,131.81 251.73,126.74 254.82,123.65 v1(254.82,123.38)
FBB_MA0_L: length 31
  IN3 w0.089: 236.07,112.1 v1(235.62,111.65)
  IN3 w0.112: 236.07,112.1 236.07,116.45 235.63,116.89 235.63,118.14 235.53,118.24 235.53,124.68 236.57,125.72 236.57,131.05 238.07,132.56 238.07,136.2 v1(240.67,138.8)
  BOTTOM w0.089: UG1.H23 235.77,111.65 v1(235.62,111.65) ; UG15.H4 v1(240.67,138.8)
FBB_MA1_H: length 39.7
  IN3 w0.089: 245.78,118.67 243.19,116.08 243.19,110.42 v1(242.82,110.05)
  IN3 w0.112: v1(253.97,122.38) 253.95,122.4 251.74,122.4 249.03,119.69 248.4,119.69 247.38,118.67 245.78,118.67
  BOTTOM w0.089: UG1.K17 242.67,110.05 v1(242.82,110.05)
  BOTTOM w0.13: 252.25,129.92 252.25,136.88 250.73,138.4 UG16.K5
  BOTTOM w0.135: 252.25,129.92 252.25,126.95 255.33,123.86 255.33,123.02 254.69,122.38 v1(253.97,122.38)
FBB_MA1_L: length 34.8
  TOP w0.089: v1(234.42,107.65) 235.15,108.38
  TOP w0.135: v1(239.87,138.8) 239.87,138.75 238.51,137.39 v2(238.51,132.18) 238.51,130.78 236.04,128.3 236.04,126.4 235.85,126.21 235.85,121.44 235.15,120.75 235.15,114.04 235.2,113.99 235.2,108.89 235.15,108.83 235.15,108.38
  BOTTOM w0.089: v1(234.42,107.65) 234.57,107.65 UG1.N24 ; UG15.H5 v1(239.87,138.8)
FBB_MA2_H: length 43.2
  IN3 w0.089: v1(242.75,107.65) 242.82,107.65 243.64,108.47 243.64,115.49 244.97,116.83
  IN3 w0.112: 244.97,116.83 246.4,116.83 248.43,118.86 249.67,118.86 251.69,120.88 v1(252.47,120.88)
  BOTTOM w0.089: UG1.N17 242.67,107.65 v1(242.75,107.65)
  BOTTOM w0.13: UG16.K11 254.65,137.98 253.76,137.98 253.29,137.5 253.29,130.04
  BOTTOM w0.135: 253.29,130.04 253.29,127.41 255.37,125.33 256.37,124.33 256.37,122.38 254.75,120.75 252.59,120.75 v1(252.47,120.88)
FBB_MA2_L: length 32.8
  TOP w0.089: v1(234.42,110.05) 233.94,110.53
  TOP w0.135: 233.94,110.53 v2(233.94,116.94) 233.94,117.19 234.53,117.78 234.53,119.11 233.5,120.14 233.5,120.92 233.62,121.04 233.62,126.26 235.01,127.66 235.01,128.52 236,129.51 236,130.39 237.33,131.71 237.33,136.55 237.07,136.8 236.27,136.8 v1(235.87,137.2)
  BOTTOM w0.089: v1(234.42,110.05) 234.57,110.05 UG1.K24 ; v1(235.87,137.2) 235.87,138 UG15.H11
FBB_MA3_H: length 41.8
  IN3 w0.089: v1(242.82,108.45) 243.41,109.04 243.41,115.81 244.97,117.37
  IN3 w0.112: v1(253.47,121.88) 251.96,121.88 249.39,119.31 248.46,119.31 247.54,118.39 246.53,118.39 245.51,117.37 244.97,117.37
  BOTTOM w0.089: UG1.M17 242.67,108.45 v1(242.82,108.45)
  BOTTOM w0.13: UG16.K10 253.63,138.4 252.77,137.54 252.77,129.92
  BOTTOM w0.135: v1(253.47,121.88) 253.59,121.75 255.01,121.75 255.85,122.59 v2(255.85,123.67) 255.85,124.11 252.77,127.2 252.77,129.92
FBB_MA3_L: length 32.8
  TOP w0.089: 234.9,108.93 v1(234.42,108.45)
  TOP w0.135: 234.9,108.93 234.9,113.76 234.8,113.86 234.8,121.6 v2(235.02,121.83) 235.4,122.21 235.4,126.38 235.6,126.58 235.6,128.48 237.75,130.64 237.75,136.92 v1(236.67,138)
  BOTTOM w0.089: UG15.H10 v1(236.67,138) ; UG1.M24 234.57,108.45 v1(234.42,108.45)
FBB_MA4_H: length 36.8
  IN3 w0.089: v1(244.02,109.25) 244.61,109.84 244.61,115.15 245.01,115.55
  IN3 w0.112: v1(254.67,136.4) 254.27,136 254.27,134.67 253.5,133.9 253.5,127.26 255.76,125 255.76,122.88 252.44,119.56 251.19,119.56 249.67,118.04 248.4,118.04 245.91,115.55 245.01,115.55
  BOTTOM w0.089: UG1.L15 243.87,109.25 v1(244.02,109.25) ; v1(254.67,136.4) 255.07,136.8 UG16.H11
FBB_MA4_L: length 32.7
  TOP w0.089: v1(233.22,109.25) 232.42,110.05
  TOP w0.135: 232.42,110.05 232.42,115.73 232.17,115.98 232.17,135.8 v2(232.58,136.21) 233.24,136.87 234.85,136.87 234.94,136.79 235.49,136.79 v1(235.87,136.4)
  BOTTOM w0.089: v1(235.87,136.4) 235.47,136.8 UG15.K11 ; UG1.L25 233.37,109.25 v1(233.22,109.25)
FBB_MA5_H: length 34.8
  IN3 w0.089: v1(244.02,110.85) 244.39,111.22 244.39,115.71 245.08,116.4
  IN3 w0.112: v1(253.87,136.4) 253.08,135.61 253.08,126.94 255.24,124.78 255.24,123.03 252.09,119.88 251.13,119.88 249.73,118.48 248.46,118.48 246.38,116.4 245.08,116.4
  BOTTOM w0.089: UG1.J15 243.87,110.85 v1(244.02,110.85) ; UG16.H10 v1(253.87,136.4)
FBB_MA5_L: length 32.5
  TOP w0.089: 233.63,108.86 v1(233.22,108.45)
  TOP w0.135: 233.63,108.86 233.63,115.5 233.05,116.08 233.05,118.64 233.18,118.77 233.55,118.77 233.69,118.9 233.69,119.17 233.55,119.31 233.18,119.31 233.05,119.44 v2(233.05,121.76) 233.05,126.77 234.57,128.3 234.57,128.7 234.69,128.81 234.69,129.77 235.47,130.55 235.47,135.74 235.71,135.99 236.26,135.99 v1(236.67,136.4)
  BOTTOM w0.089: v1(233.22,108.45) 233.37,108.45 UG1.M25 ; v1(236.67,136.4) 236.27,136.8 UG15.K10
FBB_MA6_H: length 38.7
  IN3 w0.089: 240.93,106.97 240.81,106.85 v1(240.42,106.85)
  IN3 w0.112: v1(249.87,136.4) 249.87,135.85 248.67,134.65 248.67,130.68 247.95,129.95 247.95,129.77 248.51,129.2 248.51,129.01 248.38,128.88 248.2,128.88 247.63,129.45 247.45,129.45 247.32,129.32 247.32,129.13 247.88,128.57 247.88,128.38 247.75,128.25 247.57,128.25 247,128.82 246.82,128.82 242.44,124.44 242.44,118.26 240.93,116.75 240.93,106.97
  BOTTOM w0.089: UG1.P19 240.27,106.85 v1(240.42,106.85) ; UG16.H5 v1(249.87,136.4)
FBB_MA6_L: length 32.2
  IN3 w0.089: 236.1,108.13 v1(235.62,107.65)
  IN3 w0.112: v1(240.67,136.4) 240.67,136.15 240.26,135.73 240.26,129.49 238.02,127.25 238.02,118.98 237.32,118.28 237.32,117.25 237.12,117.04 237.12,110.2 236.1,109.18 236.1,108.13
  BOTTOM w0.089: UG1.N23 235.77,107.65 v1(235.62,107.65) ; v1(240.67,136.4) 240.27,136.8 UG15.K5
FBB_MA7_H: length 35.8
  IN3 w0.089: v1(241.62,110.05) 241.29,110.05 241.18,110.16
  IN3 w0.112: v1(249.87,137.2) 250.27,136.8 250.27,135.8 249.5,135.03 249.5,129.41 247.66,127.57 247.47,127.57 246.94,128.1 246.76,128.1 246.63,127.97 246.63,127.78 247.16,127.25 247.16,127.07 247.03,126.94 246.84,126.94 246.31,127.47 246.13,127.47 242.97,124.31 242.97,117.96 241.18,116.17 241.18,110.16
  BOTTOM w0.089: UG16.H4 v1(249.87,137.2) ; v1(241.62,110.05) 241.47,110.05 UG1.K18
FBB_MA7_L: length 34.9
  IN3 w0.089: v1(235.62,109.25) 236.77,110.4
  IN3 w0.112: v1(240.67,137.2) 239.39,135.91 239.39,129.21 239.16,128.98 238.97,128.98 238.41,129.54 238.23,129.54 238.1,129.41 238.1,129.22 238.66,128.66 238.66,128.48 238.53,128.35 238.34,128.35 237.82,128.87 237.63,128.87 237.5,128.74 237.5,128.55 238.02,128.03 238.02,127.85 237.6,127.43 237.6,119.22 236.77,118.39 236.77,110.4
  BOTTOM w0.089: v1(235.62,109.25) 235.77,109.25 UG1.L23 ; UG15.K4 v1(240.67,137.2)
FBB_MA8_H: length 36.1
  IN3 w0.089: v1(241.62,109.25) 242.07,109.7
  IN3 w0.112: v1(250.67,137.2) 251.1,136.78 251.1,130.42 246.93,126.25 246.75,126.25 246.27,126.73 246.09,126.73 245.96,126.6 245.96,126.41 246.43,125.94 246.43,125.75 246.3,125.62 246.12,125.62 245.64,126.1 245.45,126.1 243.81,124.45 243.81,117.69 242.07,115.95 242.07,109.7
  BOTTOM w0.089: UG16.J5 v1(250.67,137.2) ; UG1.L18 241.47,109.25 v1(241.62,109.25)
FBB_MA8_L: length 30.8
  IN3 w0.089: 236.42,110.85 v1(235.62,110.05)
  IN3 w0.112: 236.42,110.85 236.42,116.9 235.97,117.35 235.97,124.37 237.08,125.47 237.08,130.94 239.02,132.87 239.02,136.68 239.54,137.2 v1(239.87,137.2)
  BOTTOM w0.089: v1(235.62,110.05) 235.77,110.05 UG1.K23 ; UG15.J5 v1(239.87,137.2)
FBB_RAS#_H: length 39.3
  TOP w0.089: 239.66,108.89 v1(239.22,108.45)
  TOP w0.135: v1(248.27,138.8) 247.82,138.35 245.83,138.35 245.5,138.02 245.5,131.13 242.86,128.49 241.75,128.49 239.59,126.33 239.59,122.4 239.73,122.27 240.35,122.27 240.48,122.13 240.48,121.86 240.35,121.73 239.73,121.73 239.59,121.59 239.59,119.19 v2(239.83,118.95) 240.29,118.49 240.29,117.76 239.66,117.13 239.66,108.89
  BOTTOM w0.089: v1(239.22,108.45) 239.07,108.45 UG1.M20 ; UG16.L3 v1(248.27,138.8)
FBB_RAS#_L: length 34.7
  TOP w0.089: 238.83,110.44 v1(239.22,110.05)
  TOP w0.135: 238.83,110.44 238.83,114.4 239.15,114.72 239.15,126.51 241.58,128.94 242.38,128.94 244.67,131.24 244.67,137.42 243.68,138.41 242.66,138.41 v1(242.27,138.8)
  BOTTOM w0.089: UG1.K20 239.07,110.05 v1(239.22,110.05) ; UG15.G3 v1(242.27,138.8)
FBB_WCK0: length 25.8
  IN4 w0.089: 237.45,112.11 237.69,112.11 238.02,112.44 v1(238.02,112.45)
  IN4 w0.119: v1(240.67,133.26) 240.37,133.55 239.42,133.55 238.76,132.9 238.76,121.23 238.76,121.22 238.76,120.5 237.33,119.07 237.33,112.24 237.45,112.11
  BOTTOM w0.089: v1(238.02,112.45) 237.87,112.45 UG1.G21 ; UG15.P4 241.02,133.6 v1(240.67,133.26)
FBB_WCK0_N: length 26.4
  IN4 w0.089: 237.37,111.9 237.77,111.9 v1(238.02,111.65)
  IN4 w0.119: v1(240.64,134.03) 240.38,133.76 239.33,133.76 238.55,132.99 238.55,129.85 238.55,129.85 238.55,120.59 237.12,119.16 237.12,112.15 237.37,111.9
  BOTTOM w0.089: UG1.H21 237.87,111.65 v1(238.02,111.65) ; v1(240.64,134.03) 240.27,133.66 UG15.P5
FBB_WCK1: length 29.6
  IN4 w0.119: v1(240.67,141.2) 240.43,141.44 240.08,141.44 239.87,141.24 238.6,141.24 238.22,140.85 238.22,133.65 237.76,133.2 237.76,121.34 237.89,121.21 237.89,120.9 237.89,120.9 237.89,120.48 237.67,120.26 237.46,120.26 v1(237.18,119.98)
  BOTTOM w0.089: UG1.A21 237.42,117.07 237.55,116.94 237.75,116.94 237.94,117.13 237.94,118.59 237.82,118.72 237.82,120.15 237.73,120.24 237.44,120.24 v1(237.18,119.98) ; UG15.D4 241.07,141.6 v1(240.67,141.2)
FBB_WCK1_N: length 30.3
  IN4 w0.119: v1(240.67,142) 240.67,141.89 240.43,141.65 239.99,141.65 239.78,141.45 238.51,141.45 238.01,140.94 238.01,133.74 237.55,133.29 237.55,129.93 237.55,129.93 237.55,121.25 237.68,121.12 237.68,120.9 237.68,120.9 237.68,120.56 237.59,120.47 237.46,120.47 237.31,120.62 v1(237.18,120.62)
  BOTTOM w0.089: UG1.B21 237.42,116.63 237.55,116.76 237.83,116.76 238.12,117.06 238.12,118.66 237.99,118.79 237.99,120.22 237.8,120.42 237.38,120.42 v1(237.18,120.62) ; UG15.D5 240.27,141.6 v1(240.67,142)
FBB_WCK2: length 28.9
  IN4 w0.089: v1(246.42,113.25) 246.42,113.04 246.33,112.95 246.1,112.95 246.01,113.04 246.01,114.27 246.3,114.56 246.3,115.83 246.3,116.09 249.19,118.98 250.15,118.98 251.45,120.28 251.45,120.34 251.47,120.35 251.47,120.36
  IN4 w0.119: 251.47,120.36 251.47,122.35 252.99,123.88 252.99,129.92 252.99,129.92 252.99,130.15 252.69,130.44 252.69,133.09 252.05,133.73 250.36,133.73 250.19,133.73 v1(249.87,134.04)
  BOTTOM w0.089: UG1.F12 246.27,113.25 v1(246.42,113.25) ; v1(249.87,134.04) 249.47,133.64 UG16.D4
FBB_WCK2_N: length 28.8
  IN4 w0.089: 251.26,120.36 251.26,120.34 250.07,119.16 249.12,119.16 246.13,116.16 246.13,114.64 245.83,114.34 245.83,112.96 246.02,112.77 246.32,112.77 246.33,112.76 246.42,112.67 v1(246.42,112.45)
  IN4 w0.119: v1(249.88,133.22) 250.18,133.52 250.19,133.52 250.36,133.53 251.96,133.53 252.48,133 252.48,130.36 252.78,130.06 252.78,123.96 251.26,122.44 251.26,120.36
  BOTTOM w0.089: UG1.G12 246.27,112.45 v1(246.42,112.45) ; v1(249.88,133.22) 250.27,133.6 UG16.D5
FBB_WCK3: length 30.3
  IN1 w0.089: v1(249.87,142) 250.11,141.76 250.83,141.76 252.49,140.1 252.49,132.27 252.49,132.12 252.35,131.97 252.35,129.95 252.31,129.92 ; 249.6,117.27 v1(250.02,116.85)
  IN1 w0.119: 249.6,117.27 249.6,120.36 249.6,120.36 249.6,121.05 253.39,124.84 253.39,127.08 252.29,128.18 252.29,129.9 252.31,129.92
  BOTTOM w0.089: UG16.P4 v1(249.87,142) ; v1(250.02,116.85) 249.87,116.85 UG1.A8
FBB_WCK3_N: length 30.5
  IN1 w0.089: v1(249.87,141.2) 249.87,141.43 250.02,141.59 250.76,141.59 252.31,140.03 252.31,132.19 252.17,132.05 252.17,130.07 252.08,129.99 252.08,129.92 ; 249.39,117.08 249.16,116.85 v1(248.82,116.85)
  IN1 w0.119: 252.08,129.92 252.08,128.09 253.18,126.99 253.18,124.93 249.39,121.14 249.39,117.08
  BOTTOM w0.089: UG1.B9 248.67,116.85 v1(248.82,116.85) ; UG16.P5 v1(249.87,141.2)
FBB_WE#_H: length 37.8
  IN3 w0.089: v1(244.02,108.45) 244.84,109.27 244.84,114.42 245.06,114.64
  IN3 w0.112: 245.06,114.64 245.32,114.64 245.41,114.73 245.6,114.73 248.59,117.72 249.8,117.72 251.26,119.18 252.72,119.18 256.23,122.69 256.23,125.26 254.27,127.22 254.27,132.75 255.07,133.55 255.07,134.45 255.27,134.65 255.27,135.4 v1(256.27,136.4)
  BOTTOM w0.089: v1(256.27,136.4) 255.87,136 UG16.G12 ; v1(244.02,108.45) 243.87,108.45 UG1.M15
FBB_WE#_L: length 33.6
  TOP w0.089: v1(233.22,110.85) 232.8,111.27
  TOP w0.135: v1(234.27,136.4) 233.86,135.99 233.24,135.99 232.61,135.35 232.61,135.09 232.74,134.95 232.92,134.95 233.05,134.82 233.05,134.55 232.92,134.42 232.74,134.42 232.61,134.28 232.61,133.8 232.74,133.66 232.79,133.66 232.93,133.53 232.93,133.26 232.79,133.12 232.74,133.12 232.61,132.99 v2(232.61,132.24) 232.61,129.6 232.74,129.47 234,129.47 234.13,129.33 234.13,129.06 234,128.93 232.74,128.93 232.61,128.79 232.61,128.52 232.74,128.39 233.5,128.39 233.64,128.25 233.64,127.98 233.5,127.85 232.74,127.85 232.61,127.72 232.61,116.17 232.8,115.98 232.8,111.27
  BOTTOM w0.089: UG15.L12 v1(234.27,136.4) ; UG1.J25 233.37,110.85 v1(233.22,110.85)
FBC_ABI#_H: length 36
  TOP w0.089: v1(247.47,99.8) 247.88,99.38
  TOP w0.135: v1(274.92,109.81) 274.51,110.23 263.72,110.23 262.7,109.21 262.51,109.21 262.35,109.37 262.16,109.37 261.97,109.18 261.97,108.99 262.13,108.83 262.13,108.64 261.94,108.45 261.75,108.45 261.59,108.6 261.4,108.6 261.21,108.41 261.21,108.22 261.36,108.06 261.36,107.87 261.18,107.69 260.99,107.69 260.88,107.8 260.69,107.8 260.5,107.61 260.5,107.42 260.61,107.31 260.61,107.12 257.63,104.14 256.48,104.14 254.62,102.29 254.62,101.4 252.61,99.38 247.88,99.38
  BOTTOM w0.089: UG1.AA11 247.47,99.65 v1(247.47,99.8) ; UG18.J4 v1(274.92,109.81)
FBC_ABI#_L: length 44.8
  TOP w0.089: v1(247.47,102.2) 247.47,102.46 247.69,102.68
  TOP w0.135: v1(274.92,117.41) 274.51,117 274.51,116.41 274.31,116.21 273.18,116.21 272.91,115.94 272.91,115.65 v2(272.1,114.85) 270.12,112.87 269.72,112.87 269.59,113.01 269.59,113.94 269.45,114.08 269.19,114.08 269.05,113.94 269.05,113.01 268.92,112.87 268.65,112.87 268.51,113.01 268.51,113.75 268.38,113.89 268.11,113.89 267.97,113.75 267.97,113.01 267.84,112.87 267.57,112.87 267.44,113.01 267.44,113.69 267.3,113.82 267.03,113.82 266.9,113.69 266.9,113.01 266.76,112.87 266.49,112.87 266.36,113.01 266.36,113.69 266.22,113.82 265.95,113.82 265.82,113.69 265.82,113.01 265.69,112.87 265.42,112.87 265.28,113.01 265.28,113.69 265.15,113.82 264.88,113.82 264.74,113.69 264.74,113.01 264.61,112.87 262.58,112.87 260.98,111.27 260.76,111.27 258.29,108.79 258.29,108.58 256.49,106.78 255.12,106.78 251.91,103.57 251.91,102.97 251.63,102.68 247.69,102.68
  BOTTOM w0.089: v1(274.92,117.41) 275.32,117.81 UG17.J4 ; v1(247.47,102.2) 247.47,102.05 UG1.W11
FBC_CAS#_H: length 38.1
  TOP w0.089: 248.65,100.18 v1(248.27,99.8)
  TOP w0.135: 248.65,100.18 253.03,100.18 253.38,100.53 253.38,100.73 252.69,101.41 252.69,101.6 252.98,101.89 253.17,101.89 253.86,101.2 254.05,101.2 254.24,101.4 254.24,102.28 257.18,105.22 257.37,105.22 257.63,104.96 257.82,104.96 258.02,105.15 258.02,105.34 257.52,105.84 257.52,106.03 257.71,106.22 257.9,106.22 258.37,105.74 258.56,105.74 258.75,105.93 258.75,106.12 258.51,106.36 258.51,107.08 261.38,109.95 262.82,109.95 263.05,110.18 263.05,110.37 262.91,110.52 262.91,110.71 263.22,111.01 273.72,111.01 v1(274.12,110.61)
  BOTTOM w0.089: UG1.AA10 248.27,99.65 v1(248.27,99.8) ; v1(274.12,110.61) 273.72,110.21 UG18.G3
FBC_CAS#_L: length 46.9
  IN3 w0.089: 257.43,110.31 257.07,109.94 256.54,109.94 255.47,108.87 255.47,106.64 253.91,105.08 252.63,105.08 251.66,104.11 251.21,104.11 250.99,103.88 249.69,103.88 249.44,103.63 249.44,103.16 249.31,103.03 248.41,103.03 248.11,102.73 246.83,102.73 246.67,102.56 v1(246.67,102.2)
  IN3 w0.112: 257.43,110.31 257.43,110.33 257.8,110.7 257.8,111.7 258.29,112.19 258.29,112.72 260.19,114.61 263,117.43 263.23,117.43 263.34,117.32 263.34,116.92 263.45,116.81 263.67,116.81 263.78,116.92 263.78,117.52 263.9,117.63 264.12,117.63 264.23,117.52 264.23,116.92 264.34,116.81 264.58,116.81 264.69,116.92 264.69,117.52 264.81,117.63 265.03,117.63 265.14,117.52 265.14,116.92 265.25,116.81 265.48,116.81 265.59,116.92 265.59,117.52 265.7,117.63 265.92,117.63 266.04,117.52 266.04,116.92 266.15,116.81 266.37,116.81 266.48,116.92 266.48,117.52 266.59,117.63 266.82,117.63 266.93,117.52 266.93,116.92 267.04,116.81 267.26,116.81 267.38,116.92 267.38,117.52 267.49,117.63 267.77,117.63 268.37,117.04 272.14,117.04 272.25,117.15 272.25,117.48 272.36,117.6 272.58,117.6 272.69,117.48 272.69,117.15 272.81,117.04 273.03,117.04 273.14,117.15 273.14,117.48 273.25,117.6 273.48,117.6 273.59,117.48 273.59,117.15 273.7,117.04 274.01,117.04 274.12,116.93 v1(274.12,116.61)
  BOTTOM w0.089: v1(246.67,102.2) 246.67,102.05 UG1.W12 ; UG17.L3 v1(274.12,116.61)
FBC_CKE_H: length 39
  TOP w0.089: v1(245.87,99.8) 245.95,99.8 246.66,100.52
  TOP w0.135: v1(275.72,110.61) 275.51,110.61 275.12,111 274.79,111 274.54,111.25 274.54,111.55 274.28,111.8 263.38,111.8 261.97,110.39 261.13,110.39 256.82,106.08 256.3,106.08 255.55,105.32 255.55,105.13 255.8,104.88 255.8,104.69 255.61,104.5 255.42,104.5 v2(255.29,104.63) 255.17,104.75 254.98,104.75 254.79,104.56 254.79,104.37 255,104.16 255,103.96 254.82,103.77 254.63,103.77 254.41,103.99 254.22,103.99 253.65,103.43 253.65,102.94 251.85,101.14 251.85,100.84 251.53,100.52 246.66,100.52
  BOTTOM w0.089: v1(275.72,110.61) 275.32,110.21 UG18.J3 ; UG1.AA13 v1(245.87,99.8)
FBC_CKE_L: length 47.2
  IN3 w0.089: v1(245.87,101) 245.87,101.43 246.2,101.76 247.54,101.76 247.83,102.05 247.83,102.31 247.98,102.46 248.34,102.46 248.69,102.81 250.8,102.81 251.09,103.09 251.09,103.62 251.33,103.85 251.92,103.85 252.55,104.49 254.09,104.49 257.56,107.96 257.56,108.74 257.59,108.77
  IN3 w0.112: v1(275.72,116.61) 275.72,116.36 275.6,116.24 267.56,116.24 267.44,116.13 267.44,115.55 267.33,115.44 267.11,115.44 267,115.55 267,116.13 266.89,116.24 266.66,116.24 266.55,116.13 266.55,115.55 266.44,115.44 266.22,115.44 266.1,115.55 266.1,116.13 265.99,116.24 265.77,116.24 265.66,116.13 265.66,115.55 265.54,115.44 265.32,115.44 265.21,115.55 265.21,116.13 265.1,116.24 264.87,116.24 264.76,116.13 264.76,115.55 264.65,115.44 264.43,115.44 264.32,115.55 264.32,116.13 264.2,116.24 263.98,116.24 263.87,116.13 263.87,115.55 263.76,115.44 263.53,115.44 263.42,115.55 263.42,116.13 263.31,116.24 262.4,116.24 260.36,114.2 258.71,112.55 258.71,111.02 257.59,109.9 257.59,108.77
  BOTTOM w0.089: UG1.Y13 245.87,100.85 v1(245.87,101) ; UG17.J3 v1(275.72,116.61)
FBC_CLK0: length 47.5
  TOP w0.089: v1(275.73,123.86) 275.41,123.54 275.09,123.54 274.96,123.66 274.96,124.38 275.35,124.77 275.35,125.12 275.36,125.12 275.36,125.61 275.35,125.62 275.35,125.99 RG70.1
  IN3 w0.089: v1(249.87,107) 250.18,107.31 250.18,107.56 250.45,107.84 252.82,107.84 253.13,108.15 253.13,108.88 254.53,110.28 254.53,111.25 254.72,111.44 255.22,111.44 255.43,111.65 255.43,112.24 255.62,112.43 256.06,112.43 256.25,112.62 256.25,112.75 256.56,113.06 256.56,114.56 257.28,115.27 257.28,115.28 257.29,115.3
  IN3 w0.112: v1(275.73,123.86) 275.48,123.61 274.88,123.61 274.65,123.38 274.65,121.8 275.01,121.43 276.5,121.43 276.6,121.32 276.6,120.83 276.46,120.68 274.65,120.68 274.2,121.13 270.94,121.13 270.72,120.9 270.72,120.66 270.61,120.55 270.27,120.55 270.16,120.66 270.16,120.9 269.93,121.13 269.43,121.13 269.2,120.9 269.2,120.66 269.09,120.55 268.75,120.55 268.64,120.66 268.64,120.84 268.41,121.07 267.64,121.07 267.63,121.07 267.5,121.07 267.35,120.92 262.91,120.92 257.29,115.3
  BOTTOM w0.089: UG17.J12 275.37,124.21 v1(275.73,123.86) ; v1(249.87,107) 249.87,106.85 UG1.P8
FBC_CLK0#: length 47.5
  TOP w0.089: RG71.1 275.17,125.99 v3(275.17,125.37) 275.17,124.84 274.79,124.45 274.79,123.59 275.01,123.36 275.43,123.36 v1(275.69,123.09)
  IN3 w0.089: v1(250.67,107) 250.36,107.31 250.36,107.49 250.53,107.66 252.89,107.66 253.31,108.08 253.31,108.81 254.71,110.2 254.71,111.17 254.79,111.26 255.29,111.26 255.61,111.58 255.61,112.16 255.7,112.25 256.14,112.25 256.43,112.54 256.43,112.68 256.74,112.99 256.74,114.48 257.4,115.15 257.42,115.15 257.43,115.16
  IN3 w0.112: v1(275.69,123.09) 275.69,123.21 275.49,123.41 274.96,123.41 274.85,123.3 274.85,121.88 275.09,121.63 276.58,121.63 276.81,121.41 276.81,120.75 276.54,120.48 274.56,120.48 274.12,120.93 271.03,120.93 270.92,120.82 270.92,120.57 270.69,120.35 270.19,120.35 269.96,120.57 269.96,120.82 269.85,120.93 269.51,120.93 269.4,120.82 269.4,120.58 269.17,120.35 268.67,120.35 268.44,120.58 268.44,120.76 268.33,120.87 267.58,120.87 267.43,120.72 262.99,120.72 257.43,115.16
  BOTTOM w0.089: v1(250.67,107) 250.67,106.85 UG1.P7 ; UG17.J11 275.37,123.41 v1(275.69,123.09)
FBC_CLK1: length 44.3
  TOP w0.089: RG72.1 277.76,105.87 277.76,105.66 277.65,105.55 276.92,105.55 276.68,105.32 276.68,104.81 276.17,104.3 275.48,104.3 275.26,104.08 275.26,103.75 v1(274.92,103.41)
  IN4 w0.089: 258.73,98.92 258.71,98.92 258.69,98.9 257.93,98.9 253.66,94.63 245.8,94.63 245.42,94.25 245.42,94.15 v1(245.07,93.8)
  IN4 w0.119: 258.73,98.92 260.65,98.92 262.59,100.86 263.01,100.86 263.26,100.62 263.26,100.34 263.37,100.23 263.73,100.23 263.85,100.34 263.85,100.62 264.09,100.86 264.63,100.86 264.87,100.62 264.87,100.34 264.99,100.23 265.35,100.23 265.47,100.34 265.47,100.62 265.71,100.86 266.24,100.86 266.49,100.62 266.49,100.34 266.61,100.23 266.96,100.23 267.08,100.34 267.08,100.62 267.33,100.86 267.64,100.86 267.64,100.86 268.4,100.86 268.4,100.86 274.72,100.86 275.14,101.27 275.14,102.86 275.22,102.94 275.22,103.12 v1(274.92,103.41)
  BOTTOM w0.089: UG1.AF14 v1(245.07,93.8) ; UG18.J12 v1(274.92,103.41)
FBC_CLK1#: length 44.3
  TOP w0.089: v1(275.72,103.41) 275.44,103.7 275.44,104 275.56,104.12 276.24,104.12 276.86,104.73 276.86,105.24 276.99,105.38 277.72,105.38 277.94,105.59 277.94,105.84 RG73.1
  IN4 w0.089: v1(245.87,93.8) 245.6,94.07 245.6,94.17 245.88,94.46 253.74,94.46 258,98.72 258.69,98.72 258.71,98.71 258.73,98.71
  IN4 w0.119: v1(275.72,103.41) 275.43,103.12 275.43,102.86 275.34,102.77 275.34,101.19 274.81,100.65 268.49,100.65 268.48,100.65 267.41,100.65 267.29,100.53 267.29,100.26 267.05,100.01 266.52,100.01 266.28,100.26 266.28,100.53 266.16,100.65 265.8,100.65 265.68,100.53 265.68,100.26 265.44,100.01 264.9,100.01 264.66,100.26 264.66,100.53 264.54,100.65 264.18,100.65 264.06,100.53 264.06,100.26 263.82,100.01 263.29,100.01 263.04,100.26 263.04,100.53 262.93,100.65 262.68,100.65 260.74,98.71 258.73,98.71
  BOTTOM w0.089: UG18.J11 v1(275.72,103.41) ; UG1.AF13 v1(245.87,93.8)
FBC_CS#_H: length 37.8
  TOP w0.089: v1(247.47,93.8) 247.85,93.42
  TOP w0.135: v1(276.52,102.61) 276.13,102.23 275.45,102.23 275.15,101.93 275.15,101.36 274.67,100.88 v2(268.93,100.88) 266.88,100.88 259.42,93.42 258.4,93.42 258.26,93.55 258.26,93.75 258.13,93.89 257.86,93.89 257.72,93.75 257.72,93.55 257.59,93.42 257.32,93.42 257.19,93.55 257.19,94.06 257.05,94.19 256.78,94.19 256.65,94.06 256.65,93.55 256.51,93.42 256.24,93.42 256.11,93.55 256.11,94.06 255.97,94.19 255.7,94.19 255.57,94.06 255.57,93.55 255.44,93.42 247.85,93.42
  BOTTOM w0.089: v1(276.52,102.61) 276.92,103.01 UG18.L12 ; UG1.AF11 247.47,93.95 v1(247.47,93.8)
FBC_CS#_L: length 43.6
  IN3 w0.089: v1(248.1,108.24) 248.7,108.83
  IN3 w0.112: 248.7,108.83 248.7,109.55 249.16,110.02 250.82,110.02 251.24,110.45 251.24,111.5 251.1,111.65 251.1,112.22 252.03,113.16 252.03,113.19 252.95,114.1 252.95,114.35 253.14,114.54 253.14,114.71 254.2,115.77 254.62,115.77 255.53,116.68 255.53,116.99 255.88,117.33 256.28,117.33 257.49,118.55 257.49,118.58 261.75,122.84 262.96,122.84 264.61,124.49 265.89,124.49 266,124.6 266,125.21 266.11,125.32 266.33,125.32 266.44,125.21 266.44,124.6 266.56,124.49 266.78,124.49 266.89,124.6 266.89,125.26 267,125.37 267.23,125.37 267.34,125.26 267.34,124.6 267.45,124.49 267.87,124.49 268.37,124.99 274.51,124.99 274.63,124.88 274.63,124.1 274.74,123.98 274.96,123.98 275.07,124.1 275.07,124.88 275.18,124.99 275.99,124.99 276.37,124.61 v1(276.52,124.61)
  BOTTOM w0.089: v1(248.1,108.24) 248.12,108.23 248.15,108.03 UG1.M10 ; UG17.G12 v1(276.52,124.61)
FBC_D0: length 35.5
  IN1 w0.119: v1(256.17,116) 256.4,116.23 256.4,117.45 257.47,118.52 258.47,118.52 261.96,122.01 261.96,122.94 267.08,128.05 279.22,128.05 281.7,125.57 281.7,125.13 282.12,124.7 v1(282.12,124.61)
  BOTTOM w0.089: UG1.C1 256.17,115.95 v1(256.17,116) ; UG17.A13 v1(282.12,124.61)
FBC_D1: length 36.9
  IN1 w0.089: v1(254.87,115.4) 255.07,115.6
  IN1 w0.119: v1(281.32,123.01) 281.71,123.4 281.71,124.76 281.43,125.04 281.17,125.04 280.9,125.3 280.9,125.57 279.48,126.99 267.19,126.99 264.63,124.43 264.54,124.43 262.44,122.32 262.44,121.82 258.67,118.05 257.62,118.05 256.78,117.2 256.78,116.07 256.3,115.6 255.07,115.6
  BOTTOM w0.089: UG1.D2 254.87,115.05 v1(254.87,115.4) ; UG17.B11 v1(281.32,123.01)
FBC_D2: length 39.9
  IN1 w0.089: 255,116.07 254.32,115.39 v1(254.32,115.37)
  IN1 w0.119: 255,116.07 255.26,116.07 255.59,116.4 255.59,117.16 257.43,119 258.27,119 261.49,122.21 261.49,123.06 266.9,128.48 279.59,128.48 282.5,125.57 282.5,123.39 v1(282.12,123.01)
  BOTTOM w0.089: v1(254.32,115.37) 254.29,115.37 UG1.D3 ; UG17.A11 v1(282.12,123.01)
FBC_D3: length 35.9
  IN1 w0.089: v1(253.32,114.2) 254.02,114.9
  IN1 w0.119: 254.02,114.9 254.97,114.9 255.37,115.3 256.39,115.3 257.04,115.94 257.04,116.79 257.82,117.57 258.86,117.57 267.18,125.89 269.26,125.89 269.86,126.48 279.19,126.48 280.1,125.57 280.1,125.26 280.34,125.01 280.66,125.01 281.06,124.61 v1(281.32,124.61)
  BOTTOM w0.089: UG1.E4 253.32,114.1 v1(253.32,114.2) ; UG17.B13 v1(281.32,124.61)
FBC_D4: length 27.8
  IN1 w0.089: v1(255.07,113) 255.07,113.02 255.41,113.36 256.11,113.36 256.16,113.31 257.43,113.31
  IN1 w0.119: 257.43,113.31 257.75,113.31 258.07,113.62 259.05,114.61 260.09,114.61 266.38,120.9 266.92,120.9 268.65,122.62 276.93,122.62 v1(277.32,123.01)
  BOTTOM w0.089: UG17.F11 v1(277.32,123.01) ; UG1.F2 255.07,112.85 v1(255.07,113)
FBC_D5: length 30.3
  IN1 w0.089: v1(254.17,113) 254.17,113.01 254.81,113.66 256.08,113.66 256.21,113.78 257.43,113.78
  IN1 w0.119: v1(278.12,124.61) 277.74,124.24 276.41,124.24 276.14,123.97 276.14,123.6 276.02,123.48 275.09,123.48 275.03,123.41 268.36,123.41 266.33,121.38 266.2,121.38 259.9,115.08 258.85,115.08 257.56,113.78 257.43,113.78
  BOTTOM w0.089: UG17.F13 v1(278.12,124.61) ; UG1.F3 254.17,112.85 v1(254.17,113)
FBC_D6: length 31.5
  IN1 w0.089: 257.43,112.81 256.7,112.81 256.42,112.54 254.66,112.54 254.5,112.39 253.86,112.39 253.28,111.8 v1(253.27,111.8)
  IN1 w0.119: 257.43,112.81 257.92,112.81 258.26,113.15 259.25,114.13 260.29,114.13 266.58,120.42 267.6,120.42 268.62,121.44 277.62,121.44 277.74,121.56 277.74,122.64 v1(278.12,123.01)
  BOTTOM w0.089: UG17.E11 v1(278.12,123.01) ; UG1.H4 253.27,111.65 v1(253.27,111.8)
FBC_D7: length 33.2
  IN1 w0.089: v1(254.17,111.8) 254.53,112.16 256.66,112.16
  IN1 w0.119: v1(278.92,124.61) 278.52,124.21 278.52,121.12 278.4,121 268.74,121 267.69,119.95 267.31,119.95 261.02,113.66 259.44,113.66 258.09,112.3 256.8,112.3 256.66,112.16
  BOTTOM w0.089: UG1.H3 254.17,111.65 v1(254.17,111.8) ; UG17.E13 v1(278.92,124.61)
FBC_D8: length 28.6
  IN1 w0.119: v1(269.32,119.01) 269.72,119.41 277.48,119.41 277.71,119.18 277.71,118.62 v1(278.12,118.21)
  BOTTOM w0.089: UG17.E4 v1(278.12,118.21) ; UG1.J1 255.97,110.45
  BOTTOM w0.135: 255.97,110.45 255.97,110.95 264.55,119.53 268.8,119.53 v1(269.32,119.01)
FBC_D9: length 28.9
  IN1 w0.119: v1(268.52,119.01) 268.93,118.6 276.93,118.6 v1(277.32,118.21)
  BOTTOM w0.089: UG17.F4 v1(277.32,118.21) ; UG1.L3 254.47,109.55
  BOTTOM w0.135: v1(268.52,119.01) 265.33,119.01 v2(260.98,114.66) 257.75,111.43 257.2,111.43 256.37,110.6 256.37,110.24 255.68,109.55 254.47,109.55
FBC_D10: length 29.5
  IN1 w0.089: 257.43,110.37 v1(256.9,110.37)
  IN1 w0.119: 257.43,110.37 258.54,110.37 260.06,111.89 262.09,111.89 266.41,116.21 266.78,116.21 268.38,117.8 278.38,117.8 278.52,117.66 278.52,117.01 v1(278.92,116.61)
  BOTTOM w0.089: v1(278.92,116.61) 278.52,116.21 UG17.E2 ; UG1.L2 255.07,109.25
  BOTTOM w0.135: v1(256.9,110.37) 255.78,109.25 255.07,109.25
FBC_D11: length 30.7
  IN1 w0.089: v1(256.67,109.45) 257.43,109.45
  IN1 w0.119: v1(278.12,116.61) 277.72,117.01 269.02,117.01 268.92,116.91 268.92,116.36 268.77,116.21 268.23,116.21 267.74,115.73 266.61,115.73 262.29,111.41 260.26,111.41 258.29,109.45 257.43,109.45
  BOTTOM w0.089: UG1.M4 253.57,108.35 ; v1(278.12,116.61) 277.72,116.21 UG17.F2
  BOTTOM w0.135: 253.57,108.35 256.32,108.35 256.67,108.7 v1(256.67,109.45)
FBC_D12: length 33.4
  IN1 w0.119: v1(261.21,109.16) 261.45,108.92 263.32,108.92 267.64,113.24 272.3,113.24 274.11,115.05 280.46,115.05 280.92,115.52 280.92,116.01 281.32,116.41 v1(281.32,116.61)
  BOTTOM w0.089: 255.53,106.85 255.07,106.85 UG1.P2 ; UG17.B2 280.92,116.21 v1(281.32,116.61)
  BOTTOM w0.135: 255.53,106.85 256.2,106.85 257.63,108.29 257.63,109.43 258.06,109.86 v2(260.1,109.86) 260.51,109.86 v1(261.21,109.16)
FBC_D13: length 34.4
  IN1 w0.119: v1(281.32,118.21) 281.71,117.82 281.71,115.65 280.8,114.73 274.46,114.73 272.49,112.76 267.83,112.76 263.52,108.45 261.04,108.45 v1(260.76,108.73)
  BOTTOM w0.089: UG1.P1 256.47,106.4 256.52,106.45 ; v1(281.32,118.21) 280.92,117.81 UG17.B4
  BOTTOM w0.135: v1(260.76,108.73) 260.21,109.27 258.72,109.27 258.17,108.73 v2(258.17,108.36) 258.17,108.1 256.52,106.45
FBC_D14: length 35.1
  IN1 w0.119: v1(282.12,116.61) 282.51,116.22 282.51,115.65 281.28,114.42 274.82,114.42 272.69,112.29 268.03,112.29 263.62,107.88 260.72,107.88 v1(260.32,108.27)
  BOTTOM w0.089: UG1.R3 254.47,105.95 254.9,105.95 ; UG17.A2 281.72,116.21 v1(282.12,116.61)
  BOTTOM w0.135: 254.9,105.95 255.82,105.95 255.92,106.05 256.84,106.05 259.07,108.27 v1(260.32,108.27)
FBC_D15: length 36.3
  IN1 w0.119: v1(282.12,118.21) 282.82,117.51 282.82,115.29 281.48,113.94 275.74,113.94 273.61,111.81 268.23,111.81 263.8,107.39 v1(259.43,107.39)
  BOTTOM w0.089: UG17.A4 281.72,117.81 v1(282.12,118.21) ; UG1.R2 255.07,105.65
  BOTTOM w0.135: v1(259.43,107.39) 258.75,107.39 256.9,105.54 256.61,105.54 256.5,105.65 255.07,105.65
FBC_D16: length 30.8
  IN4 w0.089: v1(251.47,111.8) 251.85,112.18
  IN4 w0.119: 251.85,112.18 254.78,112.18 255.59,112.99 255.59,114.42 256.87,115.69 256.87,116.17 257.22,116.53 258.14,116.53 258.9,117.29 259.37,117.29 261.78,119.69 261.78,121.66 264.54,124.43 265.3,124.43 267.05,126.18 270.69,126.18 271.33,125.54 271.33,125 v1(271.72,124.61)
  BOTTOM w0.089: UG1.H6 251.47,111.65 v1(251.47,111.8) ; UG17.N13 v1(271.72,124.61)
FBC_D17: length 34.6
  IN4 w0.089: 250.82,111.35 v1(250.07,110.6)
  IN4 w0.119: 250.82,111.35 250.82,111.68 251.71,112.58 254.28,112.58 254.62,112.92 254.62,114.29 254.91,114.58 255.4,114.58 256.55,115.73 256.55,116.55 257,117 257.94,117 258.7,117.76 259.17,117.76 261.3,119.89 261.3,122.28 265.68,126.65 271.02,126.65 272.14,125.52 272.14,124.99 v1(272.52,124.61)
  BOTTOM w0.089: UG1.J8 250.02,110.6 v1(250.07,110.6) ; UG17.M13 v1(272.52,124.61)
FBC_D18: length 28.9
  IN4 w0.089: v1(250.87,110.6) 251.57,111.3
  IN4 w0.119: v1(269.32,124.61) 268.94,124.99 266.54,124.99 262.25,120.71 262.25,119.5 261.18,118.43 261.18,117.36 260.44,116.62 258.9,116.62 258.34,116.05 257.32,116.05 257.18,115.92 257.18,115.52 257.06,115.39 257.06,115.09 256.51,114.54 256.51,112.71 255.11,111.3 251.57,111.3
  BOTTOM w0.089: UG17.T13 v1(269.32,124.61) ; UG1.J7 250.82,110.6 v1(250.87,110.6)
FBC_D19: length 25.8
  IN4 w0.119: v1(252.37,110.6) 252.8,111.03 255.22,111.03 256.72,112.53 256.72,112.56 256.76,112.6 256.76,114.43 257.31,114.98 257.31,115.04 257.84,115.58 258.54,115.58 259.1,116.14 260.64,116.14 261.79,117.29 261.79,118.36 262.73,119.3 262.73,120.51 266.02,123.8 267.35,123.8 268.16,124.61 v1(268.52,124.61)
  BOTTOM w0.089: UG1.J5 252.37,110.45 v1(252.37,110.6) ; UG17.U13 v1(268.52,124.61)
FBC_D20: length 28.6
  IN4 w0.089: v1(249.87,109.4) 250.27,109.8
  IN4 w0.119: v1(268.52,123.01) 268.52,121.78 268.05,121.31 267.05,121.31 265.22,119.48 265.22,118.27 264.28,117.33 264.28,116.26 261.1,113.09 258.93,113.09 257.6,111.76 257.34,111.76 256.23,110.65 256.23,110.06 255.32,109.15 253.61,109.15 252.95,109.8 250.27,109.8
  BOTTOM w0.089: UG17.U11 v1(268.52,123.01) ; UG1.L8 249.87,109.25 v1(249.87,109.4)
FBC_D21: length 31
  IN4 w0.089: 251.87,109 v1(251.47,109.4)
  IN4 w0.119: v1(272.52,123.01) 272.52,122.75 270.13,120.36 267.44,120.36 266.17,119.09 266.17,117.88 265.23,116.93 265.23,115.58 261.78,112.14 259.32,112.14 257.05,109.86 257.05,109.14 256.23,108.32 253.23,108.32 252.55,109 251.87,109
  BOTTOM w0.089: v1(251.47,109.4) 251.47,109.25 UG1.L6 ; UG17.N11 v1(272.52,123.01)
FBC_D22: length 27.3
  IN4 w0.089: v1(252.37,109.4) 252.65,109.4
  IN4 w0.119: 252.65,109.4 253.29,108.77 255.45,108.77 256.52,109.83 256.52,110.53 257.27,111.28 257.8,111.28 259.12,112.61 261.37,112.61 264.75,116 264.75,117.13 265.7,118.07 265.7,119.28 267.25,120.83 268.91,120.83 269.38,121.3 269.38,122.96 v1(269.32,123.01)
  BOTTOM w0.089: UG17.T11 v1(269.32,123.01) ; UG1.L5 252.37,109.25 v1(252.37,109.4)
FBC_D23: length 35.2
  IN4 w0.089: v1(249.32,108.24) 249.32,108.45 249.49,108.61
  IN4 w0.119: v1(273.32,123.01) 272.93,122.62 272.93,122.07 270.91,120.05 267.8,120.05 266.65,118.89 266.65,117.68 265.7,116.73 265.7,114.85 262.51,111.66 259.52,111.66 257.63,109.77 257.63,108.52 257.08,107.98 253.19,107.98 252.55,108.61 249.49,108.61
  BOTTOM w0.089: UG1.M9 249.26,108.24 v1(249.32,108.24) ; UG17.M11 v1(273.32,123.01)
FBC_D24: length 24.4
  IN4 w0.089: 253.37,106.3 252.67,107 v1(252.37,107)
  IN4 w0.119: v1(268.52,116.61) 268.49,116.61 268.14,116.26 268.14,112.24 264.95,109.05 261.68,109.05 258.93,106.3 253.37,106.3
  BOTTOM w0.089: UG1.P5 252.37,106.85 v1(252.37,107) ; UG17.U2 268.92,116.21 v1(268.52,116.61)
