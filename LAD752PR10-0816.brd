# Allegro board LAD752PR10-0816.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
FBA_D59: length 21.7
  IN4 w0.089: 230.02,113.95 229.62,113.55 v1(229.62,113.25)
  IN4 w0.119: 230.02,113.95 230.02,114.35 229.56,114.81 229.56,117.31 229.3,117.57 229.3,118.12 228.79,118.63 228.73,118.63 226.53,120.83 225.77,120.83 225.69,120.91 225.69,125.74 226.09,126.14 226.09,130.22 v1(226.67,130.8)
  BOTTOM w0.089: v1(226.67,130.8) 227.07,131.2 UG14.A11 ; v1(229.62,113.25) 229.77,113.25 UG1.F29
FBA_D60: length 20.3
  IN4 w0.089: 230.83,114.08 230.82,114.07 v1(230.82,113.25)
  IN4 w0.119: 230.83,114.08 230.83,117.89 228.18,120.54 228.18,124.71 228.58,125.11 228.58,130.49 v1(228.27,130.8)
  BOTTOM w0.089: UG1.F27 230.97,113.25 v1(230.82,113.25) ; UG14.A13 228.67,131.2 v1(228.27,130.8)
FBA_D61: length 22.7
  IN4 w0.089: v1(232.02,115.05) 231.37,115.7
  IN4 w0.119: 231.37,115.7 231.37,118.21 229.14,120.44 229.14,124.32 229.53,124.72 229.53,130.31 229.75,130.52 229.75,133.07 229.22,133.61 228.66,133.61 v1(228.27,134)
  BOTTOM w0.089: UG14.E13 228.67,134.4 v1(228.27,134) ; UG1.D26 232.17,115.05 v1(232.02,115.05)
FBA_D62: length 21.3
  IN4 w0.089: 231.12,115.05 v1(232.02,114.15)
  IN4 w0.119: 231.12,115.05 231.12,117.98 228.66,120.44 228.66,124.51 229.06,124.91 229.06,130.25 229.46,130.66 229.46,130.96 229.23,131.19 228.68,131.19 v1(228.27,131.6)
  BOTTOM w0.089: UG1.E26 232.17,114.15 v1(232.02,114.15) ; UG14.B13 228.67,132 v1(228.27,131.6)
FBA_D63: length 27
  IN4 w0.089: 232.42,112.85 v1(232.02,112.45)
  IN4 w0.119: 232.42,112.85 232.42,117.25 231.72,117.95 231.72,118.37 231.37,118.71 231.37,119.45 231.15,119.67 230.84,119.67 230.62,119.45 230.49,119.45 229.61,120.32 229.61,124.12 230.01,124.52 230.01,130.27 230.07,130.33 230.07,133.56 229.23,134.4 228.67,134.4 v1(228.27,134.8)
  BOTTOM w0.089: UG1.G26 232.17,112.45 v1(232.02,112.45) ; UG14.F13 228.67,135.2 v1(228.27,134.8)
FBA_DBI0#: length 44.7
  IN1 w0.089: v1(217.67,107) 217.26,107.41 216.46,107.41 216.4,107.34 215.65,107.34
  IN1 w0.119: 215.65,107.34 214.85,107.34 214.29,107.34 206.15,115.48 206.15,118.93 204.81,120.27 204.81,125.95 204.44,126.32 204.44,130.2 204.84,130.6 204.84,141.18 205.28,141.61 205.88,141.61 v1(206.25,141.98)
  BOTTOM w0.089: v1(217.67,107) 217.67,106.85 UG1.P43 ; UG13.D13 v1(206.25,141.98)
FBA_DBI1#: length 39.8
  IN1 w0.089: v1(220.37,111.8) 219.57,112.6
  IN1 w0.119: v1(214.27,142) 214.65,141.62 214.65,138.64 214.43,138.42 211.61,138.42 211.46,138.27 211.46,130.14 211.28,129.96 211.28,122.64 216.1,117.82 216.1,116.81 216.05,116.75 216.05,114.32 217.12,113.25 217.12,113.02 217.54,112.6 219.57,112.6
  BOTTOM w0.089: UG13.D2 214.67,141.6 v1(214.27,142) ; v1(220.37,111.8) 220.37,111.65 UG1.H40
FBA_DBI2#: length 40.6
  IN4 w0.089: v1(220.37,107) 219.96,106.59
  IN4 w0.112: 217.56,106.59 216.67,106.59 216.63,106.63 216.61,106.63 216.39,106.85 216.39,107.15 216.26,107.28 215.65,107.28
  IN4 w0.119: 215.65,107.28 211.27,107.28 206.02,112.54 206.02,124.38 206.55,124.91 206.55,127.07 207.19,127.72 207.19,130.2 207.46,130.47 207.46,130.97 207.45,130.98 207.45,132.56 207.23,132.78 207.21,132.78 207.19,132.79 206.68,132.79 v1(206.27,133.2) ; 219.96,106.59 217.56,106.59
  BOTTOM w0.089: v1(220.37,107) 220.37,106.85 UG1.P40 ; UG13.P13 205.87,133.6 v1(206.27,133.2)
FBA_DBI3#: length 28
  IN4 w0.089: v1(221.27,113) 221.27,113.4 220.92,113.75
  IN4 w0.119: v1(214.27,133.2) 214.34,133.2 214.74,132.8 215.23,132.8 215.46,132.56 215.46,130.66 215.23,130.42 214.78,130.42 214.4,130.04 214.4,116.63 217.28,113.75 220.92,113.75
  BOTTOM w0.089: v1(221.27,113) 221.27,112.85 UG1.F39 ; v1(214.27,133.2) 214.67,133.6 UG13.P2
FBA_DBI4#: length 30.1
  IN1 w0.089: v1(223.62,115.05) 222.8,115.87
  IN1 w0.119: 222.8,115.87 222.8,118.3 222.33,118.77 222.33,123.29 219.09,126.52 219.09,133.36 219.32,133.58 219.68,133.58 219.85,133.75 219.85,140.82 v1(219.47,141.2)
  BOTTOM w0.089: v1(223.62,115.05) 223.77,115.05 UG1.D36 ; UG14.P2 v1(219.47,141.2)
FBA_DBI5#: length 26.7
  IN1 w0.089: v1(228.42,117.75) 229.36,118.69
  IN1 w0.119: v1(228.27,142) 228.66,141.61 228.66,130.5 228.42,130.25 228.42,126.52 229.36,125.58 229.36,118.69
  BOTTOM w0.089: UG1.A30 228.57,117.75 v1(228.42,117.75) ; UG14.P13 228.67,141.6 v1(228.27,142)
FBA_DBI6#: length 25.6
  IN3 w0.089: 224.02,114.95 v1(224.82,114.15)
  IN3 w0.112: 219.21,129.92 219.21,119.33 219.46,119.07
  IN3 w0.119: v1(220.27,133.2) 220.12,133.2 219.72,132.8 219.32,132.8 219.07,132.55 219.07,130.56 219.21,130.42 219.21,129.92 ; 224.02,114.95 224.02,117.88 223.35,118.56 219.98,118.56 219.46,119.07
  BOTTOM w0.089: UG1.E35 224.97,114.15 v1(224.82,114.15) ; v1(220.27,133.2) 219.87,133.6 UG14.D2
FBA_DBI7#: length 26.1
  IN4 w0.089: 230.07,112.1 v1(229.62,111.65)
  IN4 w0.119: v1(228.27,133.2) 228.2,133.2 227.79,132.79 227.31,132.79 227.08,132.56 227.08,130.46 226.77,130.15 226.77,125.86 226.37,125.46 226.37,121.21 226.5,121.08 226.84,121.08 229.61,118.31 229.61,117.62 229.81,117.41 229.81,114.91 230.27,114.45 230.27,113.75 230.07,113.55 230.07,112.1
  BOTTOM w0.089: v1(228.27,133.2) 228.67,133.6 UG14.D13 ; v1(229.62,111.65) 229.77,111.65 UG1.H29
FBA_EDC0: length 50
  IN1 w0.089: v1(219.47,105.8) 219.47,106.39 219.31,106.55 217.04,106.55 217,106.51 215.65,106.51
  IN1 w0.119: v1(206.27,142.8) 206.27,142.54 206.15,142.42 204.92,142.42 204.59,142.1 204.59,131.24 203.61,130.26 203.61,125.98 203.98,125.6 203.98,119.92 205.32,118.59 205.32,115.03 213.83,106.51 215.65,106.51
  BOTTOM w0.089: UG1.R41 219.47,105.65 v1(219.47,105.8) ; UG13.C13 v1(206.27,142.8)
FBA_EDC1: length 38
  IN1 w0.089: 218.04,113.53 v1(218.57,113)
  IN1 w0.119: 218.04,113.53 217.28,113.53 216.35,114.46 216.35,118.74 213.43,121.66 213.43,122.78 212.19,124.02 212.19,130.04 212.29,130.14 212.29,137.47 212.41,137.59 215.2,137.59 215.45,137.84 215.45,142.18 215.23,142.4 214.67,142.4 v1(214.27,142.8)
  BOTTOM w0.089: v1(214.27,142.8) 214.67,142.4 UG13.C2 ; UG1.F42 218.57,112.85 v1(218.57,113)
FBA_EDC2: length 41.7
  IN4 w0.089: 220.87,106.2 v1(221.27,105.8)
  IN4 w0.119: v1(206.27,132.4) 206.58,132.4 206.69,132.28 206.69,130.2 206.57,130.08 205.84,130.08 205.72,129.96 205.72,125.26 205.19,124.72 205.19,112.2 211,106.38 215.92,106.38 216.1,106.2 220.87,106.2
  BOTTOM w0.089: UG1.R39 221.27,105.65 v1(221.27,105.8) ; v1(206.27,132.4) 205.87,132.8 UG13.R13
FBA_EDC3: length 29.2
  IN4 w0.089: v1(222.17,111.8) 222.17,112.25
  IN4 w0.119: v1(214.27,132.4) 214.65,132.02 214.65,130.64 214.43,130.42 214.25,130.42 214,130.17 213.72,130.17 213.57,130.02 213.57,116.29 215.57,114.29 216.12,114.29 217.02,113.39 220.58,113.39 220.82,113.15 220.82,112.85 221.07,112.6 221.82,112.6 222.17,112.25
  BOTTOM w0.089: v1(222.17,111.8) 222.17,111.65 UG1.H38 ; v1(214.27,132.4) 214.67,132.8 UG13.R2
FBA_EDC4: length 30.2
  IN1 w0.089: v1(222.42,116.85) 222,117.27
  IN1 w0.119: v1(220.27,142.8) 220.17,142.8 219.77,142.4 219.32,142.4 219.08,142.16 219.08,133.94 218.62,133.49 218.62,130.28 218.2,129.85 218.2,126.13 221.42,122.91 221.42,118.53 222,117.95 222,117.27
  BOTTOM w0.089: v1(222.42,116.85) 222.57,116.85 UG1.B38 ; UG14.R2 v1(220.27,142.8)
FBA_EDC5: length 30.5
  IN1 w0.119: v1(228.27,142.8) 228.66,142.42 229.21,142.42 229.45,142.18 229.45,127.08 230.19,126.34 230.19,123.41 v1(230.7,122.9)
  BOTTOM w0.089: v1(228.27,142.8) 228.67,142.4 UG14.R13 ; UG1.C29 229.47,116.25
  BOTTOM w0.135: v1(230.7,122.9) 228.95,121.14 228.95,118.02 229.47,117.5 229.47,116.25
FBA_EDC6: length 22.7
  IN3 w0.089: v1(224.82,115.05) 224.42,115.45
  IN3 w0.112: 220.25,129.92 220.25,119.45 220.54,119.16
  IN3 w0.119: v1(220.27,132.4) 219.87,132 219.87,130.65 220.25,130.27 220.25,129.92 ; 220.54,119.16 220.67,119.03 223.66,119.03 224.42,118.27 224.42,115.45
  BOTTOM w0.089: UG14.C2 219.87,132.8 v1(220.27,132.4) ; UG1.D35 224.97,115.05 v1(224.82,115.05)
FBA_EDC7: length 23.2
  IN4 w0.089: v1(230.82,112.45) 230.43,112.84
  IN4 w0.119: v1(228.27,132.4) 227.87,132 227.87,130.55 227.68,130.35 227.68,125.38 227.35,125.05 227.35,121.18 227.63,120.9 227.63,120.65 229.86,118.41 229.86,118.04 229.86,117.73 230.58,117.01 230.58,113.61 230.43,113.46 230.43,112.84
  BOTTOM w0.089: v1(228.27,132.4) 228.67,132.8 UG14.C13 ; UG1.G27 230.97,112.45 v1(230.82,112.45)
FBA_MA0_H: length 34.8
  IN3 w0.089: 225.62,112.05 v1(226.02,111.65)
  IN3 w0.112: 225.62,112.05 225.62,118.59 224.42,119.79 224.42,122.14 224.29,122.27 222.79,122.27 222.66,122.4 222.66,122.59 222.79,122.72 224.29,122.72 224.42,122.85 224.42,123.03 224.29,123.17 222.79,123.17 222.66,123.3 222.66,130.42 223.3,131.06 223.3,137.37 v1(221.87,138.8)
  BOTTOM w0.089: v1(226.02,111.65) 226.17,111.65 UG1.H33 ; UG14.K4 221.47,138.4 v1(221.87,138.8)
FBA_MA0_L: length 52.5
  IN3 w0.089: v1(226.97,104.6) 226.38,105.19 223.43,105.19 223.42,105.18 223.4,105.18
  IN3 w0.112: 223.4,105.18 217.69,105.18 217.26,105.61 217.26,105.7 216.28,106.69 216.28,107.22 215.43,108.07 215.43,108.23 215.59,108.38 215.59,108.54 215.43,108.7 215.27,108.7 215.11,108.54 214.96,108.54 214.8,108.7 214.8,108.86 214.94,109.01 214.94,109.16 214.79,109.32 214.63,109.32 214.48,109.17 214.32,109.17 214.17,109.33 214.17,109.49 214.28,109.6 214.28,109.76 214.01,110.03 214.01,116.88 209.81,121.07 209.81,124.8 209.81,124.81 209.81,125.03 209.92,125.14 210.54,125.14 210.66,125.25 210.66,125.48 210.54,125.59 209.92,125.59 209.81,125.7 209.81,125.92 209.92,126.03 210.54,126.03 210.66,126.15 210.66,131.78 210.51,131.92 210.51,137.17 211.72,138.37 212.3,138.37 v1(212.67,138)
  BOTTOM w0.089: UG1.U32 226.97,104.45 v1(226.97,104.6) ; v1(212.67,138) 213.07,138.4 UG13.H4
FBA_MA1_H: length 37.6
  IN3 w0.089: v1(227.12,108.3) 226.67,108.75
  IN3 w0.112: v1(222.67,138.8) 223.77,137.7 223.77,129.95 223.21,129.39 223.21,124.88 223.49,124.61 224.78,124.61 224.91,124.48 224.91,124.29 224.78,124.16 223.49,124.16 223.36,124.03 223.36,123.84 223.49,123.71 224.78,123.71 224.91,123.58 224.91,119.97 226.45,118.43 226.45,110.32 226.67,110.1 226.67,108.75
  BOTTOM w0.089: v1(222.67,138.8) 222.27,138.4 UG14.K5 ; v1(227.12,108.3) UG1.M32
FBA_MA1_L: length 52.2
  IN3 w0.089: v1(225.37,104.6) 225.01,104.96 224.72,104.96 223.92,104.96 223.53,104.96
  IN3 w0.112: v1(212.67,138.8) 211.48,138.8 210.24,137.56 210.24,127.46 210.13,127.35 209.51,127.35 209.4,127.23 209.4,127.01 209.51,126.9 210.13,126.9 210.24,126.79 210.24,126.56 210.13,126.45 209.51,126.45 209.4,126.34 209.4,119.89 212.73,116.55 213.32,116.55 213.59,116.28 213.59,109.32 216.04,106.87 216.04,106.58 217.02,105.6 217.02,104.62 217.46,104.17 223.21,104.17 223.4,104.36 223.4,104.83 223.53,104.96
  BOTTOM w0.089: v1(212.67,138.8) 212.27,138.4 UG13.H5 ; UG1.U34 225.37,104.45 v1(225.37,104.6)
FBA_MA2_H: length 35.2
  IN3 w0.089: 226.85,111.22 v1(227.22,110.85)
  IN3 w0.112: 226.85,111.22 226.85,118.38 225.33,119.9 225.33,125.02 225.2,125.15 224.04,125.15 223.91,125.29 223.91,125.47 224.04,125.6 225.2,125.6 225.33,125.73 225.33,125.92 225.2,126.05 223.9,126.05 223.63,126.32 223.63,129.22 224.54,130.12 224.54,136.17 225.17,136.8 226.27,136.8 v1(226.67,137.2)
  BOTTOM w0.089: UG14.K11 226.67,138 v1(226.67,137.2) ; UG1.J32 227.37,110.85 v1(227.22,110.85)
FBA_MA2_L: length 52.7
  IN3 w0.089: 227.06,104.11 v1(227.77,103.4)
  IN3 w0.112: v1(207.87,138.8) 208,138.8 209.3,137.5 209.3,130.97 208.56,130.23 208.56,116.4 211.91,113.05 211.91,109.75 216.12,105.54 216.12,105.36 216.35,105.12 216.35,104.99 216.36,104.98 216.36,104.59 217.92,103.03 223.12,103.03 223.34,103.25 223.34,103.5 223.76,103.92 224.23,103.92 224.42,104.11 227.06,104.11
  BOTTOM w0.089: v1(227.77,103.4) 227.77,103.25 UG1.V31 ; v1(207.87,138.8) 207.47,138.4 UG13.H11
FBA_MA3_H: length 34.9
  TOP w0.089: v1(227.22,110.05) 226.62,110.65
  TOP w0.119: v1(225.87,138) 224.54,136.67 v2(224.54,132.05) 224.54,129.92 ; 224.52,120.94 224.52,120.2 226.62,118.1 226.62,110.65
  TOP w0.135: 224.52,120.94 224.52,123.9 224.39,124.04 223.85,124.04 223.72,124.17 223.72,124.44 223.85,124.57 224.39,124.57 224.52,124.71 224.52,124.97 224.39,125.1 223.85,125.1 223.72,125.24 223.72,125.51 223.85,125.64 224.39,125.64 224.52,125.78 224.52,126.05 224.39,126.18 223.85,126.18 223.72,126.32 223.72,126.59 223.85,126.72 224.39,126.72 224.52,126.85 224.52,129.9 224.54,129.92
  BOTTOM w0.089: UG14.K10 v1(225.87,138) ; UG1.K32 227.37,110.05 v1(227.22,110.05)
FBA_MA3_L: length 51.4
  IN3 w0.089: v1(224.57,104.6) 224.14,104.17
  IN3 w0.112: v1(208.67,138.8) 209.27,138.8 209.77,138.3 209.77,129.79 209.66,129.68 209.09,129.68 208.98,129.57 208.98,129.34 209.09,129.23 209.66,129.23 209.77,129.12 209.77,128.89 209.66,128.78 209.09,128.78 208.98,128.67 208.98,128.45 209.09,128.34 209.66,128.34 209.77,128.22 209.77,127.99 209.66,127.87 209.09,127.87 208.98,127.76 208.98,119.7 212.32,116.35 212.32,109.99 215.79,106.53 215.79,106.48 216.61,105.67 216.61,104.68 217.44,103.85 223.35,103.85 223.67,104.17 224.14,104.17
  BOTTOM w0.089: UG13.H10 208.27,138.4 v1(208.67,138.8) ; UG1.U35 224.57,104.45 v1(224.57,104.6)
FBA_MA4_H: length 34.7
  IN3 w0.089: v1(228.42,110.05) 228.04,110.43
  IN3 w0.112: v1(226.67,136.4) 226.65,136.4 226.25,136 226.25,131.09 226.16,131.01 226.16,125.55 226.29,125.42 227.16,125.42 227.29,125.29 227.29,125.1 227.16,124.97 226.29,124.97 226.16,124.84 226.16,124.65 226.29,124.52 227.16,124.52 227.29,124.39 227.29,124.21 227.16,124.08 226.29,124.08 226.16,123.95 226.16,123.76 226.29,123.63 227.16,123.63 227.29,123.5 227.29,123.31 227.16,123.18 226.29,123.18 226.16,123.05 226.16,120.46 228.04,118.59 228.04,110.43
  BOTTOM w0.089: UG14.H11 227.07,136.8 v1(226.67,136.4) ; v1(228.42,110.05) 228.57,110.05 UG1.K30
FBA_MA4_L: length 51.7
  IN3 w0.089: v1(223.77,103.4) 223.77,102.95
  IN3 w0.112: v1(207.87,137.2) 208.09,137.2 208.3,136.99 208.3,130.63 207.69,130.01 207.69,123.94 207.58,123.83 206.88,123.83 206.76,123.72 206.76,123.49 206.88,123.38 207.54,123.38 207.65,123.27 207.65,123.05 207.54,122.93 206.88,122.93 206.72,122.78 206.72,122.57 206.86,122.43 207.54,122.43 207.65,122.32 207.65,122.09 207.54,121.98 206.83,121.98 206.72,121.87 206.72,117.65 210.24,114.13 210.24,110.75 216.12,104.88 216.12,104.03 217.56,102.58 223.4,102.58 223.77,102.95
  BOTTOM w0.089: UG13.K11 v1(207.87,137.2) ; UG1.V36 223.77,103.25 v1(223.77,103.4)
FBA_MA5_H: length 39.6
  IN3 w0.089: v1(228.42,109.25) 227.89,109.78
  IN3 w0.112: v1(225.87,136.4) 225.5,136.03 225.5,130.91 225.74,130.66 225.74,129.86 225.61,129.73 224.73,129.73 224.6,129.59 224.6,129.41 224.73,129.28 225.61,129.28 225.74,129.15 225.74,128.96 225.61,128.83 224.32,128.83 224.19,128.7 224.19,128.51 224.32,128.38 225.61,128.38 225.74,128.25 225.74,128.07 225.61,127.94 224.55,127.94 224.42,127.81 224.42,127.62 224.55,127.49 225.61,127.49 225.74,127.36 225.74,127.17 225.61,127.04 224.45,127.04 224.32,126.91 224.32,126.73 224.45,126.6 225.61,126.6 225.74,126.47 225.74,120.12 227.72,118.14 227.72,110.2 227.89,110.04 227.89,109.78
  BOTTOM w0.089: v1(228.42,109.25) 228.57,109.25 UG1.L30 ; UG14.H10 v1(225.87,136.4)
FBA_MA5_L: length 52.4
  IN3 w0.089: 225.5,101.81 225.75,102.07 225.75,102.98 v1(226.17,103.4)
  IN3 w0.112: 225.5,101.81 224.43,101.81 224.36,101.89 217.05,101.89 209.41,109.53 209.41,113.78 205.89,117.3 205.89,135.74 206.13,135.99 207.46,135.99 v1(207.87,136.4)
  BOTTOM w0.089: UG13.K10 v1(207.87,136.4) ; v1(226.17,103.4) 226.17,103.25 UG1.V33
FBA_MA6_H: length 34.5
  TOP w0.089: 224,112.47 v1(224.82,111.65)
  TOP w0.135: 224,112.47 224,118.75 v2(222.61,120.14) 222,120.75 222,121.99 222.14,122.13 222.44,122.13 222.58,122.26 222.58,122.53 222.44,122.67 222.14,122.67 222,122.8 222,123.06 222.14,123.2 222.7,123.2 222.83,123.33 222.83,123.6 222.7,123.74 222.14,123.74 222,123.87 222,124.14 222.14,124.28 222.7,124.28 222.83,124.41 222.83,124.68 222.7,124.81 222.14,124.81 222,124.95 222,125.22 222.14,125.35 222.7,125.35 222.83,125.49 222.83,125.76 222.7,125.89 222.14,125.89 222,126.03 222,126.29 222.16,126.44 222.67,126.44 222.83,126.6 222.83,126.83 222.67,126.98 222.16,126.98 222,127.14 222,127.36 222.16,127.52 222.67,127.52 222.89,127.74 222.89,129.81 222.29,130.41 222.29,135.99 v1(221.87,136.4)
  BOTTOM w0.089: v1(224.82,111.65) 224.97,111.65 UG1.H35 ; UG14.H5 v1(221.87,136.4)
FBA_MA6_L: length 51.9
  IN3 w0.089: 225.73,106.24 v1(226.17,105.8)
  IN3 w0.112: 225.73,106.24 224.38,106.24 224.16,106.46 219.21,106.46 218.94,106.73 218.94,107.3 218.19,108.05 218.19,108.36 217.94,108.62 217.05,108.62 215.65,110.02 215.65,117.01 212.66,119.99 212.66,120.89 212.77,121 213.29,121 213.4,121.11 213.4,121.33 213.29,121.45 212.78,121.45 212.67,121.56 212.67,121.78 212.78,121.89 213.29,121.89 213.4,122.01 213.4,124.69 213.29,124.8 212.78,124.8 212.67,124.91 212.67,125.13 212.78,125.25 213.29,125.25 213.4,125.36 213.4,125.6 213.29,125.71 212.77,125.71 212.66,125.82 212.66,126.04 212.77,126.16 213.29,126.16 213.4,126.27 213.4,126.49 213.29,126.6 212.77,126.6 212.66,126.71 212.66,126.94 212.77,127.05 213.29,127.05 213.4,127.16 213.4,127.38 213.29,127.5 212.77,127.5 212.66,127.61 212.66,127.83 212.77,127.94 213.29,127.94 213.4,128.06 213.4,128.28 213.29,128.39 212.77,128.39 212.66,128.5 212.66,128.73 212.77,128.84 213.29,128.84 213.4,128.95 213.4,129.17 213.29,129.28 212.77,129.28 212.66,129.4 212.66,129.62 212.77,129.73 213.29,129.73 213.4,129.84 213.4,130.35 213.1,130.65 213.1,135.9 212.6,136.4 v1(211.87,136.4)
  BOTTOM w0.089: v1(226.17,105.8) 226.17,105.65 UG1.R33 ; UG13.K5 v1(211.87,136.4)
FBA_MA7_H: length 35
  TOP w0.089: 225.13,110.29 v1(226.12,109.3)
  TOP w0.135: v1(221.87,137.2) 221.46,136.79 221.46,129.85 221.59,129.71 222.32,129.71 222.45,129.58 222.45,129.31 222.32,129.17 221.59,129.17 221.46,129.04 221.46,128.77 221.59,128.63 222.32,128.63 222.45,128.5 222.45,128.23 222.32,128.1 221.59,128.1 221.46,127.96 221.46,127.68 221.49,127.64 v2(221.49,121.7) 221.49,120.24 223.24,118.5 223.24,112.73 224.27,111.7 224.27,110.54 224.52,110.29 225.13,110.29
  BOTTOM w0.089: UG14.H4 v1(221.87,137.2) ; v1(226.12,109.3) UG1.L33
FBA_MA7_L: length 50.7
  IN3 w0.089: 223.97,106.21 224.38,105.8 v1(224.57,105.8)
  IN3 w0.112: 223.97,106.21 218.45,106.21 218.13,106.52 218.13,107.16 214.84,110.45 214.84,117.23 212.25,119.82 212.25,120.13 212.13,120.24 211.83,120.24 211.74,120.33 211.74,120.51 211.85,120.62 212.13,120.62 212.25,120.73 212.25,120.96 212.13,121.07 210.99,121.07 210.88,121.19 210.88,121.34 210.99,121.46 212.13,121.46 212.25,121.57 212.25,121.81 212.13,121.92 210.76,121.92 210.64,122.03 210.64,122.25 210.76,122.37 212.13,122.37 212.25,122.48 212.25,123.27 212.13,123.38 211.6,123.38 211.49,123.49 211.49,123.71 211.6,123.83 212.13,123.83 212.25,123.94 212.25,124.16 212.13,124.27 211.6,124.27 211.49,124.38 211.49,124.61 211.6,124.72 212.13,124.72 212.25,124.83 212.25,125.05 212.13,125.17 211.6,125.17 211.49,125.28 211.49,125.5 211.6,125.61 212.13,125.61 212.25,125.72 212.25,135.45 212.36,135.56 v1(212.68,135.56)
  BOTTOM w0.089: v1(212.68,135.56) 212.68,136.4 213.07,136.8 UG13.K4 ; UG1.R35 224.57,105.65 v1(224.57,105.8)
FBA_MA8_H: length 32.4
  IN3 w0.089: v1(226.02,110.85) 225.22,111.65
  IN3 w0.112: 225.22,111.65 225.22,118.61 223.97,119.86 223.97,120.78 223.84,120.91 223.07,120.91 222.96,121.02 222.96,121.24 223.07,121.35 223.84,121.35 223.97,121.49 223.97,121.72 223.84,121.85 222.38,121.85 222.25,121.99 222.25,130.65 222.38,130.78 223.05,131.45 223.05,136.83 v1(222.67,137.2)
  BOTTOM w0.089: UG1.J33 226.17,110.85 v1(226.02,110.85) ; UG14.J5 v1(222.67,137.2)
FBA_MA8_L: length 53.7
  IN3 w0.089: v1(227.77,104.6) 226.94,105.43 223.4,105.43
  IN3 w0.112: v1(211.87,138) 210.76,136.88 210.76,132.06 211.07,131.74 211.07,127.59 211.18,127.48 211.72,127.48 211.83,127.37 211.83,127.15 211.72,127.04 211.18,127.04 211.07,126.92 211.07,126.7 211.18,126.59 211.72,126.59 211.83,126.48 211.83,126.25 211.72,126.14 211.18,126.14 211.07,126.03 211.07,124.84 210.96,124.72 210.34,124.72 210.23,124.61 210.23,124.39 210.34,124.28 210.96,124.28 211.07,124.17 211.07,123.94 210.96,123.83 210.34,123.83 210.23,123.72 210.23,123.49 210.34,123.38 210.96,123.38 211.07,123.27 211.07,123.05 210.96,122.94 210.34,122.94 210.23,122.82 210.23,121.25 214.42,117.05 214.42,110.27 217.24,107.45 217.24,106.9 218.04,106.1 218.04,105.72 218.34,105.43 223.4,105.43
  BOTTOM w0.089: UG1.U31 227.77,104.45 v1(227.77,104.6) ; UG13.J5 v1(211.87,138)
FBA_RAS#_H: length 36.2
  TOP w0.089: 224.17,108.6 v1(224.57,108.2)
  TOP w0.135: 224.17,108.6 222.4,108.6 221.77,109.23 221.77,109.5 220.86,110.41 220.86,114.39 220.96,114.5 220.96,114.84 220.73,115.06 220.73,117.82 218.65,119.91 218.65,137.18 v1(220.27,138.8)
  BOTTOM w0.089: UG14.L3 v1(220.27,138.8) ; UG1.M35 v1(224.57,108.2)
FBA_RAS#_L: length 53.1
  IN3 w0.089: v1(226.17,107) 226.17,107.63
  IN3 w0.112: v1(213.47,138.8) 213.87,139.2 215.93,139.2 216.69,138.44 216.69,129.98 216.85,129.83 217.78,129.83 217.88,129.73 217.88,129.47 217.77,129.36 216.81,129.36 216.7,129.24 216.7,129.02 216.81,128.91 217.71,128.91 217.82,128.8 217.82,128.57 217.71,128.46 216.81,128.46 216.7,128.35 216.7,128.13 216.81,128.01 217.71,128.01 217.82,127.9 217.82,127.68 217.71,127.57 216.81,127.57 216.7,127.46 216.7,127.23 216.81,127.12 217.71,127.12 217.82,127.01 217.82,126.79 217.71,126.67 216.81,126.67 216.7,126.56 216.7,126.34 216.81,126.23 217.71,126.23 217.82,126.12 217.82,125.88 217.71,125.76 216.81,125.76 216.7,125.65 216.7,125.43 216.81,125.32 217.23,125.32 217.34,125.21 217.34,118.42 218.95,116.82 218.95,116.5 219.97,115.48 219.97,110.47 220.74,109.7 220.74,109.4 221.19,108.95 224.66,108.95 224.99,108.62 224.99,108.05 225.22,107.83 225.97,107.83 226.17,107.63
  BOTTOM w0.089: UG13.G3 213.87,139.2 v1(213.47,138.8) ; v1(226.17,107) UG1.P33
FBA_WCK0: length 43.4
  IN1 w0.089: v1(218.57,109.4) 218.83,109.66 218.83,109.92 218.74,110 216.62,110 215.75,110.88 215.65,110.88
  IN1 w0.119: 215.65,110.88 215.21,110.88 212.4,113.69 212.4,116.4 207.44,121.36 207.44,126.42 208.08,127.06 208.08,130 208.08,130.01 208.08,130.19 209.18,131.29 209.18,140.01 210.87,141.7 212.37,141.7 v1(212.67,142)
  BOTTOM w0.089: UG1.L42 218.57,109.25 v1(218.57,109.4) ; UG13.D4 213.07,141.6 v1(212.67,142)
FBA_WCK0_N: length 43.3
  IN1 w0.089: v1(219.47,109.4) 219.1,109.4 219.01,109.49 219.01,109.99 218.81,110.18 216.69,110.18 215.82,111.05 215.74,111.05 215.73,111.07 215.68,111.07 215.66,111.09 215.65,111.09
  IN1 w0.119: 215.65,111.09 215.29,111.09 212.61,113.77 212.61,116.49 207.65,121.44 207.65,126.33 208.29,126.97 208.29,130.1 209.39,131.21 209.39,139.93 210.96,141.49 212.38,141.49 v1(212.67,141.2)
  BOTTOM w0.089: v1(219.47,109.4) 219.47,109.25 UG1.L41 ; UG13.D5 v1(212.67,141.2)
FBA_WCK1: length 40.8
  IN4 w0.089: v1(221.27,109.4) 221.57,109.7 221.57,109.9 221.48,109.98 216.64,109.98 216.28,110.34 215.67,110.34 215.67,110.34 215.65,110.34
  IN4 w0.119: 215.65,110.34 214.28,110.34 213.35,111.27 213.18,111.27 212.81,110.91 212.47,110.91 212.09,111.29 212.09,111.63 212.46,112 212.46,112.16 210.31,114.31 210.14,114.31 209.78,113.95 209.37,113.95 208.99,114.33 208.99,114.67 209.39,115.07 209.39,115.23 208.64,115.98 208.64,123.01 209.96,124.32 209.96,130 209.96,130.01 209.96,133 210.75,133.79 212.46,133.79 v1(212.67,134)
  BOTTOM w0.089: v1(221.27,109.4) 221.27,109.25 UG1.L39 ; UG13.P4 v1(212.67,134)
FBA_WCK1_N: length 40.8
  IN4 w0.089: v1(222.17,109.4) 221.83,109.4 221.75,109.49 221.75,109.97 221.55,110.16 216.71,110.16 216.32,110.55 215.65,110.55
  IN4 w0.119: v1(212.67,133.2) 212.29,133.58 210.83,133.58 210.17,132.91 210.17,124.23 208.86,122.92 208.86,116.06 209.6,115.32 209.6,114.98 209.2,114.58 209.2,114.41 209.46,114.16 209.69,114.16 210.05,114.52 210.4,114.52 212.67,112.25 212.67,111.91 212.3,111.55 212.3,111.38 212.56,111.12 212.73,111.12 213.09,111.49 213.43,111.49 214.37,110.55 215.65,110.55
  BOTTOM w0.089: v1(222.17,109.4) 222.17,109.25 UG1.L38 ; v1(212.67,133.2) 212.27,133.6 UG13.P5
FBA_WCK2: length 29.7
  IN1 w0.089: 223.78,129.92 223.78,129.93 223.77,129.95 223.77,130 223.75,130.01 223.75,140.87 222.91,141.71 222.16,141.71 v1(221.87,142) ; v1(226.02,116.85) 226.02,116.64 225.89,116.51 225.67,116.51 225.54,116.63 225.54,121.23
  IN1 w0.119: 223.78,129.92 223.78,128.83 223.53,128.58 223.53,127.03 225.54,125.02 225.54,121.23
  BOTTOM w0.089: UG14.P4 v1(221.87,142) ; UG1.B33 226.17,116.85 v1(226.02,116.85)
FBA_WCK2_N: length 29.7
  IN1 w0.089: 223.57,129.92 223.57,140.8 222.84,141.53 222.2,141.53 v1(221.87,141.2) ; v1(226.02,115.95) 226.02,116.21 225.89,116.33 225.59,116.33 225.37,116.56 225.37,121.13 225.35,121.15 225.35,121.2 225.33,121.22 225.33,121.23
  IN1 w0.119: 223.57,129.92 223.57,128.92 223.32,128.66 223.32,126.94 225.33,124.93 225.33,121.23
  BOTTOM w0.089: UG1.C33 226.17,115.95 v1(226.02,115.95) ; UG14.P5 v1(221.87,141.2)
FBA_WCK3: length 25.7
  IN4 w0.089: v1(228.42,115.05) 228.42,114.89 228.27,114.73 227.98,114.73 227.83,114.89 227.83,117.45 227.78,117.49 227.78,117.94 227.76,117.96 227.76,117.97 227.44,118.29 227.43,118.29 226.15,119.57 224.45,119.57 223.59,120.43 223.59,121.23
  IN4 w0.119: v1(221.87,134) 222.17,133.7 223.29,133.7 223.91,133.08 223.91,128.81 223.59,128.49 223.59,121.23
  BOTTOM w0.089: v1(228.42,115.05) 228.57,115.05 UG1.D30 ; UG14.D4 v1(221.87,134)
FBA_WCK3_N: length 25.7
  IN4 w0.089: v1(228.42,114.15) 228.42,114.33 228.19,114.56 227.91,114.56 227.65,114.82 227.65,117.37 227.6,117.42 227.6,117.86 227.58,117.88 227.58,117.9 227.37,118.11 227.35,118.11 226.07,119.39 224.37,119.39 223.41,120.36 223.41,121.13 223.39,121.15 223.39,121.2 223.38,121.22 223.38,121.23
  IN4 w0.119: v1(221.87,133.2) 222.16,133.49 223.21,133.49 223.7,133 223.7,129.92 223.7,129.92 223.7,128.9 223.38,128.57 223.38,121.23
  BOTTOM w0.089: v1(221.87,133.2) 222.27,133.6 UG14.D5 ; UG1.E30 228.57,114.15 v1(228.42,114.15)
FBA_WE#_H: length 34.9
  IN3 w0.089: 228.05,119.85 228.78,119.11 228.78,112.01 v1(228.42,111.65)
  IN3 w0.112: 228.05,119.85 227.72,120.17 227.72,121.63 227.71,121.64 227.71,125.72 227.6,125.83 226.69,125.83 226.58,125.95 226.58,126.17 226.69,126.28 227.6,126.28 227.71,126.39 227.71,126.62 227.6,126.73 226.69,126.73 226.58,126.84 226.58,127.06 226.69,127.18 227.6,127.18 227.71,127.29 227.71,128.28 227.58,128.41 226.71,128.41 226.58,128.54 226.58,128.72 226.71,128.85 227.58,128.85 227.71,128.99 227.71,129.17 227.58,129.3 226.71,129.3 226.58,129.43 226.58,129.62 226.71,129.75 227.58,129.75 227.71,129.88 227.71,130.34 227.87,130.5 227.87,136 v1(228.27,136.4)
  BOTTOM w0.089: UG14.G12 227.87,136 v1(228.27,136.4) ; v1(228.42,111.65) 228.57,111.65 UG1.H30
FBA_WE#_L: length 54.1
  IN3 w0.089: 224.81,102.84 v1(225.37,103.4)
  IN3 w0.112: 224.81,102.84 224.23,102.84 223.59,102.2 217.5,102.2 215.78,103.92 215.78,104.55 209.83,110.51 209.83,113.96 206.31,117.48 206.31,124.25 206.42,124.36 207.16,124.36 207.27,124.47 207.27,124.69 207.16,124.8 206.42,124.8 206.31,124.92 206.31,125.14 206.42,125.25 207.16,125.25 207.27,125.36 207.27,125.59 207.16,125.7 206.42,125.7 206.31,125.81 206.31,126.03 206.42,126.15 207.16,126.15 207.27,126.26 207.27,126.48 207.16,126.59 206.42,126.59 206.31,126.7 206.31,126.94 206.46,127.1 207.1,127.1 207.21,127.21 207.21,130.06 207.47,130.32 207.47,134.33 v1(206.26,135.54)
  BOTTOM w0.089: v1(225.37,103.4) 225.37,103.25 UG1.V34 ; UG13.L12 206.67,135.95 v1(206.26,135.54)
FBB_ABI#_H: length 36.6
  TOP w0.089: 240.85,109.68 v1(240.42,109.25)
  TOP w0.135: 240.85,109.68 240.85,114.53 240.72,114.67 240.43,114.67 240.29,114.8 240.29,115.07 240.43,115.21 240.72,115.21 240.85,115.34 240.85,115.61 240.72,115.75 240.43,115.75 240.29,115.88 240.29,116.15 240.43,116.28 240.72,116.28 240.85,116.42 240.85,117.2 v2(242.19,118.53) 242.39,118.74 242.39,119 242.25,119.13 242.16,119.13 242.02,119.27 242.02,119.54 242.16,119.67 242.25,119.67 242.39,119.81 242.39,120.08 242.25,120.21 242.16,120.21 242.02,120.34 242.02,120.61 242.16,120.75 242.25,120.75 242.39,120.88 242.39,121.14 242.2,121.34 242.2,121.68 242.39,121.88 242.39,124.38 242.57,124.57 242.57,124.76 242.39,124.94 242.39,125.13 242.58,125.32 242.77,125.32 242.95,125.14 243.15,125.14 247.86,129.85 247.86,136.56 248.08,136.79 248.66,136.79 v1(249.07,137.2)
  BOTTOM w0.089: UG1.L19 240.27,109.25 v1(240.42,109.25) ; UG16.J4 v1(249.07,137.2)
FBB_ABI#_L: length 31.2
  IN3 w0.089: 237.61,109.67 v1(238.02,109.25)
  IN3 w0.112: 237.61,109.67 237.61,116.45 238.44,117.28 238.44,127.08 241.07,129.71 241.07,137.08 241.19,137.2 v1(241.47,137.2)
  BOTTOM w0.089: v1(238.02,109.25) 237.87,109.25 UG1.L21 ; UG15.J4 v1(241.47,137.2)
FBB_CAS#_H: length 39.1
  TOP w0.089: 241.12,109.15 v1(240.42,108.45)
  TOP w0.135: v1(248.27,136.4) 248.67,136 248.67,130.05 242.83,124.2 242.83,123.56 242.96,123.43 243.74,123.43 243.87,123.29 243.87,123.02 243.74,122.89 242.96,122.89 242.83,122.75 242.83,122.48 242.96,122.35 243.74,122.35 243.87,122.21 243.87,121.94 243.74,121.81 242.96,121.81 242.83,121.68 242.83,121.41 242.96,121.28 243.71,121.28 243.85,121.14 243.85,120.88 243.71,120.74 242.96,120.74 242.83,120.61 242.83,120.34 242.96,120.21 243.33,120.21 243.47,120.08 243.47,119.81 243.33,119.67 242.96,119.67 242.83,119.54 242.83,118.51 241.12,116.8 241.12,109.15
  BOTTOM w0.089: UG16.G3 v1(248.27,136.4) ; UG1.M19 240.27,108.45 v1(240.42,108.45)
FBB_CAS#_L: length 34.3
  TOP w0.089: v1(238.02,110.05) 237.57,110.5
  TOP w0.135: v1(242.27,136.4) 242,136.4 241.86,136.26 241.86,130.64 237.57,126.35 237.57,119.6 237.43,119.46 236.55,119.46 236.42,119.33 236.42,119.06 236.55,118.93 237.43,118.93 237.57,118.79 237.57,118.52 237.43,118.39 v2(236.93,118.39) 236.55,118.39 236.42,118.25 236.42,117.98 236.55,117.85 237.43,117.85 237.57,117.71 237.57,117.45 237.43,117.32 237.38,117.32 237.24,117.18 237.24,116.91 237.38,116.78 237.43,116.78 237.57,116.64 237.57,110.5
  BOTTOM w0.089: UG15.L3 241.87,136 v1(242.27,136.4) ; v1(238.02,110.05) 237.87,110.05 UG1.K21
FBB_CKE_H: length 39.7
  TOP w0.089: 240.02,108.45 v1(239.22,107.65)
  TOP w0.135: 240.02,108.45 240.02,116.93 241.76,118.67 241.76,122.52 241.62,122.66 241.04,122.66 240.91,122.79 240.91,123.06 241.04,123.2 241.62,123.2 241.76,123.33 241.76,123.6 241.62,123.73 241.04,123.73 240.91,123.87 240.91,124.14 241.04,124.27 241.62,124.27 241.76,124.41 241.76,124.67 241.62,124.8 241.51,124.8 241.37,124.94 241.37,125.21 241.51,125.34 241.62,125.34 241.76,125.48 241.76,126.77 246.07,131.08 246.07,137.59 246.48,138 v1(248.27,138)
  BOTTOM w0.089: UG16.J3 v1(248.27,138) ; UG1.N20 239.07,107.65 v1(239.22,107.65)
FBB_CKE_L: length 35.6
  TOP w0.089: 238.51,108.14 v1(238.02,107.65)
  TOP w0.135: 238.51,108.14 238.51,114.59 238.71,114.79 v2(238.71,121.44) 238.71,123.38 238.58,123.52 238.46,123.52 238.32,123.65 238.32,123.92 238.46,124.06 238.58,124.06 238.71,124.19 238.71,124.45 238.58,124.59 238.31,124.59 238.17,124.72 238.17,124.99 238.31,125.12 238.58,125.12 238.71,125.26 238.71,125.53 238.58,125.66 238.31,125.66 238.17,125.8 238.17,126.07 238.71,126.61 238.71,126.7 242.69,130.67 242.69,137.59 v1(242.29,137.99)
  BOTTOM w0.089: UG1.N21 v1(238.02,107.65) ; UG15.J3 242.26,137.99 v1(242.29,137.99)
FBB_CLK0: length 41.1
  TOP w0.135: RG54.1 237.73,140.25 237.41,140.25 237.15,139.99 237.15,139.44 236.77,139.07 236.2,139.07 235.69,138.55 235.69,137.89 235.56,137.76 235.31,137.76 v1(235.07,138)
  IN3 w0.089: v1(232.15,107.52) 232.24,107.43 232.6,107.43 232.68,107.52 232.68,107.91 232.59,108 232.59,114.99 231.67,115.92 231.67,121.2 231.66,121.2 231.66,121.23 ; v1(235.07,138) 234.8,137.73 234.35,137.73 233.82,137.19 233.13,137.19 232.93,137 232.93,129.85
  IN3 w0.112: 231.66,121.23 231.66,126.6 232.93,127.88 232.93,129.85
  BOTTOM w0.089: v1(232.15,107.52) 232.15,107.37 231.76,106.99 231.76,106.72 232.08,106.4 UG1.P26 ; UG15.J12 v1(235.07,138)
FBB_CLK0#: length 40.3
  TOP w0.135: RG59.1 237.73,140.02 237.5,140.02 237.37,139.9 237.37,139.35 236.86,138.84 v3(236.57,138.84) 236.29,138.84 235.91,138.46 235.91,137.8 235.65,137.54 235.4,137.54 235.07,137.21 v1(235.07,137.2)
  IN3 w0.089: v1(232.15,106.85) 232.15,107.01 232.39,107.25 232.67,107.25 232.86,107.44 232.86,107.98 232.77,108.08 232.77,115.07 231.84,115.99 231.84,121.2 231.85,121.2 231.85,121.23 ; 233.13,129.85 233.13,129.86 233.12,129.87 233.12,129.93 233.11,129.93 233.11,136.93 233.2,137.01 233.89,137.01 234.43,137.55 235.07,137.55 235.17,137.45 235.17,137.3 v1(235.07,137.2)
  IN3 w0.112: 231.85,121.23 231.85,126.52 233.13,127.79 233.13,129.85
  BOTTOM w0.089: UG1.N26 232.5,107.2 v1(232.15,106.85) ; UG15.J11 v1(235.07,137.2)
FBB_CLK1: length 39.4
  TOP w0.089: v1(255.47,138) 255.17,137.7 254.99,137.7 254.9,137.79 254.9,138.37 254.7,138.57 254.51,138.57 RG55.1
  IN3 w0.089: 257.91,131.98 257.91,131.99 257.89,132 257.89,132.05 257.88,132.06 257.88,136.68 257.26,137.31 256.62,137.31 256.24,137.69 255.78,137.69 v1(255.47,138) ; 253.55,118.5 253.54,118.49 253.53,118.49 253.49,118.45 253.33,118.45 253.32,118.46 251.15,118.46 249.94,117.25 248.7,117.25 246.02,114.56 246.02,112.19 245.78,111.96 245.53,111.96 v1(245.22,111.65)
  IN3 w0.112: 253.55,118.5 255.22,120.16 255.22,120.34 255.34,120.46 255.34,120.58 257.26,122.5 257.26,126.54 256.93,126.86 256.93,129.74 257.91,130.71 257.91,131.98
  BOTTOM w0.089: UG16.J12 255.87,137.6 v1(255.47,138) ; v1(245.22,111.65) 245.07,111.65 UG1.H14
FBB_CLK1#: length 38.8
  TOP w0.089: RG56.1 254.51,138.39 254.63,138.39 254.72,138.3 254.72,137.72 254.91,137.52 255.15,137.52 v1(255.47,137.2)
  IN3 w0.089: v1(255.47,137.2) 255.78,137.51 256.17,137.51 256.55,137.13 257.19,137.13 257.7,136.61 257.7,131.98 ; 253.41,118.64 251.08,118.64 249.87,117.43 248.63,117.43 245.84,114.64 245.84,112.27 245.71,112.14 245.53,112.14 v1(245.22,112.45)
  IN3 w0.112: 253.41,118.64 255.01,120.24 255.01,120.42 255.1,120.51 255.11,120.51 255.14,120.54 255.14,120.66 257.06,122.58 257.06,126.45 256.74,126.78 256.74,129.83 257.7,130.79 257.7,131.98
  BOTTOM w0.089: UG1.G14 245.07,112.45 v1(245.22,112.45) ; UG16.J11 v1(255.47,137.2)
FBB_CS#_H: length 38.7
  IN3 w0.089: 247,110.63 v1(246.42,110.05)
  IN3 w0.112: v1(256.27,138.8) 256.27,138.2 256.92,137.55 257.92,137.55 258.64,136.83 258.64,122.93 255.91,120.2 255.82,120.2 253.06,117.44 252.64,117.44 252.57,117.38 251.08,117.38 250.08,116.39 248.65,116.39 247,114.73 247,110.63
  BOTTOM w0.089: UG1.K12 v1(246.42,110.05) ; UG16.L12 v1(256.27,138.8)
FBB_CS#_L: length 34
  IN3 w0.089: v1(232.02,109.25) 231.37,109.9
  IN3 w0.112: 231.37,109.9 231.37,117.92 230.28,119.01 230.28,123.62 230.88,124.22 230.88,126.77 232.04,127.93 232.04,137.12 232.47,137.55 233.67,137.55 233.87,137.75 233.87,138.4 v1(234.27,138.8)
  BOTTOM w0.089: v1(232.02,109.25) 232.17,109.25 UG1.L26 ; UG15.G12 v1(234.27,138.8)
FBB_D0: length 30
  IN4 w0.089: v1(232.02,110.05) 232.77,110.8
  IN4 w0.119: 232.77,110.8 232.77,118.05 231.62,119.19 231.62,119.55 231.25,119.92 230.9,119.92 230.9,119.92 230.65,119.92 230.29,120.28 230.29,123.84 230.69,124.24 230.69,132.13 232.96,134.4 233.87,134.4 v1(234.27,134.8)
  BOTTOM w0.089: UG15.M13 233.87,135.2 v1(234.27,134.8) ; v1(232.02,110.05) 232.17,110.05 UG1.K26
FBB_D1: length 24.3
  IN4 w0.089: v1(233.22,114.15) 233.62,114.55
  IN4 w0.119: v1(234.27,134) 233.88,133.61 232.95,133.61 232.77,133.43 232.66,133.43 231.16,131.93 231.16,120.29 231.28,120.17 231.36,120.17 231.87,119.65 231.87,119.39 233.09,118.17 233.09,115.83 233.62,115.3 233.62,114.55
  BOTTOM w0.089: v1(234.27,134) 233.87,134.4 UG15.N13 ; UG1.E25 233.37,114.15 v1(233.22,114.15)
FBB_D2: length 23.7
  IN4 w0.089: 233.94,113.97 v1(233.22,113.25)
  IN4 w0.119: 233.94,113.97 233.94,115.68 233.41,116.21 233.41,118.42 232.12,119.71 232.12,119.76 231.64,120.25 231.64,131.27 232.35,131.98 233.89,131.98 v1(234.27,131.6)
  BOTTOM w0.089: UG1.F25 233.37,113.25 v1(233.22,113.25) ; v1(234.27,131.6) 233.87,132 UG15.T13
FBB_D3: length 24.3
  IN4 w0.089: v1(233.22,111.65) 234.02,112.45
  IN4 w0.119: v1(234.27,130.8) 233.89,131.18 232.5,131.18 232.11,130.79 232.11,120.24 234.26,118.09 234.26,113.79 234.02,113.55 234.02,112.45
  BOTTOM w0.089: v1(233.22,111.65) 233.37,111.65 UG1.H25 ; v1(234.27,130.8) 233.87,131.2 UG15.U13
FBB_D4: length 24
  IN4 w0.089: v1(234.42,110.85) 235.22,111.65
  IN4 w0.119: 235.22,111.65 235.22,118.01 232.99,120.24 232.99,128.21 234.95,130.17 235.33,130.17 235.34,130.17 235.37,130.17 235.87,130.68 v1(235.87,130.8)
  BOTTOM w0.089: v1(234.42,110.85) 234.57,110.85 UG1.J24 ; UG15.U11 235.47,131.2 v1(235.87,130.8)
FBB_D5: length 19.3
  IN4 w0.089: 236.02,115.45 v1(235.62,115.05)
  IN4 w0.119: 236.02,115.45 236.02,118.61 234.83,119.79 234.83,129.23 236.03,130.42 236.03,130.42 236.25,130.64 236.25,131.22 v1(235.87,131.6)
  BOTTOM w0.089: UG15.T11 235.47,132 v1(235.87,131.6) ; v1(235.62,115.05) 235.77,115.05 UG1.D23
FBB_D6: length 23.8
  IN4 w0.089: v1(235.62,114.15) 236.34,114.87
  IN4 w0.119: 236.34,114.87 236.34,118.58 236.27,118.65 236.27,118.71 235.15,119.83 235.15,120.94 235.26,121.05 235.26,129.05 235.88,129.67 235.88,129.92 236.24,130.27 236.36,130.27 236.5,130.42 236.5,131.33 236.29,131.54 236.29,132.94 236.41,133.06 236.41,134.26 v1(235.87,134.8)
  BOTTOM w0.089: v1(235.87,134.8) 235.47,134.4 UG15.N11 ; UG1.E23 235.77,114.15 v1(235.62,114.15)
FBB_D7: length 26.7
  IN4 w0.089: 236.66,113.49 v1(235.62,112.45)
  IN4 w0.119: 236.66,113.49 236.66,118.92 235.72,119.86 235.72,128.92 236.3,129.5 236.3,129.73 236.8,130.23 236.8,132 237.05,132.25 237.05,134.97 236.82,135.21 236.26,135.21 v1(235.87,135.6)
  BOTTOM w0.089: UG15.M11 v1(235.87,135.6) ; UG1.G23 235.77,112.45 v1(235.62,112.45)
FBB_D8: length 19.8
  IN4 w0.089: v1(238.02,114.15) 238.02,115.2
  IN4 w0.119: 238.02,115.2 238.42,115.6 238.42,116.25 237.97,116.7 237.97,118.8 239.94,120.77 239.94,130.58 240.16,130.8 v1(240.67,130.8)
  BOTTOM w0.089: v1(238.02,114.15) 237.87,114.15 UG1.E21 ; UG15.U4 241.07,131.2 v1(240.67,130.8)
FBB_D9: length 24.7
  IN4 w0.089: 238.59,111.48 v1(239.22,110.85)
  IN4 w0.119: v1(240.67,131.6) 239.97,131.6 239.51,131.14 239.51,120.79 237.62,118.9 237.62,113.05 237.82,112.85 238.31,112.85 238.59,112.57 238.59,111.48
  BOTTOM w0.089: UG1.J20 239.07,110.85 v1(239.22,110.85) ; v1(240.67,131.6) 241.07,132 UG15.T4
FBB_D10: length 23
  IN4 w0.089: 238.42,113.25 v1(239.22,112.45)
  IN4 w0.119: v1(242.27,131.6) 241.88,131.21 241.88,130.52 241.56,130.21 241.56,123.1 240.77,122.3 240.77,120.71 240.1,120.05 239.72,120.05 238.32,118.65 238.32,116.9 238.77,116.45 238.77,115.05 238.42,114.7 238.42,113.25
  BOTTOM w0.089: v1(239.22,112.45) 239.07,112.45 UG1.G20 ; v1(242.27,131.6) 242.67,132 UG15.T2
FBB_D11: length 21.6
  IN4 w0.089: v1(239.22,113.25) 238.82,113.65
  IN4 w0.119: 238.82,113.65 238.82,114.6 239.12,114.9 239.12,116.65 238.67,117.1 238.67,118.49 239.98,119.79 241.25,119.79 242.01,120.56 242.01,129.7 242.29,129.98 v1(242.29,130.82)
  BOTTOM w0.089: UG1.F20 239.07,113.25 v1(239.22,113.25) ; UG15.U2 242.67,131.2 v1(242.29,130.82)
FBB_D12: length 23.7
  IN4 w0.089: v1(240.42,114.15) 240.42,114.75
  IN4 w0.119: 240.42,114.75 240.22,114.95 240.22,118.26 242.52,120.56 242.52,129.62 243.72,130.83 243.72,133.1 243.22,133.61 242.66,133.61 v1(242.27,134)
  BOTTOM w0.089: UG1.E19 240.27,114.15 v1(240.42,114.15) ; UG15.N2 242.67,134.4 v1(242.27,134)
FBB_D13: length 25.7
  IN4 w0.089: 240.82,113.65 v1(240.42,113.25)
  IN4 w0.119: 240.82,113.65 240.82,114.8 240.57,115.05 240.57,118.16 242.95,120.55 242.95,129.46 244.04,130.54 244.04,133.59 243.23,134.4 242.67,134.4 v1(242.27,134.8)
  BOTTOM w0.089: v1(242.27,134.8) 242.67,135.2 UG15.M2 ; v1(240.42,113.25) 240.27,113.25 UG1.F19
FBB_D14: length 27.3
  IN4 w0.089: v1(241.62,114.15) 241.17,114.6
  IN4 w0.119: v1(240.67,134.8) 241.06,135.19 243.23,135.19 244.36,134.07 244.36,130.26 243.38,129.28 243.38,120.46 240.89,117.98 240.89,115.23 241.17,114.95 241.17,114.6
  BOTTOM w0.089: v1(241.62,114.15) 241.47,114.15 UG1.E18 ; UG15.N4 v1(240.67,134.8)
FBB_D15: length 27.5
  IN4 w0.089: 241.22,115.45 v1(241.62,115.05)
  IN4 w0.119: v1(240.67,135.6) 241.06,135.99 243.23,135.99 244.83,134.4 244.83,130.13 243.8,129.11 243.8,120.06 243.37,119.63 243.12,119.63 241.22,117.74 241.22,115.45
  BOTTOM w0.089: UG15.M4 v1(240.67,135.6) ; v1(241.62,115.05) 241.47,115.05 UG1.D18
FBB_D16: length 27.1
  IN1 w0.119: v1(240.48,125.44) 240.82,125.78 240.82,129.74 240.26,130.3 240.26,139.99 v1(240.67,140.4)
  BOTTOM w0.089: UG15.E4 241.07,140.8 v1(240.67,140.4) ; UG1.C20 239.09,115.97
  BOTTOM w0.135: v1(240.48,125.44) 240.1,125.44 239.03,124.37 239.03,121.04 239.09,120.99 239.09,115.97
FBB_D17: length 28.7
  IN1 w0.119: v1(242.27,141.2) 241.9,141.57 241.63,141.57 241.63,141.58 240.04,141.58 239.4,140.94 239.4,130.57 240.36,129.62 v1(240.36,126.14)
  BOTTOM w0.089: v1(242.27,141.2) 242.67,140.8 UG15.E2
  BOTTOM w0.135: UG1.A20 238.62,121.01 238.59,121.04 238.59,124.55 v2(239.7,125.66) 239.92,125.88 240.1,125.88 v1(240.36,126.14)
FBB_D18: length 27
  IN1 w0.119: v1(240.48,124.17) 241.09,124.78 241.09,125.1 241.25,125.26 241.25,129.92 241.09,130.07 241.09,139.18 v1(240.67,139.6)
  BOTTOM w0.089: UG15.F4 241.07,140 v1(240.67,139.6) ; UG1.D20 239.41,115.39
  BOTTOM w0.135: v1(240.48,124.17) 240.31,124.17 239.47,123.34 v2(239.47,121.38) 239.47,118.21 239.41,118.15 239.41,115.39
FBB_D19: length 26.6
  IN1 w0.119: v1(242.27,140.4) 241.5,139.63 241.5,139.3 241.62,139.18 241.63,139.18 241.85,138.96 241.85,136.24 241.63,136.02 241.62,136.02 241.5,135.9 241.5,134.5 241.62,134.38 241.63,134.38 241.85,134.16 241.85,130.16 241.82,130.13 241.82,125.24 241.51,124.93 241.51,124.51 v1(240.48,123.48)
  BOTTOM w0.089: v1(242.27,140.4) 242.67,140 UG15.F2 ; UG1.B19 240.23,116.81
  BOTTOM w0.135: v1(240.48,123.48) 240.23,123.48 239.92,123.17 239.92,120.1 240.23,119.8 240.23,116.81
FBB_D20: length 32.1
  IN1 w0.119: v1(244.29,123.03) 244.59,123.33 244.59,137.34 244.26,137.67 244.26,143.54 243.79,144.01 242.71,144.01 v1(242.29,143.58)
  BOTTOM w0.089: v1(242.29,143.58) UG15.B2 ; UG1.B18 241.67,117.05
  BOTTOM w0.135: 241.67,117.05 241.67,117.47 242.01,117.8 242.01,119.09 242.52,119.6 242.52,120.43 242.84,120.75 242.84,120.88 242.84,120.89 242.84,121.62 242.89,121.67 242.89,122.46 243.47,123.03 v1(244.29,123.03)
FBB_D21: length 31.6
  IN1 w0.119: v1(244.3,122.39) 245.01,123.1 245.01,137.51 244.68,137.84 244.68,143.82 243.72,144.78 242.65,144.78 v1(242.27,144.4)
  BOTTOM w0.089: UG15.A2 242.67,144 v1(242.27,144.4) ; UG1.A17 242.39,117.47
  BOTTOM w0.135: 242.39,117.47 242.39,118.65 242.83,119.09 242.83,120.3 243.28,120.75 243.28,121.44 v2(243.47,121.63) 243.59,121.75 243.59,122.21 243.79,122.4 244.29,122.4 v1(244.3,122.39)
FBB_D22: length 32.8
  IN1 w0.089: 244.19,121.23 v1(244.29,121.13)
  IN1 w0.119: 244.19,121.23 243.79,121.63 243.79,123.29 244.16,123.66 244.16,137.16 244.03,137.29 244.03,137.33 243.91,137.45 243.91,142.74 243.48,143.18 241.09,143.18 v1(240.67,143.6)
  BOTTOM w0.089: UG1.C17 242.67,115.95 ; UG15.B4 241.07,143.2 v1(240.67,143.6)
  BOTTOM w0.135: v1(244.29,121.13) 244.17,121.13 243.21,120.17 243.21,118.9 242.67,118.36 242.67,115.95
FBB_D23: length 36.7
  IN1 w0.089: v1(244.26,120.52) 244.96,121.23
  IN1 w0.119: 244.96,121.23 245.44,121.7 245.44,137.69 245.11,138.02 245.11,144 243.9,145.2 241.47,145.2 v1(240.67,144.4)
  BOTTOM w0.089: v1(240.67,144.4) 241.07,144 UG15.A4 ; UG1.D17 242.97,115.35
  BOTTOM w0.135: v1(244.26,120.52) 243.53,119.79 243.53,118.76 242.97,118.2 242.97,115.35
FBB_D24: length 33.4
  IN1 w0.119: v1(234.32,125.44) 234.45,125.44 234.77,125.76 234.77,126.26 232.57,128.47 232.57,132.35 231.84,133.07 231.84,136.8 232.42,137.38 232.42,144.66 232.54,144.78 233.89,144.78 v1(234.27,144.4)
  BOTTOM w0.089: UG1.A26 232.62,118.21
  BOTTOM w0.13: v1(234.27,144.4) UG15.A13
  BOTTOM w0.135: v1(234.32,125.44) 233.82,125.44 231.78,123.41 v2(231.78,122.59) 231.78,120.05 232.62,119.21 232.62,118.21
FBB_D25: length 37.3
  IN1 w0.089: 235.5,144.77 v1(235.87,144.4)
  IN1 w0.119: 235.5,144.77 235.02,145.25 231.76,145.25 231.41,144.9 231.41,132.75 232.14,132.02 232.14,128.29 234.32,126.11 v1(234.32,126.08)
  BOTTOM w0.089: UG15.A11 v1(235.87,144.4) ; UG1.B26 232.17,116.85
  BOTTOM w0.135: v1(234.32,126.08) 233.82,126.08 v2(233.12,125.38) 231.34,123.6 231.34,119.79 232.17,118.96 232.17,116.85
FBB_D26: length 35.3
  IN1 w0.119: v1(235.87,143.6) 235.48,143.99 233.31,143.99 232.99,143.67 232.99,128.64 235.19,126.44 235.19,125.59 234.9,125.29 234.9,124.56 234.51,124.17 v1(234.32,124.17)
  BOTTOM w0.089: UG15.B11 v1(235.87,143.6) ; UG1.C25 233.07,116.25
  BOTTOM w0.135: v1(234.32,124.17) 233.47,124.17 232.29,122.99 232.29,121.04 232.29,121.04 232.29,120.11 v2(232.8,119.6) 233.07,119.33 233.07,116.25
FBB_D27: length 30.7
  IN1 w0.119: v1(234.27,143.6) 233.85,143.18 233.85,128.38 235.62,126.61 235.62,125.41 235.4,125.2 235.4,124.17 234.77,123.54 v1(234.32,123.54)
  BOTTOM w0.089: UG1.B25 233.37,116.85
  BOTTOM w0.13: v1(234.27,143.6) UG15.B13
  BOTTOM w0.135: v1(234.32,123.54) 234.07,123.54 232.73,122.2 232.73,120.31 233.37,119.67 233.37,116.85
FBB_D28: length 29.1
  IN1 w0.119: v1(236.67,124.3) 236.47,124.51 236.47,126.97 235.46,127.97 235.46,134.46 235.34,134.58 235.02,134.58 234.9,134.7 234.9,134.94 235.02,135.06 235.34,135.06 235.46,135.18 235.46,135.43 235.34,135.55 235.02,135.55 234.9,135.67 234.9,135.9 235.02,136.02 235.34,136.02 235.46,136.14 235.46,140.7 235.34,140.82 234.89,140.82 234.69,141.02 234.69,141.52 234.58,141.64 234.39,141.64 234.27,141.52 v1(234.27,141.2)
  BOTTOM w0.089: UG15.E13 v1(234.27,141.2) ; UG1.A24 235.02,117.97
  BOTTOM w0.135: v1(236.67,124.3) v2(236.07,123.7) 235.02,122.65 235.02,117.97
FBB_D29: length 29.8
  IN1 w0.119: v1(236.71,122.36) 237.08,122.74 237.08,122.85 237.09,122.86 237.09,127.29 236.97,127.41 236.62,127.41 236.5,127.53 236.5,127.73 236.62,127.84 236.97,127.84 237.09,127.96 237.09,128.13 236.97,128.25 236.01,128.25 235.89,128.37 235.89,128.61 236.01,128.73 236.97,128.73 237.09,128.85 237.09,129.09 236.97,129.21 236.01,129.21 235.89,129.33 235.89,129.57 236.01,129.69 236.18,129.69 236.29,129.8 236.29,137.63 236.18,137.75 235.83,137.75 235.72,137.86 235.72,138.1 235.83,138.22 236.18,138.22 236.29,138.34 236.29,138.59 236.18,138.71 235.83,138.71 235.72,138.83 235.72,139.07 235.83,139.19 236.18,139.19 236.29,139.3 236.29,139.48 236.17,139.6 v1(235.87,139.6)
  BOTTOM w0.089: UG1.A23 236.22,118.19 236.24,118.21 ; UG15.F11 v1(235.87,139.6)
  BOTTOM w0.135: v1(236.71,122.36) 236.58,122.36 236.24,122.02 v2(236.24,119.41) 236.24,118.21
FBB_D30: length 29.9
  IN1 w0.119: v1(234.27,140.4) 234.44,140.57 234.9,140.57 235.02,140.45 235.02,139.28 234.65,138.91 234.65,138.41 234.53,138.29 234.22,138.29 234.1,138.17 234.1,137.93 234.22,137.81 234.53,137.81 234.65,137.69 234.65,130.47 234.58,130.4 234.39,130.4 234.27,130.28 234.27,129.9 234.39,129.78 234.92,129.78 235.04,129.66 235.04,129.41 234.92,129.29 234.39,129.29 234.27,129.17 234.27,128.56 236.04,126.79 236.04,123.79 236.16,123.67 v1(236.67,123.67)
  BOTTOM w0.089: UG1.B23 235.72,116.9 ; UG15.F13 v1(234.27,140.4)
  BOTTOM w0.135: v1(236.67,123.67) 235.72,122.71 v2(235.72,121.44) 235.72,116.9
FBB_D31: length 32
  IN1 w0.119: v1(235.87,140.4) 236.27,140.01 236.82,140.01 237.06,139.77 237.06,134.42 236.94,134.3 236.67,134.3 236.55,134.18 236.55,133.95 236.67,133.83 236.94,133.83 237.06,133.71 237.06,133.47 236.94,133.35 236.67,133.35 236.55,133.23 236.55,132.99 236.67,132.87 236.94,132.87 237.06,132.75 237.06,132.51 236.94,132.39 236.67,132.39 236.55,132.27 236.55,132.04 236.67,131.92 236.94,131.92 237.06,131.8 237.06,131.56 236.94,131.44 236.67,131.44 236.55,131.32 236.55,131.08 236.67,130.96 236.94,130.96 237.06,130.84 237.06,130.6 236.94,130.48 236.67,130.48 236.55,130.36 236.55,130.12 236.67,130 237.39,130 237.51,129.88 237.51,122.42 236.79,121.7 v1(236.76,121.7)
  BOTTOM w0.089: UG1.D21 236.76,115.26 ; UG15.E11 v1(235.87,140.4)
  BOTTOM w0.135: 236.76,115.26 v1(236.76,121.7)
FBB_D32: length 30.2
  IN4 w0.089: v1(241.62,112.45) 242.02,112.85
  IN4 w0.119: v1(249.07,135.6) 248.69,135.98 247.3,135.98 245.51,134.19 245.51,124.75 244.8,124.05 244.8,120.4 243.62,119.22 243.24,119.22 242.02,118 242.02,112.85
  BOTTOM w0.089: v1(249.07,135.6) 249.07,134.8 UG16.E4 ; v1(241.62,112.45) 241.47,112.45 UG1.G18
FBB_D33: length 30.2
  IN4 w0.089: v1(241.62,111.65) 242.34,112.37
  IN4 w0.119: v1(249.87,134.8) 249.48,135.19 247.31,135.19 245.96,133.85 245.96,124 245.23,123.27 245.23,120.47 243.72,118.97 243.34,118.97 242.34,117.97 242.34,112.37
  BOTTOM w0.089: UG16.F4 249.47,135.2 v1(249.87,134.8) ; UG1.H18 241.47,111.65 v1(241.62,111.65)
FBB_D34: length 25.8
  IN4 w0.089: v1(248.27,134.8) 247.87,134.4 247.32,134.4 246.57,133.65 ; 242.66,113.41 v1(242.82,113.25)
  IN4 w0.119: 246.57,133.65 246.39,133.47 246.39,123.41 245.65,122.67 245.65,120.52 243.85,118.71 243.47,118.71 242.66,117.91 242.66,113.41
  BOTTOM w0.089: UG1.F17 242.67,113.25 v1(242.82,113.25) ; UG16.F2 247.87,135.2 v1(248.27,134.8)
FBB_D35: length 25.7
  IN4 w0.089: v1(242.82,112.45) 243.22,112.85 ; 247.02,133.38 247.21,133.57 247.84,133.57 v1(248.27,134)
  IN4 w0.119: 247.02,133.38 246.81,133.17 246.81,122.5 246.08,121.77 246.08,120.05 242.98,116.96 242.98,113.69 243.22,113.45 243.22,112.85
  BOTTOM w0.089: UG1.G17 242.67,112.45 v1(242.82,112.45) ; UG16.E2 247.87,134.4 v1(248.27,134)
FBB_D36: length 22
  IN4 w0.089: v1(244.02,113.25) 244.42,113.65
  IN4 w0.119: v1(248.27,130.8) 248.35,130.8 249.23,129.91 249.23,121.05 247.21,119.03 247.13,119.03 247.13,119.02 246.81,119.02 246.81,119.03 246.64,119.03 244.18,116.57 244.18,114.59 244.42,114.35 244.42,113.65
  BOTTOM w0.089: UG16.A2 247.87,131.2 v1(248.27,130.8) ; v1(244.02,113.25) 243.87,113.25 UG1.F15
FBB_D37: length 27.2
  IN4 w0.089: v1(244.02,111.65) 244.15,111.65 244.48,111.98 244.48,113.25 244.99,113.76 245.44,113.76 245.58,113.91 245.58,114.31 245.25,114.65 244.99,114.65 244.82,114.82 244.82,115.16
  IN4 w0.119: 244.82,115.16 244.82,116.38 246.83,118.4 247.47,118.4 248.93,119.86 249.24,119.86 250.08,120.7 250.08,130.09 250.25,130.26 250.25,130.96 250.03,131.18 248.69,131.18 v1(248.27,131.6)
  BOTTOM w0.089: UG1.H15 243.87,111.65 v1(244.02,111.65) ; v1(248.27,131.6) 247.87,132 UG16.B2
FBB_D38: length 22
  IN4 w0.089: v1(245.22,115.05) 245.46,115.05 245.77,115.36
  IN4 w0.119: 245.77,115.36 245.77,116.19 247.46,117.88 247.46,118 249.06,119.6 249.59,119.6 250.58,120.6 250.58,122.83 251.95,124.19 251.95,129.62 249.96,131.6 v1(249.87,131.6)
  BOTTOM w0.089: v1(249.87,131.6) 249.47,132 UG16.B4 ; UG1.D14 245.07,115.05 v1(245.22,115.05)
