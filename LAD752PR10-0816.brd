# Allegro board LAD752PR10-0816.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
+VGA_PCIE on BOTTOM (solid shape): 202.07,86.71 202.07,83.34 201.62,82.9 199.53,82.9 199.21,83.22 199.21,83.22 199.17,83.26 199.17,84.22 199.7,84.22 199.7,84.72 199.17,84.72 199.17,85.02 199.7,85.02 199.7,85.52 199.17,85.52 199.17,86.42 199.84,87.09 201.68,87.09
+VGA_PCIEP on BOTTOM (solid shape): 199.03,87.59 199.03,81 198.54,80.51 197.9,80.51 197.41,80.99 192.35,80.99 191.91,81.44 191.91,84.74 192.35,85.19 196.29,85.19 196.55,85.45 196.55,87.88 196.64,87.97 198.66,87.97
ADPIN on BOTTOM (solid shape): outline of 95 points within 76.34,32.67 86.37,47.78
AMP_ASEL on BOTTOM (solid shape): 35.37,15.34 35.89,15.34 35.96,15.28 35.96,14.77 35.89,14.7 35.64,14.7 35.51,14.58 35.51,14.13 35.38,14.01 35.13,14.01 35,14.13 35,14.58 34.83,14.75 34.44,14.75 34.42,14.77 34.42,15.28 34.48,15.34 35.37,15.34
AMP_LDO_A1.5V on BOTTOM (solid shape): 34.23,14.39 34.23,14.01 34.43,13.81 35.51,13.81 35.57,13.75 35.57,13.3 35.51,13.24 35.32,13.24 35.31,13.25 34.04,13.25 33.72,13.57 33.72,14.39 33.85,14.52 34.1,14.52
B+ on TOP (solid shape): 154.95,158.21 154.95,156.81 154.19,156.05 153.87,156.05 153.36,156.56 153.36,157.96 153.93,158.53 154.63,158.53
B+ on TOP (solid shape): 207.72,7.14 207.72,4.54 207.35,4.17 204.66,4.17 204.35,4.48 204.35,7.08 204.54,7.27 207.59,7.27
B+ on TOP (solid shape): 292.94,83.88 292.94,81.91 292.93,81.9 292.93,81.83 292.8,81.69 291.51,81.69 291.16,82.04 291.16,83.95 291.32,84.11 292.71,84.11
B+ on TOP (solid shape): 87.75,32.18 88.87,32.18 88.87,31.65 89.3,31.65 89.3,32.18 89.52,32.18 89.6,32.14 89.69,32.1 89.73,32.05 89.73,27.46 89.04,26.77 83.51,26.77 82.88,27.4 82.88,32.04 83.26,32.42 87.51,32.42
B+ on TOP (solid shape): 139.41,140.7 139.41,136.65 139.41,136.65 139.41,133.36 136.65,130.6 128.9,130.6 128.53,130.97 128.53,133.51 128.79,133.76 130.76,133.76 132.26,135.27 132.26,139.37 132.88,139.99 134.43,139.99 134.44,140 134.51,140 135.66,141.14 138.97,141.14
B+ on TOP (solid shape): 278.96,166.53 279.04,166.49 279.06,166.41 279.07,165.73 279.35,165.11 279.35,163.95 279.25,163.86 278.33,163.86 277.5,163.03 277.5,162.72 277.24,162.46 276.86,162.46 276.54,162.13 276.54,161.81 276.04,161.32 274.71,161.32 274.48,161.55 274.48,163.7 274.71,163.93 275.79,163.93 276.17,164.31 276.17,166.08 277.16,166.2 278.11,166.52 278.12,166.53
B+ on TOP (solid shape): 186.81,10.69 186.84,10.61 186.8,10.54 186.76,10 187.3,10.04 187.37,10.08 187.45,10.05 189.79,7.72 189.79,7.37 187.7,5.29 186.76,5.29 183.84,8.22 182.86,9.69 181.38,10.68 180.95,11.11 177.66,11.11 176.04,9.49 173.31,9.49 173.15,9.65 173.15,12.14 176.04,15.04 182.46,15.04
B+ on TOP (solid shape): outline of 212 points within 93.61,48.74 102.52,65.84
B+ on TOP (solid shape): outline of 510 points within 101.29,8.03 119.52,23.84
B+ on TOP (solid shape): outline of 2229 points within 249.37,5.24 272.97,33.62
B+ on BOTTOM (solid shape): 269.76,31.97 269.76,30.45 268.93,29.62 266.2,29.62 265.94,29.89 265.94,31.33 267.72,33.12 268.61,33.12
B+ on BOTTOM (solid shape): 260.09,33.25 260.09,29.62 259.96,29.5 254.77,29.5 254.39,29.88 254.39,32.42 255.6,33.62 259.71,33.62
B+ on BOTTOM (solid shape): 186.32,80.61 186.32,80.36 185.81,79.85 185.62,79.85 185.17,80.3 182.84,80.3 182.74,80.3 182.68,80.35 182.68,81.58 182.8,81.69 185.24,81.69
B+ on BOTTOM (solid shape): 118.18,123.66 119.19,122.65 119.19,121.38 119,121.19 118.62,121.19 118.62,121.76 118.12,121.76 118.12,121.19 114.29,121.19 113.65,121.83 113.65,123.9 114.24,124.49 118.18,124.49
B+ on BOTTOM (solid shape): 58.37,34.02 59.13,34.02 59.13,37.36 60.38,37.36 60.43,37.3 60.43,33.66 59.64,32.86 59.64,31.66 57.98,30 57.98,27.72 57.54,27.27 55.51,27.27 55.13,27.65 55.13,30.13 53.92,31.34 51.89,31.34 51.44,31.78 51.44,33.56 52.14,34.26 54.36,34.26 55.83,35.72 55.83,36.74 56.45,37.36 58.37,37.36
B+ on BOTTOM (solid shape): 138.82,141.64 139.33,141.13 139.33,134.53 135.32,130.53 134.25,130.53 131.64,127.92 130.06,127.92 128.91,129.06 128.91,131.23 128.91,131.23 128.91,133.13 129.67,133.89 129.79,133.89 129.93,133.88 130.07,133.89 132.09,133.89 135.33,137.13 135.33,142.84 135.52,143.03 138.82,143.03
B+ on BOTTOM (solid shape): 158.53,168.78 158.53,168.31 158.62,167.85 159.09,167.89 159.9,167.89 160.03,167.76 160.03,166.27 159.98,166.23 159.4,166.23 159.13,166.23 158.84,166.52 157.63,166.52 157.42,166.73 157.23,166.87 157.01,166.93 156.9,166.93 156.82,166.92 156.73,166.9 156.7,166.89 156.52,167.06 156.52,168.91 156.62,169.01 158.3,169.01
B+ on BOTTOM (solid shape): 198.11,71.91 198.81,71.91 198.82,71.92 199.09,71.92 199.09,71.37 199.58,71.37 199.58,71.93 200.02,71.93 200.07,71.88 200,71.65 200.09,71.42 200.09,70.44 200.03,70.39 198.88,70.39 198.36,70.68 197.79,70.49 197.79,70.5 197.76,70.5 197.44,70.91 196.93,71 196.75,71.19 196.75,72.15 197.87,72.15
B+ on BOTTOM (solid shape): 284.01,43.12 284.64,43.12 284.91,42.86 284.91,41 284.26,40.35 283.63,40.35 283.27,40 283.26,40 281.92,38.67 281.01,38.67 279.69,39.99 279.69,40.81 279.7,40.82 279.92,41.15 280.11,41.49 280.11,41.5 280.91,42.3 280.93,42.3 281.05,42.32 281.16,42.38 281.22,42.41 281.29,42.38 281.8,42.44 281.72,42.95 281.68,43.02 281.71,43.1 281.75,43.14 283.99,43.14
B+ on BOTTOM (solid shape): 103.34,65.46 103.31,65.44 103.31,60.12 99.89,56.7 99.89,54.58 96.97,51.66 96.97,50.45 96.7,50.17 96.62,50.17 96.61,50.18 96.07,50.24 95.67,49.88 94.69,49.88 94.37,50.2 94.37,52.23 95.14,53 95.31,53.11 95.48,53.22 96.1,53.75 96.62,54.39 97.31,56.11 97.25,57.97 99.95,60.66 99.95,65.69 100.29,66.03 102.76,66.03
B+ on BOTTOM (solid shape): outline of 1071 points within 102.24,9.67 185.58,27.72
B+ on IN1 (solid shape): 207.72,5.43 207.72,4.54 207.35,4.17 204.66,4.17 204.35,4.48 204.35,7.08 204.54,7.27 205.88,7.27
B+ on IN1 (solid shape): 293.27,83.69 293.27,80.82 292.99,80.54 291.33,80.54 291.18,80.69 291.18,83.77 291.27,83.86 293.1,83.86
B+ on IN1 (solid shape): 281.89,164.88 281.89,164.12 281.31,163.54 280.87,163.54 280.49,163.93 278.2,163.93 277.76,163.48 276.68,163.48 276.42,163.74 276.42,165.58 277,166.15 280.62,166.15
B+ on IN1 (solid shape): 175.65,14.89 175.65,13.81 176.18,13.28 181.8,13.28 186.44,8.65 186.62,8.65 186.68,8.59 186.68,7.44 185.81,6.57 183.61,6.57 180.52,9.67 172.9,9.67 172.68,9.89 172.68,15.03 172.79,15.15 175.4,15.15
B+ on IN1 (solid shape): 299.98,67.19 299.98,62.5 300.31,62.17 300.31,61.21 299.94,60.84 297.21,60.84 296.92,61.13 296.92,61.47 297.09,61.73 296.99,62.02 297.35,62.69 296.92,63.33 296.92,66.75 297.62,67.44 299.73,67.44
B+ on IN1 (solid shape): 118.88,12.61 118.88,10.38 117.74,9.24 115.64,9.24 113.9,10.98 117.64,10.98 117.64,10.93 117.64,10.87 117.66,10.82 117.68,10.78 117.71,10.73 117.75,10.69 117.79,10.66 117.84,10.63 117.89,10.61 117.94,10.6 117.99,10.6 118.05,10.6 118.1,10.61 118.15,10.63 118.19,10.66 118.23,10.69 118.27,10.73 118.3,10.78 118.32,10.82 118.34,10.87 118.35,10.93 118.35,10.98 118.34,11.03 118.32,11.08 118.3,11.13 118.27,11.18 118.23,11.22 118.19,11.25 118.15,11.28 118.1,11.29 118.05,11.31 117.99,11.31 117.94,11.31 117.89,11.29 117.84,11.28 117.79,11.25 117.75,11.22 117.71,11.18 117.68,11.13 117.66,11.08 117.64,11.03 117.64,10.98 113.9,10.98 112.98,11.91 112.98,12.1 114.44,13.56 117.93,13.56
B+ on IN1 (solid shape): outline of 445 points within 223.4,4.21 258.52,10.7
B+ on IN1 (solid shape): outline of 3765 points within 84.88,17.94 108.59,53.63
B+ on IN2 (solid shape): 207.72,7.14 207.72,4.54 207.35,4.17 204.66,4.17 204.35,4.48 204.35,7.08 204.54,7.27 207.59,7.27
B+ on IN2 (solid shape): 182.61,12.7 187.07,8.24 187.07,7.27 185.56,5.76 185.16,5.76 181.25,9.67 173.43,9.67 172.98,10.11 172.98,12.26 173.43,12.7 180.86,12.7
B+ on IN2 (solid shape): 158.36,167.35 158.36,167.17 156.23,165.04 156.2,165.04 155.5,164.85 155.31,164.15 155.31,164.12 155.13,163.94 155.13,163.91 155.11,163.9 154.85,163.37 155.05,162.82 155.07,162.62 155.13,162.43 155.13,157.33 154.96,157.16 153.7,157.16 153.56,157.3 153.56,164.79 156.68,167.92 157.79,167.92
B+ on IN2 (solid shape): outline of 673 points within 223.21,4.22 257.5,8.86
B+ on IN2 (solid shape): outline of 1753 points within 54.62,26.89 91.89,42.58
B+ on IN3 (solid shape): 178.13,28.54 178.13,26.64 177.87,26.38 176.86,26.38 176.54,26.7 176.54,28.48 176.73,28.67 178,28.67
B+ on IN3 (solid shape): 182.61,12.7 187.07,8.24 187.07,7.27 185.56,5.76 185.16,5.76 181.25,9.67 173.43,9.67 172.98,10.11 172.98,12.26 173.43,12.7 180.86,12.7
B+ on IN3 (solid shape): 184.2,81.62 184.2,80.47 184.09,80.36 181.26,80.36 181.16,80.46 181.16,81.56 181.3,81.69 184.13,81.69
B+ on IN3 (solid shape): 102.37,63.6 102.37,59.33 99.81,56.76 99.81,53.48 98.39,52.06 97.28,52.06 96.91,51.69 96.91,50.52 96.39,50.01 94.05,50.01 93.67,50.39 93.67,53.47 96.38,56.18 96.38,57.28 99.82,60.71 99.82,63.99 100.1,64.27 101.7,64.27
B+ on IN3 (solid shape): outline of 1114 points within 204.35,4.22 258.71,8.77
B+ on IN4 (solid shape): 207.72,7.14 207.72,4.54 207.35,4.17 204.66,4.17 204.35,4.48 204.35,7.08 204.54,7.27 207.59,7.27
B+ on IN4 (solid shape): 293.71,83.69 293.71,81.19 293.39,80.86 291.08,80.86 291.08,83.91 291.21,84.04 293.36,84.04
B+ on IN4 (solid shape): 299.98,66.58 299.98,63.6 299.54,63.15 298.08,63.15 297.63,63.6 297.63,66.77 297.82,66.96 299.6,66.96
B+ on IN4 (solid shape): 182.61,12.7 187.07,8.24 187.07,7.27 185.56,5.76 185.16,5.76 181.25,9.67 173.43,9.67 172.98,10.11 172.98,12.26 173.43,12.7 180.86,12.7
B+ on IN4 (solid shape): 281.89,164.88 281.89,164.12 281.31,163.54 280.87,163.54 280.49,163.93 278.2,163.93 277.76,163.48 276.68,163.48 276.42,163.74 276.42,165.58 277,166.15 280.62,166.15
B+ on IN4 (solid shape): outline of 635 points within 223.4,4.22 258.45,10.12
B+ on IN4 (solid shape): outline of 1744 points within 55.25,26.89 91.89,42.58
B+ on IN1: 291.51,49.37 298.61,49.37 299.55,48.43 299.55,43.39 298.84,42.68 298.84,41.97 296.64,39.77 290.17,39.77 289.3,40.63 283.54,40.63 282.85,41.32 282.85,43.1 282.87,43.12 282.87,43.93 283.79,44.85 286.99,44.85
B+ on VCC: 300.55,61.98 297.1,62 297.05,62 295.73,63.32 295.73,68.84 289.63,74.94 289.63,85.1 286.25,88.49 284.78,88.49 284.74,88.53 284.74,158.82 281.8,161.77 275.07,161.77 274.65,162.19 274.65,163.76 276.28,165.39 284.78,165.39 286.25,161.87 286.25,160.18 286.25,160.18 286.25,114.98 286.33,113.01 289.38,93.17 300.2,76.27 300.2,63.25 300.3,62.6 300.59,62.02
B+_BIAS on TOP (solid shape): 324.81,10.9 324.81,10.2 324.96,10.05 326.04,10.05 326.13,9.96 326.13,9.74 326.05,9.66 324.41,9.66 324.23,9.84 324.23,10.91 324.33,11.01 324.7,11.01
B+_BIAS on TOP (solid shape): 69.61,14 69.76,13.85 69.76,10.35 69.6,10.18 68.14,10.18 68.09,10.14 68.01,10.14 67.56,9.69 67.56,9.61 67.53,9.57 67.53,8.82 67.4,8.69 65.79,8.69 65.58,8.9 65.58,13.15 66.43,14 69.54,14
B+_BIAS on BOTTOM (solid shape): 29.47,3.27 29.47,2.92 29.25,2.7 28.77,2.7 28.46,2.38 28.46,1.98 28.03,1.56 27.25,1.56 27.12,1.68 27.12,3.02 27.5,3.4 29.35,3.4
B+_BIAS on IN2 (solid shape): 30.93,4.79 30.93,3.14 30.43,2.64 29.44,2.64 29.43,2.64 29.28,2.67 29.13,2.64 29.12,2.64 29.03,2.64 28.84,2.45 28.84,2.19 28.2,1.56 27.25,1.56 27.06,1.75 27.06,2.83 27.19,2.95 27.76,2.95 28.39,3.59 29.54,3.59 29.66,3.72 29.66,4.16 28.84,4.99 28.84,5.43 30.3,5.43
B+_BIAS on IN2 (solid shape): 67.99,8.78 67.98,8.77 67.98,8.4 67.88,8.3 66.63,8.3 66.37,8.04 66.37,7.62 66.09,7.33 65.18,7.33 64.75,7.76 64.75,8.95 64.83,9.03 65.42,8.89 65.28,9.48 65.42,9.62 67.99,9.62
B+_BIAS on IN2 (solid shape): 41.66,7.72 41.66,7.08 40.71,6.13 37.92,6.13 37.6,5.81 35.7,5.81 35.7,7.06 39.21,7.06 39.21,7 39.22,6.95 39.24,6.9 39.26,6.85 39.29,6.81 39.33,6.77 39.37,6.74 39.41,6.71 39.46,6.69 39.52,6.68 39.57,6.67 39.62,6.68 39.67,6.69 39.72,6.71 39.77,6.74 39.81,6.77 39.85,6.81 39.88,6.85 39.9,6.9 39.92,6.95 39.92,7 39.92,7.06 39.92,7.11 39.9,7.16 39.88,7.21 39.85,7.25 39.81,7.29 39.77,7.32 39.72,7.35 39.67,7.37 39.62,7.38 39.57,7.39 39.52,7.38 39.46,7.37 39.41,7.35 39.37,7.32 39.33,7.29 39.29,7.25 39.26,7.21 39.24,7.16 39.22,7.11 39.21,7.06 35.7,7.06 35.7,7.27 35.76,7.33 36.46,7.33 37.35,8.22 40.65,8.22 40.84,8.41 40.97,8.41
B+_VCCIO on BOTTOM (solid shape): 120.03,121 120.9,121 120.91,120.99 120.91,119.62 120.89,119.6 120.4,119.6 120.21,119.41 120.21,118.02 120.46,117.76 120.46,116.36 120.34,116.24 118.94,116.24 118.37,116.81 118.37,120.43 117.93,120.87 117.93,121 120.02,121
BATT+ on BOTTOM (solid shape): 87,27.08 88.65,27.08 88.78,26.96 88.78,23.21 88.34,22.77 83,22.77 81.23,20.99 78.81,20.99 78.56,21.24 78.56,23.34 78.59,23.37 79.41,23.37 79.47,23.31 79.47,21.94 79.83,21.58 80.18,21.94 80.18,23.31 81.42,24.54 81.42,27.15 81.73,27.46 86.62,27.46
BATT++ on TOP (solid shape): 85.67,20.48 85.67,19.15 85.35,18.83 82.94,18.83 82.81,18.96 82.81,20.54 83,20.73 85.42,20.73
BATT++ on BOTTOM (solid shape): 89.32,21.21 93.39,21.21 93.93,20.67 93.93,16.02 93.91,15.93 93.93,15.85 93.93,10.92 93.31,10.31 87.02,10.31 86.81,10.51 86.81,17.62 86.4,18.03 84.94,18.03 84.15,18.83 82.5,18.83 82.3,19.02 82.3,21.78 82.59,22.07 88.46,22.07
BOOT_1.2V on BOTTOM (solid shape): 90.05,44.1 91.5,44.1 91.56,44.04 91.56,43.95 91.51,43.9 90.31,43.9 89.69,43.28 89.29,43.28 89.23,43.34 89.23,44.23 89.29,44.29 89.86,44.29
BST_1.2V on BOTTOM (solid shape): 88.71,44.25 88.71,41.61 88.53,41.43 87.83,41.43 87.72,41.55 87.72,44.25 87.77,44.3 88.65,44.3
BST_3V on BOTTOM (solid shape): 56.4,45.19 57.48,45.19 57.6,45.06 57.6,44.23 57.54,44.17 56.9,44.17 55.95,45.12 55.06,45.12 54.93,45.25 54.93,45.31 55,45.38 56.2,45.38
BST_5V on BOTTOM (solid shape): 52.76,45.35 52.76,45.21 52.73,45.17 51.65,45.17 51.2,44.73 51.2,44.17 51,43.97 50.43,43.97 50.36,44.04 50.36,44.94 50.81,45.39 52.73,45.39
BST_+1VALWP on TOP (solid shape): 247.28,22.77 247.28,22.13 247.15,22.01 244.92,22.01 244.8,22.13 244.8,22.77 245,22.96 247.09,22.96
BST_VCCIO on BOTTOM (solid shape): 120.46,115.99 120.46,115.8 119.07,114.4 117.86,114.4 117.73,114.53 117.73,115.29 117.86,115.41 118.94,115.41 119.58,116.05 120.4,116.05
BTST_CHG on TOP (solid shape): 60.53,22.17 61.68,22.17 61.74,22.12 61.74,21.24 61.68,21.19 61.11,21.19 61.06,21.24 61.06,21.7 60.91,21.85 60.53,21.85 60.26,22.12 59.11,22.12 59.04,22.18 59.04,22.29 59.08,22.33 60.36,22.33
CHG_B+ on TOP (solid shape): 75,28.54 75,21.62 74.49,21.11 70.11,21.11 69.29,21.94 69.29,25.62 68.24,26.67 65,26.67 64.72,26.96 61.41,26.96 61.22,27.15 61.22,29.12 62.18,30.07 63.7,30.07 64.78,31.15 72.4,31.15
CHG_B+ on BOTTOM (solid shape): 62.81,30.07 64.84,30.07 65.16,29.75 65.16,28.1 64.33,27.27 59.25,27.27 59,27.53 59,30.07 59.76,30.83 62.05,30.83
CPU_B+ on TOP (solid shape): 157.46,149.09 157.46,148.32 157.24,147.99 157.46,147.66 157.46,147.14 156.15,145.83 155.37,145.83 155.11,146.09 155.09,146.11 151.85,146.11 151.85,146.94 151.96,147.06 152.62,147.06 152.91,147.35 152.91,148.55 153.01,148.65 153.89,148.65 153.89,148.14 154.06,147.98 155.76,147.98 155.96,148.18 156.47,148.18 156.6,148.3 156.6,148.3 156.81,148.51 156.81,149.09 156.88,149.16 157.39,149.16
CPU_B+ on TOP (solid shape): 164.6,144.82 164.6,143.42 164.52,143.42 164.36,143.25 163.84,143.25 163.81,143.25 163.64,143.07 163.64,140.86 163.46,140.68 162.99,140.68 162.82,140.85 162.82,142.55 162.53,142.84 161.82,142.84 161.75,142.85 161.68,142.84 161.17,142.84 161.1,142.85 161.03,142.84 160.52,142.84 160.45,142.85 160.38,142.84 159.87,142.84 159.8,142.85 159.74,142.84 159.42,142.84 159.39,142.87 159.39,143.52 159.09,143.82 159.04,143.88 158.98,143.93 158.92,144 158.82,144 158.74,144.07 158.74,144.57 158.87,144.7 159.62,144.7 159.73,144.81 162.99,144.81 163.13,144.94 164.48,144.94
CPU_B+ on TOP (solid shape): 148.6,148.56 148.6,146.59 147.89,145.89 146.87,145.89 146.71,146.05 145.89,146.05 145.73,146.08 145.58,146.05 145.24,146.05 145.09,146.08 144.93,146.05 144.6,146.05 144.44,146.08 144.28,146.05 143.95,146.05 143.79,146.08 143.63,146.05 143.41,146.05 143.27,146.18 143.27,146.91 143.37,147 144.37,147 144.78,147.41 144.78,148.63 144.81,148.66 145.63,148.66 145.68,148.6 145.68,148.15 145.89,147.94 147.53,147.94 147.64,148.05 147.64,148.75 147.71,148.81 148.34,148.81
CPU_B+ on TOP (solid shape): 172.92,145.32 172.92,143.23 172.04,142.35 170.61,142.35 170.42,142.54 170.25,142.75 169.98,142.78 169.53,142.78 169.43,142.79 169.33,142.78 168.88,142.78 168.78,142.79 168.68,142.78 168.24,142.78 168.14,142.79 168.04,142.78 167.85,142.78 167.77,142.86 167.77,143.78 168.28,144.14 168.26,144.76 168.3,144.8 171.76,144.8 172.03,145.06 172.03,145.38 172.09,145.45 172.79,145.45
CPU_B+ on TOP (solid shape): outline of 277 points within 176.17,138.77 188.18,146.4
CPU_B+ on BOTTOM (solid shape): 186.25,142.66 186.25,141.64 186.06,141.45 183.96,141.45 183.96,142.66 184.6,142.66 184.79,142.85 186.06,142.85
CPU_B+ on BOTTOM (solid shape): 164.72,145.15 164.72,143.35 164.42,143.05 159.94,143.05 159.88,143.12 159.88,144.26 161.28,144.26 161.41,144.39 161.41,145.28 161.66,145.53 164.34,145.53
CPU_B+ on BOTTOM (solid shape): 173.11,145.26 173.11,143.35 172.76,143 168.28,143 168.21,143.07 168.21,144.21 169.61,144.21 169.74,144.34 169.74,145.23 169.99,145.48 172.89,145.48
CPU_B+ on BOTTOM (solid shape): 180.22,145.26 180.22,144.81 180.73,144.3 180.73,142.72 180.54,142.53 179.78,142.53 179.27,143.03 176.62,143.03 176.56,143.09 176.56,144.24 177.95,144.24 178.08,144.36 178.08,145.25 178.33,145.51 179.97,145.51
CPU_B+ on BOTTOM (solid shape): 139.45,146.41 139.45,144.56 139.77,144.24 140.09,144.24 140.47,143.86 140.47,141.83 140.03,141.38 139.58,141.38 139.01,141.95 139.01,143.1 138.57,143.54 135.9,143.54 135.2,144.24 135.2,146.34 135.21,146.34 135.21,146.58 135.44,146.82 139.05,146.82
CPU_B+ on BOTTOM (solid shape): outline of 82 points within 142.12,146.29 157.62,157.13
CPU_B+ on IN2 (solid shape): outline of 2183 points within 147.14,139.29 186.51,149.7
CPU_B+ on IN3 (solid shape): outline of 4629 points within 137.42,137.19 186.19,150.46
CPU_B+ on IN4 (solid shape): outline of 5390 points within 137.42,137.19 186.19,156.31
DGPU_PWR_EN# on BOTTOM (solid shape): 209.3,91.06 209.3,90.36 209.24,90.11 209.35,89.87 209.56,89.66 209.84,89.66 210,89.5 210.51,89.5 210.57,89.44 210.57,87.73 210.51,87.66 208.99,87.66 208.61,88.04 208.61,89.19 207.78,90.01 207.78,90.02 207.65,90.15 207.65,91.01 207.95,91.31 209.05,91.31
DH_1.2V on TOP (solid shape): 90.28,38.88 90.28,38.04 90.04,37.81 89.67,37.81 89.07,38.41 89.07,39.34 89.15,39.42 89.74,39.42
DH_1.2V on BOTTOM (solid shape): 91.56,43.65 91.56,43.55 91.51,43.5 90.73,43.5 90.5,43.26 90.5,43.09 90.14,42.73 89.96,42.73 89.95,42.72 89.81,42.72 89.7,42.83 89.7,43.1 89.81,43.2 89.98,43.2 90.12,43.35 90.12,43.52 90.31,43.71 91.5,43.71
DH_1.2V on IN4 (solid shape): 90.56,43.58 90.56,43.32 89.99,42.75 87.96,42.75 88.91,43.71 90.43,43.71
DH_1.2V on IN4 (solid shape): 88.78,40.04 89.61,39.21 89.61,38.39 89.48,38.26 89.23,38.26 89.04,38.45 89.04,38.7 87.77,39.97 87.77,40.42 87.83,40.48 88.78,40.48
DH_CHG on TOP (solid shape): 75.13,20.48 75.13,19.27 74.81,18.96 73.29,18.96 73.1,19.15 73.1,20.42 73.35,20.67 74.94,20.67
DH_CHG on TOP (solid shape): 62.18,22.77 62.3,22.77 62.37,22.7 62.37,22.45 62.23,22.31 60.59,22.31 60.38,22.52 59.08,22.52 59.03,22.57 59.03,22.69 59.08,22.74 60.57,22.74 60.61,22.78 62.16,22.78
DH_CHG on IN1 (solid shape): 62.81,22.19 62.81,21.75 62.49,21.43 61.92,21.43 61.22,22.13 61.22,22.61 61.42,22.8 62.2,22.8
DH_CHG on IN1 (solid shape): 75.07,20.42 75.07,19.4 74.94,19.27 72.97,19.27 72.72,19.53 72.72,20.16 73.1,20.54 74.94,20.54
DL_1.2V on TOP (solid shape): 95.89,35.85 95.89,33.75 95.77,33.62 95.45,33.62 95.32,33.75 95.32,34.77 95.45,34.89 95.45,35.85 95.51,35.91 95.83,35.91
DL_1.2V on BOTTOM (solid shape): 91.98,42.82 91.98,42.05 91.92,41.99 91.55,41.99 91.17,41.61 90.92,41.61 90.74,41.79 90.74,42.09 90.89,42.24 91.54,42.89 91.91,42.89
DL_1.2V on IN4 (solid shape): 96.47,35.66 96.47,34 96.08,33.62 95.51,33.62 95.39,33.75 95.39,35.08 95.07,35.4 95.07,35.78 95.51,36.23 95.89,36.23
DL_1.2V on IN4 (solid shape): 91.7,42.51 91.7,42.2 91.19,41.69 91.19,41.37 91.39,41.18 91.7,41.18 91.7,41.05 91.83,40.93 91.83,40.35 91.77,40.29 91.07,40.29 90.56,40.8 90.56,41.97 91.23,42.64 91.58,42.64
DL_CHG on TOP (solid shape): 65.35,21.75 65.35,20.86 65.22,20.73 64.4,20.73 64.21,20.92 64.21,21.5 64.59,21.88 65.22,21.88
DL_CHG on TOP (solid shape): 61.08,20.62 61.08,20.39 60.99,20.3 60.67,20.3 60.16,20.81 60.16,21.04 59.87,21.33 59.07,21.33 59.03,21.37 59.03,21.49 59.08,21.55 60.15,21.55
DL_CHG on IN4 (solid shape): 65.35,21.18 65.35,20.67 64.97,20.29 64.46,20.29 64.02,19.84 63.32,20.54 63.32,20.67 64.02,21.37 65.16,21.37
DL_CHG on IN4 (solid shape): 60.65,21.05 61.09,21.05 61.1,21.05 61.28,21.05 61.98,20.35 62.17,20.35 62.18,20.35 62.37,20.16 62.37,19.34 62.17,19.34 61.41,19.34 61.1,19.65 61.1,19.97 60.78,20.29 60.59,20.29 60.53,20.34 60.52,20.34 60.14,20.73 60.14,20.99 60.33,21.18 60.52,21.18
ECAGND on TOP (solid shape): 295.04,9.6 295.04,9.42 294.89,9.27 294.89,7.35 294.82,7.28 294.68,7.28 294.61,7.36 294.61,9.15 294.47,9.29 294.47,9.62 294.56,9.71 294.93,9.71
EN_+1.8VGS on BOTTOM (solid shape): 233.43,40.58 233.43,39.96 232.86,39.39 232.86,39.05 232.73,38.92 231.63,38.92 231.49,39.05 231.49,39.59 231.28,39.8 230.86,39.8 230.82,39.85 230.82,40.59 230.91,40.68 233.32,40.68
EN_TPLED on TOP (solid shape): 193.56,20.41 193.54,20.37 193.48,20.18 193.55,19.98 193.58,19.92 193.55,19.85 193.62,19.38 194.08,19.5 194.09,19.53 194.57,19.53 194.7,19.4 194.7,18.83 194.51,18.63 193.62,18.63 193.35,18.37 193.35,18.12 193.33,18.05 193.32,17.98 193.32,17.96 192.67,17.3 192.67,16.06 192.57,15.96 192.13,15.96 192.03,16.06 192.03,17.43 192.73,18.13 192.73,20.35 192.74,20.36 192.86,20.4 192.95,20.48 193.49,20.48
FB_+1.8VGS on BOTTOM (solid shape): 237.24,40.71 237.24,38.96 237.17,38.9 235.01,38.9 234.96,38.94 234.96,40.65 235.07,40.76 237.19,40.76
GPU_B+ on TOP (solid shape): outline of 1572 points within 221.56,36.12 275.92,53.18
GPU_B+ on BOTTOM (solid shape): 236.17,53.18 236.17,52.74 236.29,52.61 237.69,52.61 238.04,52.26 238.04,50.49 237.88,50.32 234.45,50.32 234.32,50.45 234.32,50.96 234.07,51.21 233.5,51.21 233.43,51.28 233.43,51.91 233.69,52.17 233.69,53.31 233.74,53.36 235.99,53.36
GPU_B+ on BOTTOM (solid shape): 244.74,53.18 244.74,52.74 244.86,52.61 246.26,52.61 246.59,52.28 246.59,50.46 246.45,50.32 243.02,50.32 242.9,50.45 242.9,50.96 242.64,51.21 242.07,51.21 242.01,51.28 242.01,51.91 242.26,52.17 242.26,53.31 242.32,53.37 244.55,53.37
GPU_B+ on BOTTOM (solid shape): 253.31,53.18 253.31,52.73 253.43,52.6 255.16,52.6 255.47,52.29 255.47,50.64 255.15,50.32 251.59,50.32 251.46,50.45 251.46,50.95 251.21,51.21 250.59,51.21 250.55,51.24 250.55,51.88 250.83,52.16 250.83,53.3 250.89,53.37 253.11,53.37
GPU_B+ on BOTTOM (solid shape): 227.47,54.18 227.47,53.73 227.6,53.61 228.86,53.61 229.38,53.09 229.38,51.51 228.89,51.02 228.89,50.46 228.8,50.37 225.83,50.37 225.68,50.53 225.68,51.37 225.63,51.41 225.63,51.95 225.38,52.21 224.81,52.21 224.74,52.27 224.74,52.91 225,53.16 225,54.3 225.06,54.37 227.28,54.37
GPU_B+ on BOTTOM (solid shape): 273.38,52.15 273.38,51.71 273.49,51.59 274.84,51.59 275.22,51.98 276.68,51.98 277,51.66 277.69,51.66 277.82,51.53 277.82,50.26 277.63,50.07 275.36,50.07 274.59,49.29 270.53,49.29 270.14,49.69 270.14,50.77 270.2,50.83 270.52,50.83 270.9,51.21 270.9,52.28 270.96,52.34 273.19,52.34
GPU_B+ on BOTTOM (solid shape): 267.92,40.35 267.92,38.48 267.89,38.41 267.81,38.38 267.46,38.09 267.67,37.69 267.73,37.63 267.72,37.55 267.64,37.03 267.92,36.59 267.92,33.56 263.96,29.6 261.67,29.6 261.25,30.02 261.25,33.31 257.88,36.67 257.88,39.78 258.14,40.04 260.93,40.04 262.01,41.12 267.15,41.12
HP2_D_L_C on TOP (solid shape): 27.38,27.07 27.38,25.43 27.25,25.31 26.68,25.31 26.55,25.43 26.55,26.37 25.8,27.12 25.22,27.12 25.07,27.28 25.07,27.82 25.1,27.86 26.59,27.86
HP2_D_L_C on BOTTOM (solid shape): 27.44,26.32 27.44,24.8 26.87,24.23 23.44,24.23 21.85,22.64 21.85,20.91 21.74,20.8 19.57,20.8 19.44,20.92 19.44,22.86 20.92,24.34 21.77,24.34 22.81,25.37 25.92,25.37 26.36,25.81 26.36,26.19 26.62,26.45 27.31,26.45
HP2_D_R_C on TOP (solid shape): 25.84,24.53 26.05,24.53 26.17,24.42 26.17,23.4 25.98,23.21 25.02,23.21 24.88,23.35 24.88,23.8 25.07,24 25.07,24.5 25.11,24.54 25.84,24.54
HP2_D_R_C on BOTTOM (solid shape): 26.62,23.53 26.62,20.99 26.3,20.67 24.33,20.67 24.08,20.92 24.08,23.46 24.39,23.78 26.36,23.78
HP2_D_R_R on TOP (solid shape): 23.9,26.31 23.9,25.47 23.86,25.43 22.98,25.43 22.49,25.93 22.49,26.41 22.51,26.43 22.93,26.43 22.98,26.49 23.72,26.49
ISENSEP_L_R on TOP (solid shape): 38.87,3.53 38.87,2.51 38.86,2.51 38.74,2.39 38.74,2.39 38.55,2.2 37.85,2.2 37.16,2.89 36.97,2.89 36.84,3.02 36.83,3.02 36.83,3.53 36.9,3.6 37.66,3.6 37.79,3.72 38.68,3.72
ISENSEP_L_R on TOP (solid shape): 34.22,17.08 34.22,16.88 34.09,16.75 33.92,16.75 33.71,16.53 33.71,16.06 33.66,16.01 33.11,16.01 33.07,16.06 33.07,16.64 33.2,16.77 33.2,17.09 33.34,17.23 34.06,17.23
ISENSEP_L_R on BOTTOM (solid shape): 38.98,2.67 38.98,1.48 38.87,1.38 37.6,1.38 37.47,1.5 37.47,2.73 37.6,2.85 38.79,2.85
ISENSEP_L_R on IN1 (solid shape): 34.19,17.13 34.19,15.95 33.94,15.69 33.35,15.69 33.12,15.92 33.12,17.11 33.29,17.28 34.04,17.28
ISENSEP_L_R on IN1 (solid shape): 38.43,3.34 38.55,3.34 38.55,3.33 38.8,3.09 38.8,2.58 38.42,2.2 37.79,2.2 37.54,2.45 37.53,2.45 36.9,3.08 36.9,4.04 37.73,4.04
ISENSEP_R_R on TOP (solid shape): 29.26,16.61 29.26,16.26 29.22,16.22 29.22,15.68 29.02,15.48 28.54,15.48 28.39,15.63 28.39,16.04 28.26,16.17 28.26,16.55 28.39,16.68 29.19,16.68
ISENSEP_R_R on TOP (solid shape): 33.22,2.27 33.22,1.24 33.16,1.18 31.57,1.18 31.5,1.24 31.5,1.56 31.63,1.68 32.71,1.68 32.71,2 32.64,2.08 32.16,2.08 32.14,2.09 32.14,2.57 32.15,2.59 32.9,2.59
ISENSEP_R_R on BOTTOM (solid shape): 32.83,4.08 32.83,1.45 32.55,1.18 31.63,1.18 31.44,1.37 31.44,1.87 32.01,2.45 32.01,4.11 32.08,4.17 32.74,4.17
ISENSEP_R_R on IN1 (solid shape): 29.3,16.62 29.3,15.39 29.1,15.19 28.48,15.19 28.24,15.42 28.24,16.69 28.3,16.75 29.18,16.75
ISENSEP_R_R on IN1 (solid shape): 33.03,1.49 32.71,1.17 31.57,1.17 31.44,1.3 31.44,1.68 32.01,2.25 32.01,2.64 33.03,2.64
LG_3V on TOP (solid shape): 47.06,31.97 47.06,31.27 46.36,30.58 46.11,30.58 45.92,30.77 45.92,31.59 46.43,32.1 46.94,32.1
LG_3V on BOTTOM (solid shape): 55.89,43.53 55.89,43.22 55.76,43.09 55.19,43.09 54.55,43.73 54.55,44.49 54.68,44.61 54.81,44.61
LG_3V on IN3 (solid shape): 48.27,30.96 47.82,30.51 46.24,30.51 45.86,30.89 45.86,31.53 46.05,31.72 48.27,31.72
LG_3V on IN3 (solid shape): 55.89,43.53 55.89,42.96 56.84,42.01 56.84,41.44 56.59,41.19 56.27,41.19 55,42.46 55,43.34 54.81,43.53 54.81,43.92 54.93,44.04 55.38,44.04
LG_5V on TOP (solid shape): 48.65,36.16 48.65,35.53 48.46,35.34 46.94,35.34 46.81,35.47 46.81,35.72 46.94,35.85 47.57,35.85 47.7,35.97 47.7,36.23 47.76,36.29 48.52,36.29
LG_5V on BOTTOM (solid shape): 53.16,44.49 53.16,43.73 52.97,43.53 52.97,43.09 52.78,42.9 52.46,42.9 52.33,43.03 52.33,43.98 52.9,44.55 53.09,44.55
LG_5V on IN3 (solid shape): 48.65,36.99 48.65,35.53 48.46,35.34 48.08,35.34 47.63,35.78 47.63,37.05 48.59,37.05
LG_5V on IN3 (solid shape): 53.03,43.92 53.03,41.95 52.65,41.57 52.14,41.57 51.95,41.76 51.95,42.96 52.27,43.28 52.27,43.85 52.46,44.04 52.9,44.04
LG_+1VALWP on TOP (solid shape): 254.82,22.27 254.82,21.09 254.77,21.04 253.69,21.04 253.69,22.19 253.82,22.32 254.78,22.32
LG_+1VALWP on TOP (solid shape): 250.45,23.72 250.45,22.26 250.2,22.01 249,22.01 248.93,22.07 248.93,22.83 249.25,23.15 249.75,23.66 249.75,23.78 249.88,23.91 250.26,23.91
LG_+1VALWP on IN4 (solid shape): 254.82,22.5 254.82,21.27 254.68,21.13 252.97,21.13 252.87,21.23 252.87,22.4 253.03,22.55 254.77,22.55
LG_+1VALWP on IN4 (solid shape): 250.56,23.71 251.52,23.71 251.61,23.62 251.61,22.72 251.53,22.64 250.07,22.64 249.73,22.98 249.73,23.68 249.93,23.88 250.39,23.88
LINE1_L on BOTTOM (solid shape): 26.25,30.37 27.13,30.37 27.18,30.42 29.09,30.42 29.12,30.38 29.12,30.22 29.09,30.18 27.63,30.18 27.54,30.2 27.46,30.18 27.28,30.18 27.17,30.07 26.13,30.07 25.98,29.91 25.98,29.5 25.72,29.24 23.63,29.24 23.06,28.67 23.06,27.53 22.11,26.58 19.19,26.58 19.06,26.7 19.06,29.05 19.19,29.18 21.92,29.18 23.17,30.44 26.19,30.44
LINE1_R on BOTTOM (solid shape): 29.12,29.95 29.12,29.85 29.06,29.79 27.41,29.79 27.02,29.4 27.02,27.02 26.77,26.77 24.14,26.77 24.08,26.83 24.08,28.99 24.14,29.05 25.85,29.05 26.11,29.31 26.11,29.81 26.22,29.93 26.31,29.93 26.75,29.93 26.76,29.94 27.26,29.94 27.33,30.02 29.06,30.02
LX_3V on TOP (solid shape): 50.05,29.37 52.08,29.37 52.21,29.24 52.21,26.96 49.79,24.54 44.01,24.54 43.32,25.24 43.32,27.34 43.51,27.53 45.22,27.53 46.43,28.73 46.43,30.32 46.68,30.58 48.84,30.58
LX_3V on BOTTOM (solid shape): 51.82,30.07 51.82,25.75 50.55,24.48 44.59,24.48 44.27,24.8 44.27,27.78 46.87,30.39 51.51,30.39
LX_3V on BOTTOM (solid shape): 57.86,45.5 57.79,45.43 57.42,45.43 57.41,45.44 56.4,45.44 56.27,45.57 55,45.57 54.93,45.63 54.93,45.76 55,45.82 56.01,45.82 56.25,46.06 57.86,46.06
LX_3V on IN4 (solid shape): 57.98,44.93 57.98,44.68 57.86,44.55 56.71,44.55 56.01,45.25 56.01,45.88 56.14,46.01 56.9,46.01
LX_3V on IN4 (solid shape): 51.37,26.73 51.37,26.68 50.41,25.71 49.62,25.71 49.54,25.72 49.46,25.71 48.99,25.71 48.9,25.72 48.82,25.71 48.48,25.71 48.36,25.84 48.36,25.86 48.37,25.94 48.36,26.02 48.36,26.39 48.63,26.65 49.84,26.65 50.62,27.43 50.67,27.43
LX_5V on TOP (solid shape): 43.65,37.36 45.89,37.36 46.05,37.2 46.05,35.91 46.3,35.66 46.3,33.46 46.21,33.37 41.22,33.37 40.04,34.55 40.04,36.48 40.01,36.51 40.01,37.62 40.33,37.94 43.06,37.94
LX_5V on BOTTOM (solid shape): 47.13,35.4 47.13,32.29 46.94,32.1 42.55,32.1 39.7,34.96 39.7,37.24 40.3,37.85 44.68,37.85
LX_5V on BOTTOM (solid shape): 51.66,45.8 52.74,45.8 52.78,45.76 52.78,45.63 52.71,45.57 50.67,45.57 50.43,45.33 49.96,45.33 49.88,45.4 49.88,45.96 49.94,46.02 51.43,46.02
LX_5V on IN4 (solid shape): 51.63,45.82 51.63,45.38 50.93,44.68 50.3,44.68 50.11,44.87 50.11,45.5 50.62,46.01 51.44,46.01
LX_5V on IN4 (solid shape): 44.4,38.13 44.4,37.43 43.82,36.86 43.32,36.86 43.19,36.99 43.19,37.24 42.93,37.5 42.93,38.13 43.51,38.7 43.82,38.7
LX_+1.8VGS on BOTTOM (solid shape): 232.79,38.13 232.79,37.48 232.7,37.39 231.65,37.39 231.45,37.2 231.45,36.65 231.26,36.46 230.37,36.46 230.04,36.13 230.04,35.22 229.96,35.14 229.18,35.14 229.12,35.2 229.12,37.64 229.72,38.23 232.69,38.23
LX_+VGA_PCIE on BOTTOM (solid shape): 198.06,79.1 198.52,79.1 198.87,78.75 198.87,78.25 198.71,78.09 198.36,78.09 198.03,77.75 198.03,76.82 197.85,76.64 197.3,76.64 197.18,76.76 197.18,77.63 197.05,77.76 196.08,77.76 195.62,78.22 193.92,78.22 193.71,78.42 195.87,78.42 195.87,78.36 195.88,78.31 195.89,78.26 195.92,78.21 195.95,78.17 195.98,78.13 196.02,78.1 196.07,78.07 196.12,78.05 196.17,78.04 196.22,78.03 196.28,78.04 196.33,78.05 196.38,78.07 196.42,78.1 196.47,78.13 196.5,78.17 196.53,78.21 196.56,78.26 196.57,78.31 196.58,78.36 196.58,78.42 196.57,78.47 196.56,78.52 196.53,78.57 196.5,78.61 196.47,78.65 196.42,78.69 196.38,78.71 196.33,78.73 196.28,78.74 196.22,78.75 196.17,78.74 196.12,78.73 196.07,78.71 196.02,78.69 195.98,78.65 195.95,78.61 195.92,78.57 195.89,78.52 195.88,78.47 195.87,78.42 193.71,78.42 193.45,78.68 193.45,80.65 193.48,80.68 196.48,80.68
LX_CHG on TOP (solid shape): 62.05,23.78 62.05,23.02 61.98,22.96 60.44,22.96 60.4,22.92 59.08,22.92 59.04,22.96 59.04,23.08 59.11,23.15 59.95,23.15 60.97,24.16 61.67,24.16
LX_CHG on TOP (solid shape): 68.97,24.04 68.97,21.81 69.35,21.43 69.35,20.99 69.6,20.73 71.95,20.73 72.53,20.16 72.53,19.08 72.34,18.89 68.4,18.89 68.21,18.7 66.24,18.7 65.67,19.27 65.67,24.16 65.92,24.42 68.59,24.42
LX_CHG on BOTTOM (solid shape): outline of 87 points within 63.51,19.24 70.56,25.84
LX_CHG on IN1 (solid shape): 61.86,23.95 62.11,23.95 62.11,23.08 61.98,22.96 60.91,22.96 60.58,23.28 60.58,23.68 61.06,24.16 61.64,24.16
LX_CHG on IN1 (solid shape): 66.81,21.88 66.81,20.73 66.62,20.54 65.79,20.54 65.67,20.67 65.67,21.56 65.22,22 65.22,22.07 65.79,22.64 66.05,22.64
LX_VCCIO on BOTTOM (solid shape): 121.23,115.67 121.23,112.54 121.55,112.22 127.46,112.22 127.59,112.09 127.59,110.28 127.41,110.1 122.01,110.1 121.09,109.18 120.4,109.18 120.02,109.56 120.02,114.02 120.46,114.46 120.46,115.54 120.66,115.73 121.16,115.73
Net_141 on TOP (solid shape): 119.69,18.83 111.69,18.83 111.69,26.83 119.69,26.83
Net_142 on TOP (solid shape): 149.08,26.78 141.08,26.78 141.08,34.78 149.08,34.78
Net_143 on TOP (solid shape): 159.68,12.89 144.68,12.89 144.68,22.89 159.68,22.89
OUT_A on TOP (solid shape): 36.36,6.67 36.36,5.86 36.7,5.52 37,5.52 37.12,5.4 37.13,5.4 37.66,4.87 37.66,3.91 37.59,3.85 36.9,3.85 36.83,3.91 36.83,4.63 36.8,4.66 36.8,4.75 36.75,5.06 36.48,5.21 36.36,5.34 36.28,5.48 36.14,5.57 36.14,6.67 36.19,6.72 36.31,6.72
OUT_A on BOTTOM (solid shape): 40.08,6 40.08,5.87 39.38,5.18 38.92,5.18 38.71,4.97 38.71,4.97 38.55,4.81 38.55,4.48 38.43,4.35 37.46,4.35 36.76,5.05 36.72,5.1 36.67,5.15 36.67,5.38 36.79,5.5 37.24,5.5 37.27,5.56 37.42,5.62 37.54,5.52 37.56,5.47 37.79,5.24 38.12,5.24 38.12,5.24 38.42,5.24 38.49,5.24 38.87,5.62 38.87,6.13 39.32,6.57 39.51,6.57
OUT_B on TOP (solid shape): 35.16,6.65 35.16,5.75 35.66,5.25 35.76,4.99 36.03,4.88 36.11,4.8 36.24,4.58 36.5,4.5 36.52,4.48 36.52,3.08 36.52,3.08 36.52,2.51 36.58,2.45 36.58,2.25 36.39,2.06 36.2,2.06 35.94,2.32 35.94,3.47 35.5,3.91 35.5,4.8 35.27,5.03 35.27,5.21 34.95,5.53 34.95,6.65 35,6.7 35.11,6.7
OUT_C on TOP (solid shape): 33.15,6.66 33.15,5.65 32.66,5.17 32.66,4.79 32.77,4.68 32.77,3.61 32.91,3.47 33.66,3.47 33.82,3.32 33.82,2.67 33.78,2.64 33.28,2.64 33.09,2.83 32.14,2.83 32.05,2.91 32.05,4.95 32.15,5.04 32.15,5.45 32.28,5.58 32.69,5.58 32.95,5.84 32.95,6.66 33,6.72 33.1,6.72
OUT_D on TOP (solid shape): 28.08,7.46 28.08,6.57 27.89,6.38 26.81,6.38 26.68,6.51 26.68,7.4 26.81,7.53 28.01,7.53
OUT_D on TOP (solid shape): 31.96,6.68 31.96,5.75 32.02,5.69 32.02,5.13 31.88,4.99 31.88,3.2 31.7,3.02 30.81,3.02 30.74,3.09 30.74,4.79 30.81,4.86 30.98,4.86 31.75,5.63 31.75,6.68 31.79,6.72 31.92,6.72
OUT_D on IN1 (solid shape): outline of 245 points within 26.42,2.83 31.89,7.53
P1 on TOP (solid shape): 70.4,39.02 70.4,36.12 70.14,35.86 69.48,35.86 68.91,35.28 68.91,34.65 68.77,34.51 66.68,34.51 66.43,34.77 66.43,37.81 66.75,38.13 67.56,38.13 68.61,39.18 70.25,39.18
P1 on BOTTOM (solid shape): 68.94,38.66 69.01,38.66 69.11,38.56 69.11,38.32 69.05,38.25 69,38.17 68.97,38.01 69,37.84 69,37.67 69.43,37.24 70.37,37.24 70.49,37.12 70.49,34.13 70.18,33.81 68.73,33.81 68.23,34.31 68.13,34.48 67.96,34.58 67.63,34.91 66.82,34.91 66.56,35.17 66.56,38.11 66.57,38.11 66.57,38.5 66.74,38.67 68.93,38.67
P1 on IN1 (solid shape): 70.94,38.39 70.94,34.83 69.86,33.75 67.51,33.75 67.06,34.2 67.06,38.51 67.7,39.15 70.18,39.15
P1 on IN3 (solid shape): 70.94,38.39 70.94,34.83 69.86,33.75 67.51,33.75 67.06,34.2 67.06,38.51 67.7,39.15 70.18,39.15
P2 on TOP (solid shape): outline of 89 points within 58.62,34.39 65.67,41.88
P2 on BOTTOM (solid shape): 62.96,43.31 62.91,43.26 62.89,43.26 62.75,43.25 62.62,43.18 62.56,43.16 62.49,43.18 62.23,43.26 61.99,43.13 61.91,43.09 61.83,43.13 61.59,43.26 61.33,43.18 61.26,43.16 60.97,43.26 60.68,43.16 60.61,43.18 60.03,42.91 60.61,42.63 60.68,42.66 60.97,42.55 61.26,42.66 61.33,42.63 61.59,42.55 61.83,42.68 61.91,42.72 61.99,42.68 62.23,42.55 62.49,42.63 62.56,42.66 62.85,42.55 63.14,42.66 63.21,42.63 63.43,42.55 63.65,42.63 64.14,42.13 64.14,39.72 65.65,38.21 65.88,38.21 66.04,38.05 66.04,34.04 65.82,33.81 61.16,33.81 60.97,34 60.97,38.01 60.37,38.61 59.13,38.61 59.13,41.94 58.36,41.94 58.36,38.61 57.13,38.61 56.78,38.96 56.78,43.09 57.1,43.4 62.87,43.4
PQ703_S on TOP (solid shape): 82.24,32.04 82.24,29.12 82.05,28.92 80.91,28.92 80.65,29.18 78.62,29.18 78.56,29.24 78.56,29.69 78.3,29.94 77.22,29.94 76.72,30.45 76.72,32.1 77.16,32.54 81.73,32.54
PQ703_S on BOTTOM (solid shape): 80.97,31.34 80.97,24.67 80.97,24.67 80.97,24.51 80.77,24.32 80.18,24.32 80.18,25.7 79.83,26.06 79.47,25.7 79.47,24.32 78.66,24.32 78.3,24.65 77.95,24.32 77.7,24.32 77.22,23.84 77.22,22.32 76.46,21.56 72.91,21.56 72.34,22.13 72.34,29.31 73.03,30 75.76,30 76.34,30.58 76.34,31.66 76.84,32.16 80.15,32.16
PWR_VGA_CORE_BOOT1 on TOP (solid shape): 276.93,156.43 276.93,155.42 276.61,155.1 276.61,154.21 276.42,154.02 275.85,154.02 275.73,154.15 275.73,154.91 276.68,155.86 276.68,156.43 276.74,156.5 276.87,156.5
PWR_VGA_CORE_BOOT1_1 on TOP (solid shape): 273.82,156.12 273.82,155.29 274.14,154.97 275.03,154.97 275.15,154.85 275.15,154.15 274.96,153.96 273.88,153.96 272.87,154.97 272.87,156.18 273,156.31 273.63,156.31
PWR_VGA_CORE_BOOT2 on TOP (solid shape): 276.69,160.01 276.69,159.8 276.94,159.56 276.94,158.79 276.85,158.7 276.77,158.7 276.65,158.83 276.65,159.27 276.11,159.81 276.11,160.12 276.22,160.23 276.48,160.23
PWR_VGA_CORE_BOOT2_1 on BOTTOM (solid shape): 276.87,162.78 276.87,161.89 276.81,161.83 274.87,161.83 274.81,161.89 274.81,162.75 274.96,162.91 276.74,162.91
PWR_VGA_CORE_LGATE1 on TOP (solid shape): 266.2,157.39 266.2,156.75 266.14,156.69 265.57,156.69 265.38,156.5 265.38,155.54 265.12,155.29 264.61,155.29 264.36,155.54 264.36,157.19 264.61,157.45 266.14,157.45
PWR_VGA_CORE_LGATE1 on TOP (solid shape): 276.52,157.25 276.52,157.21 276.44,157.13 275.67,157.13 275.05,156.51 273.68,156.51 273.57,156.62 273.57,157.19 273.63,157.26 274.78,157.26 274.84,157.2 275.35,157.2 275.49,157.33 276.44,157.33
PWR_VGA_CORE_LGATE1 on IN4 (solid shape): 274.71,157.19 275.28,157.19 275.47,157 275.47,156.62 275.34,156.5 273.95,156.5 273.31,157.13 273.95,157.77 274.14,157.77
PWR_VGA_CORE_LGATE1 on IN4 (solid shape): 265.31,157.51 265.31,155.29 265.18,155.16 264.36,155.16 264.17,155.35 264.17,157.26 264.61,157.7 265.12,157.7
PWR_VGA_CORE_LGATE2 on TOP (solid shape): 265.5,166.28 265.5,164.43 265.31,164.24 264.61,164.24 264.42,164.43 264.42,166.34 264.49,166.4 265.38,166.4
PWR_VGA_CORE_LGATE2 on TOP (solid shape): 275.15,158.91 275.15,158.59 275.62,158.12 276.47,158.12 276.53,158.06 276.53,157.97 276.48,157.92 275.3,157.92 275.22,157.93 275.13,157.92 275.09,157.92 273.88,159.13 273.88,159.42 274.07,159.61 274.46,159.61
PWR_VGA_CORE_LGATE2 on IN4 (solid shape): 274.46,160.12 274.46,159.67 275.09,159.04 275.09,158.78 274.9,158.59 274.52,158.59 273.31,159.8 274.01,160.5 274.07,160.5
PWR_VGA_CORE_LGATE2 on IN4 (solid shape): 266.65,165.58 266.65,164.75 266.52,164.62 266.26,164.62 265.95,164.31 264.93,164.31 264.87,164.37 264.87,165.32 264.99,165.45 265.57,165.45 265.76,165.64 266.58,165.64
PWR_VGA_CORE_PHASE1 on TOP (solid shape): 276.53,156.87 276.53,156.76 276.1,156.33 276.1,155.63 275.73,155.26 275.04,155.26 275.03,155.26 274.39,155.26 274.32,155.34 274.32,156.23 274.38,156.29 275.09,156.29 275.73,156.93 276.46,156.93
PWR_VGA_CORE_PHASE1 on TOP (solid shape): 269.38,160.94 269.38,156.56 269.57,156.37 269.57,155.29 269.31,155.04 265.86,155.04 265.67,155.23 265.67,156.22 265.76,156.31 266.14,156.31 266.45,156.62 266.45,161 266.52,161.07 269.25,161.07
PWR_VGA_CORE_PHASE1 on BOTTOM (solid shape): 272.96,162.24 272.96,161 272.64,160.69 271.09,160.69 270.58,160.18 270.58,159.17 270.59,159.16 270.59,157.55 270.41,157.37 270.01,157.37 269.5,156.87 269.5,155.35 269.25,155.1 268.58,155.1 268.49,155 265.79,155 265.69,155.1 265.69,156.62 267.47,158.4 267.47,160.81 267.92,161.26 270.27,161.26 271.33,162.31 272.88,162.31
PWR_VGA_CORE_PHASE1 on IN4 (solid shape): 276.04,156.24 276.04,155.23 275.66,154.85 274.07,154.85 274.07,155.86 275.03,155.86 275.54,156.37 275.92,156.37
PWR_VGA_CORE_PHASE1 on IN4 (solid shape): 269.88,156.94 269.87,156.92 269.26,156.92 268.65,156.31 267.82,156.31 267.63,156.5 267.63,157.32 268.26,157.96 269.88,157.96
PWR_VGA_CORE_PHASE2 on TOP (solid shape): 271.06,172.56 271.06,170.51 270.84,170.29 268.33,170.01 268.33,165.83 268.19,165.7 266.14,165.7 265.92,165.91 265.92,170.01 267.19,171.28 267.19,172.56 267.42,172.8 270.83,172.8
PWR_VGA_CORE_PHASE2 on TOP (solid shape): 275.57,160.33 275.65,160.3 275.74,160.29 275.95,160.08 275.95,158.87 276.3,158.52 276.48,158.52 276.54,158.46 276.54,158.37 276.48,158.31 275.69,158.31 275.41,158.59 275.41,158.97 274.71,159.67 274.71,160.05 274.72,160.06 274.72,160.24 274.81,160.33
PWR_VGA_CORE_PHASE2 on BOTTOM (solid shape): 275.98,161.07 275.98,159.95 275.88,159.85 274.84,159.85 274.65,160.04 274.65,161 274.9,161.26 275.79,161.26
PWR_VGA_CORE_PHASE2 on BOTTOM (solid shape): 270.84,172.6 270.84,165.27 270.68,165.1 267.56,165.1 267.38,165.28 267.38,172.59 267.56,172.78 270.67,172.78
PWR_VGA_CORE_PHASE2 on IN4 (solid shape): 271.08,172.59 271.08,170 270.53,169.45 267.55,169.45 267.34,169.65 267.34,172.5 267.62,172.77 270.91,172.77
PWR_VGA_CORE_PHASE2 on IN4 (solid shape): 275.79,161 275.79,160.37 275.98,160.18 275.98,159.8 275.85,159.67 275.03,159.67 274.84,159.86 274.84,160.5 274.39,160.94 275.03,161.58 275.22,161.58
PWR_VGA_CORE_UGATE1 on TOP (solid shape): 277.35,156.33 277.35,154.29 277.15,154.09 276.94,154.09 276.78,154.26 276.78,154.94 277.13,155.3 277.13,156.31 277.19,156.37 277.31,156.37
PWR_VGA_CORE_UGATE1 on TOP (solid shape): 271.98,157.32 271.98,156.12 271.73,155.86 270.07,155.86 269.88,156.05 269.88,156.62 269.95,156.69 270.9,156.69 271.15,156.94 271.15,157.32 271.28,157.45 271.85,157.45
PWR_VGA_CORE_UGATE1 on IN4 (solid shape): 277.5,155.1 277.5,154.15 276.74,153.38 275.73,153.38 275.6,153.51 275.6,154.34 275.66,154.4 276.04,154.4 276.87,155.23 277.38,155.23
PWR_VGA_CORE_UGATE1 on IN4 (solid shape): 271.85,155.99 271.85,155.61 271.22,154.97 271.03,154.97 270.65,155.35 270.65,155.61 270.46,155.8 270.01,155.8 269.82,155.99 269.82,156.43 270.07,156.69 271.15,156.69
PWR_VGA_CORE_UGATE2 on TOP (solid shape): 271.47,165.96 271.47,164.81 271.34,164.69 271.09,164.69 270.84,164.94 270.84,165.26 270.58,165.51 270.07,165.51 270.01,165.58 270.01,166.28 270.14,166.4 271.03,166.4
PWR_VGA_CORE_UGATE2 on TOP (solid shape): 277.23,161.21 277.23,159.84 277.34,159.73 277.34,158.75 277.3,158.71 277.19,158.71 277.13,158.77 277.13,159.6 276.85,159.87 276.85,160.19 276.55,160.49 276.24,160.49 276.04,160.69 276.04,161 276.36,161.32 277.12,161.32
PWR_VGA_CORE_UGATE2 on IN4 (solid shape): 272.36,165.26 272.36,164.43 271.6,164.43 270.96,165.07 270.96,166.02 271.09,166.15 271.47,166.15
PWR_VGA_CORE_UGATE2 on IN4 (solid shape): 277.31,162.08 277.31,160.94 277,160.62 276.23,160.62 276.04,160.81 276.04,161.83 275.73,162.15 275.73,162.53 275.85,162.66 276.74,162.66
RING2 on TOP (solid shape): 28.92,22.23 28.92,20.86 29.05,20.73 29.54,20.73 29.68,20.59 29.68,19.99 29.54,19.84 28.25,19.84 28.18,19.91 28.18,21.41 28.18,21.43 28.01,21.6 28.01,22.26 28.07,22.31 28.84,22.31
RING2 on BOTTOM (solid shape): 26.74,31.07 26.75,31 26.79,30.92 27.02,30.76 27.29,30.81 27.5,30.81 27.69,30.75 27.89,30.81 29.06,30.81 29.12,30.75 29.12,30.65 29.04,30.56 27.26,30.56 27.25,30.55 27.13,30.55 27.08,30.5 26.32,30.5 25.91,30.91 25.91,31.16 26.08,31.34 26.47,31.34
RING2 on IN1 (solid shape): 28.33,21.11 28.33,20.93 28.52,20.73 29.28,20.73 29.41,20.61 29.41,20.03 29.22,19.84 27.63,19.84 27.31,20.16 27.31,21.3 28.14,21.3
RING2 on IN1 (solid shape): 26.85,30.84 26.85,30.24 26.58,29.98 24.59,29.98 24.4,30.16 24.4,31.3 24.55,31.45 24.62,31.45 24.67,31.46 26.22,31.46
RING2_R on TOP (solid shape): 28.06,21.36 28.06,19.42 28.33,19.15 28.33,17.56 28.01,17.24 27.31,17.24 27.16,17.4 27.16,17.74 27.16,17.81 27.16,17.88 27.16,18.67 26.9,18.92 26.9,21.2 27.11,21.41 28.01,21.41
RING2_R on TOP (solid shape): 22.17,19.98 22.17,19.7 21.12,18.65 20.06,18.65 20.06,18.64 19.67,18.64 19.29,18.26 18.22,18.26 18.13,18.35 18.13,18.76 18.09,18.8 18.09,19.4 18.22,19.53 19.56,19.53 19.72,19.69 20.61,19.69 21.01,20.09 22.07,20.09
RING2_R on BOTTOM (solid shape): 29.1,18 29.1,17.44 28.9,17.24 27.31,17.24 27.12,17.43 27.12,17.62 27.25,17.75 27.5,17.75 27.89,18.13 28.96,18.13
RING2_R on IN1 (solid shape): 19.32,18.55 19.32,17.95 18.58,17.2 18.31,17.2 17.93,17.58 17.93,18.09 18.12,18.28 18.12,18.57 18.31,18.76 19.11,18.76
RING2_R on IN1 (solid shape): 22.32,21.15 22.32,20.24 22.13,20.05 22.13,19.62 21.76,19.25 21.05,19.25 20.86,19.44 20.86,20.8 21.33,21.27 22.21,21.27
RING2_R on IN1 (solid shape): 28.34,18.41 28.34,17.67 27.8,17.13 27.25,17.13 26.92,17.46 26.92,17.47 27.16,17.81 26.92,18.15 26.92,18.28 27.58,18.94 27.81,18.94
RJ45_CT on BOTTOM (solid shape): 255.99,162.48 255.99,161.3 255.45,160.76 253.67,160.76 253.56,160.87 253.56,162.38 253.69,162.5 255.96,162.5
SLEEVE on BOTTOM (solid shape): 29.64,21.87 29.64,20.9 29.28,20.54 28.14,20.54 27.12,19.53 26.74,19.53 26.42,19.21 26.42,18.45 25.92,18.45 25.92,19.21 26.04,19.34 26.04,19.97 26.17,20.1 26.68,20.1 27.06,20.48 27.06,21.09 27.37,21.39 28.24,21.39 28.96,22.11 29.4,22.11
SLEEVE on IN1 (solid shape): 29.05,31.56 29.05,30.21 28.92,30.07 27.17,30.07 26.99,30.25 26.99,30.88 26.85,31.02 26.85,31.58 26.99,31.72 28.89,31.72
SLEEVE on IN1 (solid shape): 31.41,22.25 31.41,21.53 31.12,21.24 29.92,21.24 29.57,20.89 29.06,20.89 28.84,21.11 28.84,22.29 29.03,22.48 31.18,22.48
SLEEVE_R on TOP (solid shape): 21.14,18.23 21.14,17.02 20.81,16.7 19.76,16.7 19.29,16.22 17.14,16.22 17,16.36 17,17.3 17.2,17.51 17.48,17.51 17.71,17.38 17.95,17.51 19.21,17.51 20.09,18.38 20.99,18.38
SLEEVE_R on BOTTOM (solid shape): 28.27,19.86 28.46,19.81 28.64,19.87 28.89,19.87 29.09,19.81 29.29,19.87 29.45,19.87 29.54,19.78 29.54,19.25 29.37,19.08 27.57,19.08 27.31,18.83 27.31,18.51 27.19,18.38 26.68,18.38 26.62,18.45 26.62,19.15 26.74,19.27 27.06,19.27 27.65,19.87 28.26,19.87
SLEEVE_R on IN3 (solid shape): 17.65,17.33 17.65,15.79 17.23,15.37 16.34,15.37 16.18,15.54 16.18,17.19 16.42,17.43 17.55,17.43
SLEEVE_R on IN3 (solid shape): 20.96,19.67 21,19.56 21.08,19.47 21.08,17.95 20.91,17.79 20.09,17.79 19.78,18.09 19.78,19.34 20.14,19.69 20.94,19.69
SLEEVE_R on IN3 (solid shape): 28.15,19.98 28.36,19.82 28.63,19.86 28.91,19.86 29.09,19.81 29.28,19.86 29.3,19.86 29.47,19.68 29.47,19.04 29.28,18.85 27.42,18.85 27.17,19.09 27.17,19.54 27.62,19.98
SNB_VCCIO on BOTTOM (solid shape): 119.17,111.3 119.17,107.9 119,107.72 117.75,107.72 117.55,107.93 117.55,111.17 117.75,111.37 119.1,111.37
SNUB_CHG on TOP (solid shape): 64.04,21.31 64.04,20.71 64.27,20.48 65.22,20.48 65.35,20.35 65.35,18.96 65.16,18.76 64.27,18.76 63.45,19.59 63.45,21.3 63.51,21.37 63.99,21.37
SPK_L+_CONN on TOP (solid shape): 30.67,17.12 30.67,16.8 30.61,16.74 30.34,16.74 30.21,16.61 30.21,16.08 30.12,16 29.54,16 29.47,16.06 29.47,16.54 29.47,16.54 29.47,16.98 29.59,17.11 29.59,17.12 29.66,17.18 30.61,17.18
SPK_L+_CONN on TOP (solid shape): 48.71,12.99 48.71,12.41 48.59,12.29 48.18,12.29 47.94,12.05 47.59,12.05 47.5,12.04 47.41,12.01 44.54,12.01 44.33,12.22 44.33,13.05 44.54,13.25 48.44,13.25
SPK_L+_CONN on BOTTOM (solid shape): 48.78,14.83 48.78,12.42 48.31,11.95 47.88,11.95 47.57,12.26 47.57,12.8 48.01,13.24 48.01,14.76 48.14,14.89 48.72,14.89
SPK_L+_CONN on BOTTOM (solid shape): 36.07,5.46 36.16,5.46 36.67,4.95 36.67,4.62 36.58,4.54 36.27,4.54 36.19,4.46 36.19,2.83 36.12,2.76 35.66,2.76 35.53,2.89 35.53,5.11 35.89,5.46 36.07,5.46
SPK_L+_CONN on IN1 (solid shape): 45.67,13.05 45.67,12.41 45.41,12.16 43.82,12.16 43.63,11.97 43.38,11.97 43.06,12.29 43.06,12.8 43.57,13.3 45.41,13.3
SPK_L+_CONN on IN1 (solid shape): 36.73,6.09 36.73,6.06 36.71,6.04 36.69,6.02 36.71,6 36.71,5.68 36.65,5.62 36.54,5.62 36.41,5.49 36.41,5.24 36.59,5.06 36.65,4.99 36.71,4.94 36.71,4.53 36.66,4.47 35.81,4.47 35.42,4.86 35.42,6.21 35.81,6.59 36.23,6.59
SPK_L+_CONN on IN3 (solid shape): 30.81,17.07 30.81,16.6 31.06,16.35 31.06,15.59 30.81,15.34 30.11,15.34 29.57,15.88 29.57,17.11 29.77,17.32 30.55,17.32
SPK_L+_CONN on IN3 (solid shape): 37.28,6.7 37.28,6.06 37.03,5.81 36.71,5.81 36.46,5.56 36.46,5.11 36.71,4.86 36.71,4.6 36.52,4.41 35.63,4.41 35.44,4.6 35.44,6.06 36.27,6.89 37.09,6.89
SPK_L-_CONN on TOP (solid shape): 32.93,17.06 32.93,16.88 32.77,16.72 32.77,16.05 32.73,16.01 32.1,16.01 32.06,16.05 32.06,16.75 31.93,16.88 31.93,17.07 32.08,17.22 32.77,17.22
SPK_L-_CONN on TOP (solid shape): 46.24,11.1 47.28,11.1 47.48,10.9 48.56,10.9 48.75,10.71 48.75,10.02 48.62,9.89 46.03,9.89 45.28,10.64 44.71,10.64 44.65,10.7 44.65,11.59 44.71,11.65 45.68,11.65
SPK_L-_CONN on BOTTOM (solid shape): 39.75,3.98 39.75,3.14 39.56,2.95 39.19,2.95 39.06,3.08 37.41,3.08 37.35,3.14 37.35,3.97 37.48,4.1 38.42,4.1 38.42,4.1 39.63,4.1
SPK_L-_CONN on BOTTOM (solid shape): 50.05,14.57 50.05,10.78 49.19,9.92 47.65,9.92 47.51,10.07 47.51,10.93 47.63,11.06 48.7,11.06 49.13,11.48 49.13,13.05 49.28,13.21 49.28,14.57 49.35,14.64 49.98,14.64
SPK_L-_CONN on IN1 (solid shape): 39.58,5.36 39.58,3.2 39.32,2.95 39.07,2.95 39,3.02 39,3.33 38.37,3.96 38.37,5.05 38.74,5.42 39.51,5.42
SPK_L-_CONN on IN1 (solid shape): 45.87,11.53 45.87,10.4 45.72,10.25 43.64,10.25 43.51,10.38 43.51,11.08 44.05,11.62 45.78,11.62
SPK_L-_CONN on IN3 (solid shape): 32.96,17.12 32.96,15.28 32.77,15.09 32.07,15.09 31.88,15.28 31.88,16.54 31.95,16.61 31.95,17.12 32.08,17.25 32.83,17.25
SPK_L-_CONN on IN3 (solid shape): 39.59,4.59 39.59,3.06 39.44,2.92 38.97,2.92 38.24,3.65 38.24,4.79 38.36,4.92 39.25,4.92
SPK_R+_CONN on TOP (solid shape): 27.5,11.6 27.94,11.6 28.07,11.47 28.07,10.96 28.01,10.9 26.87,10.9 26.74,11.03 26.74,11.91 26.81,11.97 27.12,11.97
SPK_R+_CONN on TOP (solid shape): 48.75,9.06 48.75,8.34 48.61,8.21 47.51,8.21 47.28,7.98 45.69,7.98 45.19,7.48 44.75,7.48 44.34,7.89 44.34,8.15 45.38,9.19 48.62,9.19
SPK_R+_CONN on TOP (solid shape): 30.55,4.79 30.55,3.21 30.23,2.89 27,2.89 26.74,3.14 26.74,4.03 26.87,4.16 27.95,4.16 28.01,4.1 28.01,3.81 28.2,3.62 29.38,3.62 29.85,4.1 29.85,4.73 29.98,4.86 30.49,4.86
SPK_R+_CONN on BOTTOM (solid shape): 51.32,13.08 51.48,12.92 51.48,9.98 49.82,8.33 47.76,8.33 47.57,8.52 47.57,9.35 47.7,9.47 49.4,9.47 50.55,10.63 50.55,14.7 51.32,14.7
SPK_R+_CONN on IN3 (solid shape): 28.2,4.54 28.2,4.29 28.01,4.1 28.01,3.59 27.82,3.4 26.87,3.4 26.74,3.52 26.74,4.22 27.63,5.11
SPK_R+_CONN on IN3 (solid shape): 27.63,11.53 28.26,11.53 28.51,11.28 28.51,10.39 28.39,10.26 27.76,10.26 27.51,10.51 27.5,10.51 27.5,10.64 27.38,10.76 26.93,10.76 26.74,10.95 26.74,11.91 26.81,11.97 27.19,11.97
SPK_R+_CONN on IN4 (solid shape): 45.79,8.54 45.79,7.84 45.49,7.54 43.62,7.54 43.57,7.59 43.57,8.48 43.71,8.62 45.72,8.62
SPK_R+_CONN on IN4 (solid shape): 28.14,4.48 28.14,4.29 27.94,4.09 27.94,3.68 27.72,3.46 26.87,3.46 26.8,3.53 26.81,3.67 26.81,4.35 27.44,4.99 27.63,4.99
