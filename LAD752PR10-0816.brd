# Allegro board LAD752PR10-0816.brd (continued)
## Nets (continued)
TMDS_R_TXCN: JHDMI.12 LV3.3 RV500.1 RV641.2
TMDS_R_TXCP: JHDMI.10 LV3.2 RV500.2 RV640.2
TMDS_TX0N: CV1060.2 UG1.BB38
TMDS_TX0P: CV1059.2 UG1.BC38
TMDS_TX1N: CV1062.2 UG1.AY38
TMDS_TX1P: CV1061.2 UG1.AY39
TMDS_TX2N: CV1064.2 UG1.BC39
TMDS_TX2P: CV1063.2 UG1.BB39
TMDS_TXCN: CV1057.2 UG1.BC36
TMDS_TXCP: CV1058.2 UG1.BB36
TOBII_INT: JTOBII.6 RE300.1 RE651.2
TOBII_PWR_EN#: CE79.1 RE652.2 UE6.17 UE12.4
TON_1.2V: PR206.2 PU201.9
TP_CLK: JTP.12 RE100.2 UE5.87
TP_DATA: JTP.13 RE101.2 UE5.88
TP_LED_B#: Q28.5 R146.2 UE3.14
TP_LED_B#_DRV: Q28.2 Q28.3 R144.2
TP_LED_B#_DRV#: JTP.3 Q28.6
TP_LED_EN: Q2410.2 UE5.25
TP_LED_G#: Q29.5 R154.2 UE3.11
TP_LED_G#_DRV: Q29.2 Q29.3 R150.2
TP_LED_G#_DRV#: JTP.4 Q29.6
TP_LED_R#: Q34.5 R147.2 UE3.10
TP_LED_R#_DRV: Q34.2 Q34.3 R145.2
TP_LED_R#_DRV#: JTP.5 Q34.6
TRIP_+1VALWP: PR303.2 PU300.2
TRONL_LED_B_DRV#: JTRONL.5 JTRONL.10 UE8.5
TRONL_LED_G_DRV#: JTRONL.4 JTRONL.9 UE8.4
TRONL_LED_R_DRV#: JTRONL.3 JTRONL.8 UE8.3
TRONR_LED_B_DRV#: JTRONR.5 JTRONR.10 UE8.9
TRONR_LED_G_DRV#: JTRONR.4 JTRONR.9 UE8.8
TRONR_LED_R_DRV#: JTRONR.3 JTRONR.8 UE8.6
TS_EN: JEDP.34 UE6.14
TYPEC_DET#: QU1.1 RU26.2 UE10.18
UART_2_CCTS_DRTS: RC65.1 UH1.AN44
UART_2_CRXD_DTXD: JWDB.3 RC62.1 UH1.AR45
UART_2_CTXD_DRXD: JWDB.2 RC63.1 UH1.AR39
UG_3V: PQ100.4 PU100.10
UG_5V: PQ102.4 PU100.16
UG_+1VALWP: PQ300.4 PU300.9
USB2_COMP: RH109.1 UH1.AG3
USB3_A_TRX_DTX_N0: DT5.1 JUSBC1.B10 UT1.A21
USB3_A_TRX_DTX_N1: DT9.1 JUSBC1.A10 UT1.B15
USB3_A_TRX_DTX_P0: DT4.1 JUSBC1.B11 UT1.B21
USB3_A_TRX_DTX_P1: DT8.1 JUSBC1.A11 UT1.A15
USB3_A_TTX_C_DRX_N0: CT42.1 DT3.1 JUSBC1.A3
USB3_A_TTX_C_DRX_N1: CT40.1 DT7.1 JUSBC1.B3
USB3_A_TTX_C_DRX_P0: CT41.1 DT2.1 JUSBC1.A2
USB3_A_TTX_C_DRX_P1: CT39.1 DT6.1 JUSBC1.B2
USB3_A_TTX_DRX_N0: CT42.2 UT1.B19
USB3_A_TTX_DRX_N1: CT40.2 UT1.B17
USB3_A_TTX_DRX_P0: CT41.2 UT1.A19
USB3_A_TTX_DRX_P1: CT39.2 UT1.A17
USB3_CC1: DU20.2 JUSBC2.A5 UU7.11
USB3_CC2: DU20.3 JUSBC2.B5 UU7.13
USB3_CRX_L_DTX_N1: DU2.1 DU2.9 JUSB1.5 LU5.2
USB3_CRX_L_DTX_N2: DU12.4 DU12.7 JUSBC2.B10 LU8.2
USB3_CRX_L_DTX_N5: DU13.1 DU13.9 JUSBC2.A10 LU11.3
USB3_CRX_L_DTX_P1: DU2.2 DU2.8 JUSB1.6 LU5.3
USB3_CRX_L_DTX_P2: DU12.5 DU12.6 JUSBC2.B11 LU8.3
USB3_CRX_L_DTX_P5: DU13.2 DU13.8 JUSBC2.A11 LU11.2
USB3_CTX_C_DRX_N1: CU13.1 LU4.1
USB3_CTX_C_DRX_N2: CU30.1 LU7.1
USB3_CTX_C_DRX_N5: CU38.1 LU10.4
USB3_CTX_C_DRX_P1: CU12.1 LU4.4
USB3_CTX_C_DRX_P2: CU31.1 LU7.4
USB3_CTX_C_DRX_P5: CU39.1 LU10.1
USB3_CTX_C_L_DRX_N1: DU2.4 DU2.7 JUSB1.8 LU4.2
USB3_CTX_C_L_DRX_N2: DU12.1 DU12.9 JUSBC2.A3 LU7.2
USB3_CTX_C_L_DRX_N5: DU13.4 DU13.7 JUSBC2.B3 LU10.3
USB3_CTX_C_L_DRX_P1: DU2.5 DU2.6 JUSB1.9 LU4.3
USB3_CTX_C_L_DRX_P2: DU12.2 DU12.8 JUSBC2.A2 LU7.3
USB3_CTX_C_L_DRX_P5: DU13.5 DU13.6 JUSBC2.B2 LU10.2
USB3_RUF1: DU21.2 JUSBC2.A8
USB3_RUF2: DU21.3 JUSBC2.B8
USB3RN1: LU5.1 UH1.B7
USB3RN2: LU8.1 UH1.C8
USB3RN3: CI38.1 UH1.B10
USB3RN3_C: CI38.2 JCDRA.36
USB3RN4: JIO.26 UH1.E11
USB3RN5: LU11.4 UH1.G13
USB3RP1: LU5.4 UH1.A7
USB3RP2: LU8.4 UH1.B8
USB3RP3: CI39.1 UH1.A9
USB3RP3_C: CI39.2 JCDRA.37
USB3RP4: JIO.27 UH1.G11
USB3RP5: LU11.1 UH1.H13
USB3TN1: CU13.2 UH1.C11
USB3TN2: CU30.2 UH1.B12
USB3TN3: JCDRA.42 UH1.C13
USB3TN4: JIO.29 UH1.A14
USB3TN5: CU38.2 UH1.B14
USB3TP1: CU12.2 UH1.B11
USB3TP2: CU31.2 UH1.A12
USB3TP3: JCDRA.43 UH1.D13
USB3TP4: JIO.30 UH1.B13
USB3TP5: CU39.2 UH1.C14
USB20_CAM_N7_R: DV4.3 JEDP.19 LV2.2
USB20_CAM_P7_R: DV4.2 JEDP.20 LV2.3
USB20_N1: UH1.AF5 UU1.2
USB20_N1_CONN: DU1.2 JUSB1.2 LU3.2
USB20_N2: JIO.23 UH1.AD5
USB20_N3: LM1.1 UH1.AG8
USB20_N3_CONN: JCDRA.40 LM1.2
USB20_N4: UE1.5 UH1.AE1
USB20_N5: JWLAN.5 UH1.AC2
USB20_N6: DV2.3 JEDP.17 UH1.AF2
USB20_N7: LV2.1 UH1.AB3
USB20_N8: LU9.4 UH1.AL8
USB20_N8_CONN: DU11.3 JUSBC2.A7 JUSBC2.B7 LU9.3
USB20_N9: LE3.1 RE647.1 UH1.AA1
USB20_N9_L: DV14.2 JTOBII.3 LE3.2 RE647.2
USB20_P1: UH1.AG7 UU1.3
USB20_P1_CONN: DU1.3 JUSB1.3 LU3.3
USB20_P2: JIO.24 UH1.AD7
USB20_P3: LM1.4 UH1.AG10
USB20_P3_CONN: JCDRA.39 LM1.3
USB20_P4: UE1.4 UH1.AE2
USB20_P5: JWLAN.3 UH1.AC3
USB20_P6: DV2.2 JEDP.18 UH1.AF3
USB20_P7: LV2.4 UH1.AB2
USB20_P8: LU9.1 UH1.AL7
USB20_P8_CONN: DU11.2 JUSBC2.A6 JUSBC2.B6 LU9.2
USB20_P9: LE3.4 RE648.1 UH1.AA2
USB20_P9_L: DV14.3 JTOBII.4 LE3.3 RE648.2
USB_OC0#: RPH6.4 UH1.AD43 UU1.13
USB_OC1#: CU17.1 RPH6.3 UH1.AD42 UU3.3
USB_OC2#: RPH6.1 UH1.AD39
USB_OC3#: RPH6.2 UH1.AC44
USB_PWR_EN: CU16.1 RE645.2 UE5.117 UU3.4
USBC_PWR_EN: CU35.1 RE649.2 UE10.5 UU7.6
USBCHG_DET#: CU27.2 CU28.1 DU6.2 JUSB1.10 RU4.2
USBCHG_DET_D: PD100.3 RU6.1 UU5.4
USBCHG_DET_EC#: CU29.1 DU6.1 RU6.2 UE5.75
VCIN0_PH1: PH1.1 PR24.1 PR25.1 UE5.109
VCIN1_AC_IN: CE40.2 DH1.1 PR714.2 PR715.1 PR731.1 PU700.5 QE3.5 UE5.110 UG4.1
VCIN1_ADP_PROCHOT: PC13.2 PR23.1 PR26.2 UE5.102
VCIN_ BATT_TEMP: CE35.2 PC14.1 PD3.2 PR16.1 PR22.2 PR727.1 UE5.63
VCOUT0_MAIN_PWR_ON#: PR114.1 UE5.104
VCOUT1_PROCHOT#: RE84.2 RE85.2 UE5.103
VD33STB: RA25.2 UA1.10
VGA_EN: RM14.2 RM87.1 UM8.26
VGA_SMB_CK3: QG1.4 RG42.2 UG1.AM34 UG3.8
VGA_SMB_DA3: QG1.1 RG41.2 UG1.AM33 UG3.7
VL: PC111.1 PU100.13
VR_HOT#: PC501.1 PR504.2 RE78.1
VR_PWRGD: PR520.1 UE5.101
VR_SVID_ALERT#: PR509.2 RH152.2 RH153.1
VR_SVID_CLK: CPU1.BH32 PR507.2
VR_SVID_DATA: CPU1.BH29 PR511.2 RH151.2
VRAM_0: RG160.1 RG161.2 UG1.AV19
VRAM_1: RG162.1 RG163.2 UG1.AW19
VRAM_2: RG164.1 RG165.2 UG1.AR20
VROM_SEL: RH588.2 RH589.2 UH1.BC27
VSB_N_001: PC10.2 PQ3.3 PR12.2 PR13.2
VSB_N_002: PC12.1 PQ4.2 PR17.1
VSB_N_003: PQ4.1 PR13.1
VSENSEN_L: RA61.2 RA79.1 UA4.27
VSENSEN_R: RA65.2 RA82.1 UA4.30
VTTREF_1.2V: PC210.1 PU201.4
WAKE#: RH4.2 RH453.1 UH1.BC13
WAKE_PCH#: RH545.1 UH1.BD11
WL_OFF#: RH520.2 RN15.2 UH1.AU44
WL_OFF#_R: CN9.1 JWLAN.48 RN5.2 RN15.1
WOOFER_SEL: JIO.21 UE10.7
XCLK_BIASREF: RH71.2 UH1.E1
XDP_BPM#0: CPU1.BR27 T112.1(TP-1)
XDP_BPM#1: CPU1.BT27 T113.1(TP-1)
XDP_HOOK0: JPCMC.27 RC355.1
XDP_ITP_PMODE: JPCMC.26 RC353.2 UH1.AT2
XDP_PRDY#: CPU1.BP27 JPCMC.34 UH1.AT4
XDP_PREQ#: CPU1.BL30 JPCMC.33 RH156.2 UH1.AT3
XDP_SPI_IO2: JPCMC.24 RC354.1
XDP_SPI_SI: JPCMC.25 RC9.2 RH1.1
XDP_TCK: JPCMC.31 RC348.1 UH1.AN3
XDP_TDI: CPU1.BL32 JPCMC.29 RH495.2 UH1.AP2
XDP_TDO: CPU1.BT28 JPCMC.35 RH496.2 UH1.AP1
XDP_TMS: CPU1.BP28 JPCMC.30 RH494.2 UH1.AR2
XMP1: PR212.1 UH1.BD22
XMP2: PR214.1 UH1.BE21
XTAL24_IN: CH47.1 RH72.1 UH1.A6 YH2.1
XTAL24_OUT: CH48.1 RH72.2 UH1.A5 YH2.3
XTAL_OUT: UG1.AY42
XTALIN: UG1.BA43 YG1.3
XTLI: CL8.2 UL1.8 YL1.1
XTLO: CL9.2 UL1.7 YL1.3
N4123408: PC105.2 PR108.1
N4123550: PC109.1 PR110.2
N4123582: PC110.1 PR111.2
N4124695: PC106.1 PR109.2
N16767833: PC112.1 PR100.2 PR112.2 PR113.2 PR114.2 PR115.2 PR116.1
N16767857: PD101.1 PR115.1
N16768121: PD100.1 PR113.1
N16788038: PC701.2 PC722.2 PC723.2 PQ700.1 PQ702.4 PQ708.4 PR705.1 PR725.2 PR726.2
N16788064: PQ700.2 PR700.2 PR701.1
N16857461: DS1.1 QS3.1
N17244731: PD1.2 PL2.1 PQ7.1 PR6.2
N17431129: CE36.1 RE89.1
N17434554: RE74.2 UE5.107
N17761544: PR205.1 PR207.1 PR213.1 PR215.1 PU201.6
N17847188: PC800.2 PJP800.2 PU800.2 PU800.3 PU800.4 PU800.5
N17847698: PC803.1 PU800.16 PU800.17
N17848703: PC808.1 PR806.2
N17848716: PR806.1 PU800.1
N18168284: PC207.2 PR204.2 PU201.12
N18249914: CH3.1 RH6.2 UH1.V28
N18250394: CH4.1 RH7.2 UH1.BA15
N18456729: PR722.1 PU700.20
N18456733: PR723.1 PU700.19
N18456739: PQ705.3 PR709.1 PR711.1 PU700.21
N18456772: PC711.2 PR707.2 PU700.28
N18456789: PD700.1 PR707.1
N18456799: PR724.2 PU700.10
N18456859: PC702.2 PR708.1
N18456884: PC718.2 PR717.2 PU700.7
N18456888: PC720.2 PU700.8
N18456944: PQ705.1 PR710.2
N18456952: PR720.2 PU700.11
N18456954: PR721.2 PU700.12
N18468008: RH9.1 RH656.2 RH657.2 UH1.BD7
N18650921: RV634.2 UV21.59
N18651247: RV635.2 UV21.58
N18786622: CPU1.BT2 T44.1(TP-1)
N18786625: CPU1.BR1 T43.1(TP-1)
N18786626: CPU1.E3 T41.1(TP-1)
N18786627: CPU1.BJ33 T82.1(TP-1)
N18786629: CPU1.B2 T85.1(TP-1)
N18786630: CPU1.BR2 T88.1(TP-1)
N18786631: CPU1.BJ34 T81.1(TP-1)
N18786633: CPU1.C1 T89.1(TP-1)
N18786635: CPU1.BJ16 T73.1(TP-1)
N18786636: CPU1.BK16 T74.1(TP-1)
N18786637: CPU1.BK24 T75.1(TP-1)
N18786638: CPU1.BJ24 T76.1(TP-1)
N18786639: CPU1.BM33 T66.1(TP-1)
N18786640: CPU1.BJ14 T68.1(TP-1)
N18786641: CPU1.BJ13 T69.1(TP-1)
N18786642: CPU1.BL33 T67.1(TP-1)
N18786644: CPU1.J23 RH192.2
N18786646: CPU1.H23 RH167.2
N19064079: PR1300.2 PU1300.1
N19066382: PC1305.2 PR1304.2 PR1305.1 PU1300.7
N19499560: CA51.2 UA2.B3
N19499567: RA46.2 UA2.A1
N19499569: RA47.2 UA2.A3
N19500898: RA39.2 UA3.A3
N19500900: RA38.2 UA3.A1
N19500925: CA44.2 UA3.B3
N19501351: CA18.1 RA10.2
N19501355: CA11.1 RA2.2
N19501476: CA21.1 UA1.27
N19501478: CA21.2 UA1.28
N19501482: CA20.1 UA1.25
N19501484: CA20.2 UA1.26
N19501519: CA23.1 CA85.1 UA1.18
N19501610: RA18.2 UA1.16
N19501675: CA3.1 CA4.1 RA68.1 UA1.46
N19501723: CA7.1 CA8.1 RA69.1 UA1.51
N19501777: CA26.1 CA27.1 UA1.43
N19501783: CA33.1 UA1.41
N19501785: CA30.1 CA31.1 UA1.21
N19501806: CA32.1 UA1.44
N19501856: CA25.1 UA1.29
N19501872: CA24.1 UA1.31
N19501885: CA19.2 UA1.23
N19501890: CA19.1 RA15.2 RA16.1
N19529476: CA74.1 UA4.23
N19529515: CA66.2 UA4.40
N19529521: CA71.2 RA51.2 UA4.3
N19529522: RA51.1 RA52.1 UA4.6
N19529526: CA67.2 UA4.2
N19529527: CA68.2 UA4.50
N19529528: CA69.2 UA4.49
N19529529: CA70.2 UA4.41
N19529531: RA62.2 UA4.5
N19942790: CU27.1 DU8.2 RU5.2 UU5.2
N19950372: RU3.2 UU1.16
N19950378: RU2.2 UU1.15
N19950402: RU7.2 UU1.8
N19950406: RU1.2 UU1.4
N20474318: CA90.2 RA76.1
N20474320: CA89.2 RA75.1
N20474322: CA88.2 RA74.1
N20474324: CA87.2 RA73.1
N20758419: RH580.1 UH1.AD10
N20758429: RH581.1 UH1.AG2
N20762834: RH89.2 UH1.BC17
N20904379: RT22.1 UT4.A6 UT4.A7 UT4.A8 UT4.B7
N20905578: CT104.1 UT4.H7
N20905857: RT83.2 UT4.F1
N20960158: QE53.5 RE527.1 RE528.2
N20960615: QE54.2 RE449.2 RE511.1
N20960628: QE39.5 RE455.2 RE456.1
N20960654: QE29.5 RE396.2 RE397.1
N20960689: QE29.2 RE399.2 RE401.1
N20960760: QE39.2 RE453.1 RE454.2
N20960779: QE49.5 RE512.1 RE513.2
N20960882: QE49.2 QE49.3 RE511.2
N20960884: QE40.2 RE458.1 RE460.2
N20960892: QE40.5 RE461.2 RE462.1
N20960976: QE41.2 RE465.1 RE467.2
N20960982: QE41.5 RE466.2 RE468.1
N20960988: QE54.5 RE514.1 RE517.2
N20961029: QE50.5 RE515.1 RE516.2
N20961045: QE50.2 QE50.3 RE514.2
N20961145: QE42.2 RE472.1 RE474.2
N20961166: QE42.5 RE471.2 RE473.1
N20961197: QE43.2 RE479.1 RE480.2
N20961228: QE43.5 RE476.2 RE478.1
N20961244: QE55.2 RE518.1 RE521.2
N20961277: QE51.5 RE519.1 RE520.2
N20961293: QE51.2 QE51.3 RE518.2
N20961336: QE55.5 RE522.1 RE525.2
N20961369: QE52.5 RE523.1 RE524.2
N20961391: QE52.2 QE52.3 RE522.2
N20961418: QE44.2 RE485.1 RE486.2
N20961454: QE44.5 RE482.2 RE484.1
N20961510: QE45.2 RE491.1 RE492.2
N20961531: QE45.5 RE488.2 RE490.1
N20961580: QE46.2 RE496.1 RE498.2
N20961592: QE46.5 RE495.2 RE497.1
N20961638: QE56.2 RE526.1 RE529.2
N20961685: QE53.2 QE53.3 RE526.2
N20961740: QE47.2 RE501.1 RE503.2
N20961750: QE47.5 RE502.2 RE504.1
N20961813: QE48.2 RE508.1 RE510.2
N20961825: QE48.5 RE507.2 RE509.1
N20971521: JLAN.9 RL8.1
N20971565: RL5.1 UL2.3
N20971567: CL31.1 JLAN.12 LL1.2
N20972379: RL2.2 UL1.5
N20972746: QL3.1 RL13.2 RL14.2
N20986399: RE161.1 UE12.3
N20995131: RE25.2 UE3.24
N20995135: RE31.1 UE3.30
N20999302: RM72.1 UM8.27
N20999314: RM61.2 UM8.52
N20999316: RM64.1 RM66.1 UM8.48
N21000707: RM21.2 RM96.2 UM4.1
N21000709: CM99.1 RM28.1 RM29.1
N21000711: CM98.1 RM27.1 RM38.1
N21000719: CM16.1 CM17.1 RM18.2 UM4.20
N21000750: RM25.2 UM4.18
N21000786: RM28.2 UM4.13
N21000788: RM27.2 UM4.14
N21000830: QM1.2 QM2.6 RM92.2
N21000850: QM2.3 QM3.2 RM94.2
N21000877: RM20.2 UM4.4
N21002214: RE14.2 UE2.3
N21002223: CE20.1 RE11.1 UE2.6
N21002224: RE9.1 UE2.5
N21002246: RE13.2 UE2.7
N21002311: RE651.1 UE1.20
N21002312: CE9.1 UE1.19
N21002317: CE18.1 UE1.11
N21002319: CE17.1 UE1.12
N21002321: CE16.1 UE1.13
N21002324: CE15.1 UE1.14
N21002326: CE14.1 UE1.15
N21002328: CE13.1 UE1.16
N21002352: RE10.1 UE2.2
N21002366: DE1.2 RE8.2 UE1.23
N21002397: RE20.1 UE9.3
N21003330: R181.2 U2407.7
N21003701: DF1.1 JFAN1.3 RF3.1
N21003743: DF2.1 JFAN2.3 RF6.1
N21014812: C3.1 UZ21.6
N21181966: CPU1.H13 RH154.2
N21181987: CPU1.BH31 RH153.2
N21182006: CPU1.BR33 RH519.2
N21182008: CPU1.BR30 RH158.2
N21182026: CPU1.BP31 RH155.2
N21185219: RV45.1 UV17.3
N21185406: CV374.1 RV13.2
N21238299: RE166.2 UE8.24
N21238303: RE167.1 UE8.30
N22278193: TV38.1(TP-1) UG1.AE34
N22278233: TV40.1(TP-1) UG1.AJ33
N22278253: TV41.1(TP-1) UG1.AE33
N22278293: TV43.1(TP-1) UG1.AK34
N22278373: TV47.1(TP-1) UG1.AT24
N22278393: TV48.1(TP-1) UG1.AT30
N22278413: TV49.1(TP-1) UG1.AR30
N22278433: TV50.1(TP-1) UG1.AU32
N22278453: TV51.1(TP-1) UG1.AT32
N24365027: CE63.2 RE530.2 UE10.3
N24371838: JHDMI.13 RV655.2
N24377100: QX3.2 RX6.1
N24405043: CV438.1 UV21.47
N24405047: RV24.1 UV21.34
N24405061: QV95.1 RV25.1 RV26.2 UV21.50
N24405079: CV439.1 RV26.1
N24654525: C2522.1 J6.2 U18.1
N24654698: R367.1 U18.3
N25131299: QV2.1 RV12.2
N25769611: QE57.5 RE637.2 RE638.1
N25769633: QE57.3 RE636.2
N25769981: QE57.6 RE639.2
N25769983: QE57.2 RE640.2 RE641.1
N25814049: CG306.1 QG3.2 RG50.1
N25867602: QE13.6 RE160.2
N25867965: QE21.6 RE155.2
N25868866: QE22.6 RE157.2
N26196167: RE646.2 UE5.2
N26590619: RU15.1 UU7.1
N26590621: RU16.1 UU7.20
N26590623: RU17.1 UU7.16
N26590625: RU20.1 UU7.19
N26590627: RU19.1 UU7.18
N26590629: RU18.1 UU7.17
N26590633: CU33.1 CU34.1 CU42.1 CU44.1 RU12.2 RU21.1 RU23.1 UU7.2 UU7.3 UU7.4 UU7.5
N26590645: RU14.1 UU7.9
N26590649: RU23.2 UU7.8
N26590685: RU14.2 UU7.10
N26590716: RU21.2 UU7.7
N28750395: TV39.1(TP-1) UG1.AR29
N29389682: RE32.2 UE4.24
N29389707: RE37.1 UE4.30
N29418337: PC508.2 PR525.1
N29418339: PR522.1 PR525.2 PR531.1 PU500.5
N29418355: PC533.2 PR546.2
N29418359: PR546.1 PR549.1 PR550.2 PU500.17
N29418369: PC514.1 PR532.2
N29418371: PC5011.2 PH504.2 PR545.1 PR547.2
N29418373: PR532.1 PR533.1 PR536.1 PU500.30
N29418377: PR545.2 PU500.15
N29418393: PC5010.2 PH500.2 PR513.2 PR514.1
N29418395: PR514.2 PU500.3
N29418397: PC505.2 PR521.2 PU500.4
N29418405: PR527.1 PU500.36
N29418417: PC509.2 PR524.1 PU500.33
N29418423: PC520.2 PR537.1 PU500.29
N29418425: PC519.1 PR539.1 PU500.28
N29418433: PR515.2 PR520.2 PU500.47
N29418441: PR518.1 PU500.40
N29418445: PR517.1 PU500.39
N29418451: PR516.1 PU500.38
N29418455: PR519.1 PU500.37
N29418473: PC536.1 PR551.1 PU500.16
N29418487: PC504.1 PR506.1 PU500.41
N29418491: PR523.1 PU500.48
N29419473: PC500.2 PR500.2 PU500.2
N29419486: PC518.2 PR540.2 PU500.8
N29419576: PC506.2 PR521.1
N29419623: PH502.1 PR534.2
N29419647: PC521.1 PR537.2
N29419655: PC522.1 PR536.2
N29419663: PH501.2 PR530.1
N29419667: PH503.2 PR544.1
N29419693: PC518.1 PR538.2
N29419713: PR526.1 PU500.1
N29419730: PC509.1 PR528.2
N29419832: PC503.1 PR505.2 PU500.42
N29419860: PC535.2 PR548.1 PU500.14
N29419910: PC538.2 PR551.2
N29419918: PC537.1 PR549.2
N29419943: PC532.1 PR541.1 PU500.20
N29419947: PC532.2 PR543.1
N29425467: PL503.2 PR575.1 PR577.2 PR578.1 PU504.11 PU504.12 PU504.13 PU504.14 PU504.15 PU504.16 PU504.17 PU504.18 PU504.19 PU504.20 PU504.21
N29425497: PL502.2 PR565.1 PR567.2 PR568.1 PU503.11 PU503.12 PU503.13 PU503.14 PU503.15 PU503.16 PU503.17 PU503.18 PU503.19 PU503.20 PU503.21
N29425633: PL501.2 PR555.1 PR557.2 PR558.1 PU502.11 PU502.12 PU502.13 PU502.14 PU502.15 PU502.16 PU502.17 PU502.18 PU502.19 PU502.20 PU502.21
N29426641: PR573.1 PU504.1
N29426805: PC548.1 PR555.2
N29426831: PC556.1 PR565.2
N29426855: PC564.1 PR575.2
N29435109: PL508.1 PR5002.1 PR5003.1 PU511.8
N29435333: PL506.2 PR593.1 PR595.2 PR596.1 PU510.11 PU510.12 PU510.13 PU510.14 PU510.15 PU510.16 PU510.17 PU510.18 PU510.19 PU510.20 PU510.21
N29435335: PC587.1 PR5002.2
N29436554: PL505.2 PR584.1 PR586.2 PR587.1 PU507.11 PU507.12 PU507.13 PU507.14 PU507.15 PU507.16 PU507.17 PU507.18 PU507.19 PU507.20 PU507.21
N29436709: PC580.1 PR593.2
N29436789: PC570.1 PR584.2
N29438561: PR512.2 PU500.43
N29438565: PR510.2 PU500.44
N29438567: PR502.2 PR509.1 PR510.1
N29438569: PR501.2 PR507.1 PR508.1
N29438571: PR508.2 PU500.45
N29438583: PR503.2 PR511.1 PR512.1
N29438934: PR504.1 PU500.46
N29599145: PC507.1 PR522.2
N29647096: QU1.2 RU24.2 RU25.1
N30005754: CH70.1 UH1.BA26
N30712936: PR727.2 PU700.15
N30746783: PR210.2 PU201.10
N30816588: RA84.1 RA85.1 UA2.B2
N31077401: PQ710.3 PR732.2
N31077403: PQ710.5 PQ710.6 PR729.1 PR730.2
N31077444: PC724.1 PQ710.2 PR731.2
N31306212: PR5006.1 PU511.1
N31425872: PC541.2 PU502.5
N31425874: PC541.1 PR554.1
N31425876: PR554.2 PU502.7
N31426231: PR552.1 PU502.1
N31426252: PR556.1 PU502.2
N31426527: PC5005.1 PR5028.2 PU502.24
N31427446: PC540.2 PR553.1 PU502.3
N31432086: PC550.1 PR564.1
N31432111: PC550.2 PU503.5
N31432114: PR564.2 PU503.7
N31434994: PR566.1 PU503.2
N31435092: PR563.1 PU503.1
N31436196: PC558.1 PR574.1
N31436215: PC558.2 PU504.5
N31436218: PR574.2 PU504.7
N31436380: PR576.1 PU504.2
N31438582: PC5007.1 PR5030.2 PU504.24
N31438896: PC557.2 PR5020.1 PU504.3
N31439632: PC567.1 PR583.1
N31439653: PC567.2 PU507.5
N31439658: PR583.2 PU507.7
N31439736: PR585.1 PU507.2
N31439790: PR590.1 PU507.1
N31442956: PC566.2 PR5022.1 PU507.3
N31442990: PC5008.1 PR5031.2 PU507.24
N31443441: PC549.2 PR5004.1 PU503.3
N31452286: PC574.2 PU510.5
N31452288: PC574.1 PR592.1
N31452290: PR592.2 PU510.7
N31452345: PR591.1 PU510.1
N31452390: PR594.1 PU510.2
N31459506: PC573.2 PR5024.1 PU510.3
N31460044: PC5009.1 PR5032.2 PU510.24
N31466143: PC725.1 PQ703.4 PR733.1
N31494164: PC586.1 PR5005.1
N31494196: PC586.2 PU511.4
N31494209: PR5005.2 PU511.5
N31494627: PR5001.2 PU511.12
N31495785: PC588.2 PR5025.1 PU511.2
N31495969: PC5002.2 PR5026.2 PU511.11
N31535656: PR107.1 PU100.19
N31565200: PR599.1 PU502.26
N31565645: PR5011.1 PU503.26
N31565698: PC5006.1 PR5029.2 PU503.24
N31566286: PR5019.1 PU504.26
N31567454: PR5021.1 PU507.26
N31567631: PR5023.1 PU510.26
N32073814: PC8215.1 PR8208.1 PU8200.8
N32073817: PC8217.1 PR8208.2 PR8211.1 PR8214.2 PU8200.7
N32074224: PC8210.1 PR8204.2
N32074541: PC8219.1 PR8210.2
N32187709: PC810.2 PC814.2 PJP802.2 PU802.8 PU802.9 PU802.10
N32187730: PC806.1 PR809.2
N32220030: PC305.1 PR302.2
N32220048: PC309.1 PR305.2
N32273050: PC6007.2 PC6009.1 PR6025.1 PR6028.2 PR6031.1 PU8201.48
N32273054: PC6008.2 PC6009.2 PU8201.47
N32273056: PC6000.1 PR6000.2 PU8201.11
N32273064: PC6025.2 PC6026.2 PR6068.2 PR6070.2 PU8201.24
N32273074: PC6004.2 PC6005.2 PR6012.2 PR6013.1 PU8201.34
N32273076: PC6002.2 PR6087.2 PR6088.2 PU8201.5
N32273088: PR6024.1 PR6028.1 PU8201.50
N32273092: PC6001.2 PR6003.2 PU8201.13
N32273102: PC6010.2 PR6026.1 PR6027.2 PR6085.2 PU8201.39
N32273120: PC6014.1 PC6015.1 PH6000.1 PR6042.1 PR6047.2 PR6050.2 PR6052.1 PU8201.44
N32273126: PC6003.2 PR6017.1 PU8201.10
N32273150: PC6006.2 PR6019.2 PR6033.1 PU8201.38
N32273186: PC6007.1 PR6024.2
N32273265: PC6017.1 PR6052.2 PU8201.45
N32273277: PR6005.2 PR6010.2 PU8201.3
N32273279: PC6008.1 PR6025.2
N32273281: PC6018.2 PR6054.2 PR6055.2 PR6057.2 PR6058.2 PU8201.41
N32273283: PC6011.2 PC6012.2 PR6039.2 PU8201.51
N32273319: PC6025.1 PC6026.1 PH6001.1 PR6069.1 PR6072.2 PR6077.2 PR6078.1 PU8201.22
N32273363: PC6011.1 PC6013.2 PR6041.2 PU8201.52
N32273439: PR6018.2 PU8201.9
N32273453: PR6056.2 PU8201.8
N32273563: PC6006.1 PR6019.1 PR6021.2 PU8201.37
N32273609: PC6005.1 PR6012.1 PR6015.2 PU8201.33
N32273633: PC6019.2 PC6021.1 PR6060.1 PR6063.2 PR6065.1 PU8201.16
N32273643: PH6001.2 PR6069.2 PR6070.1
N32273684: PC6028.1 PR6078.2 PU8201.21
N32273716: PC6014.2 PC6015.2 PR6040.1 PR6043.2 PR6044.1 PR6046.1 PR6048.1 PU8201.43
N32273720: PR6004.1 PR6005.1 PR6006.1 PR6089.2 PR6090.2
N32273790: PR6008.2 PU8201.1
N32273792: PR6075.1 PR6080.2 PU8201.7
N32273794: PR6074.1 PR6079.2 PU8201.6
N32273848: PC6022.2 PC6023.2 PR6064.2 PU8201.26
N32273852: PC6022.1 PR6066.1 PU8201.25
N32274096: PR6082.2 PU8201.12
N32274305: PC6024.2 PR6071.2 PU8201.15
N32274335: PC6020.2 PC6021.2 PU8201.19
N32274341: PR6059.1 PR6063.1 PU8201.17
N32274405: PC6020.1 PR6060.2
N32274409: PC6019.1 PR6059.2
N32274431: PC6016.2 PR6049.1 PR6081.2 PU8201.42
N32274465: PC6027.2 PR6073.1 PU8201.23
N32274547: PC6010.1 PR6027.1 PR6029.2 PR6086.1 PU8201.40
N32274908: PH6000.2 PR6042.2 PR6043.1
N32278456: PC6411.2 PR6402.1
N32278462: PC6400.2 PR6400.2 PU6400.6
N32278468: PU6400.8 PU6400.9 PU6400.10 PU6400.11
N32278470: PC6411.1 PL6400.1 PU6400.12 PU6400.13 PU6400.14 PU6400.15 PU6400.16 PU6400.17 PU6400.18
N32278548: PC6410.1 PR6401.2
N32320016: PC6410.2 PU6400.27 PU6400.29
N32320046: PR6401.1 PU6400.30
N32336439: PC6128.2 PR6114.1
N32336483: PU6102.8 PU6102.9 PU6102.10 PU6102.11
N32336487: PC6128.1 PL6101.1 PU6102.12 PU6102.13 PU6102.14 PU6102.15 PU6102.16 PU6102.17 PU6102.18
N32336585: PC6117.2 PR6112.2 PU6102.6
N32336677: PC6127.1 PR6113.2
N32336681: PR6113.1 PU6102.30
N32337023: PC6127.2 PU6102.27 PU6102.29
N32338871: PC6227.1 PR6213.2
N32338879: PR6213.1 PU6202.30
N32339247: PC6227.2 PU6202.27 PU6202.29
N32339676: PC6228.2 PR6214.1
N32339714: PC6228.1 PL6201.1 PU6202.12 PU6202.13 PU6202.14 PU6202.15 PU6202.16 PU6202.17 PU6202.18
N32339716: PU6202.8 PU6202.9 PU6202.10 PU6202.11
N32339788: PC6217.2 PR6212.2 PU6202.6
N32433695: RG92.1 UG13.J13
N32433703: RG88.1 UG13.J1
N32433714: RG90.1 UG13.J10
N32434049: RG93.1 UG14.J13
N32434050: RG89.1 UG14.J1
N32434053: RG91.1 UG14.J10
N32437553: RG105.1 UG15.J13
N32437554: RG102.1 UG15.J1
N32437557: RG103.1 UG15.J10
N32437559: RG107.1 UG16.J13
N32437560: RG104.1 UG16.J1
N32437563: RG106.1 UG16.J10
N32441039: RG121.1 UG17.J13
N32441040: RG117.1 UG17.J1
N32441043: RG119.1 UG17.J10
N32441045: RG120.1 UG18.J13
N32441046: RG116.1 UG18.J1
N32441049: RG118.1 UG18.J10
N32444525: RG135.1 UG19.J13
N32444526: RG131.1 UG19.J1
N32444529: RG133.1 UG19.J10
N32444531: RG134.1 UG20.J13
N32444532: RG130.1 UG20.J1
N32444535: RG132.1 UG20.J10
N32552238: RG79.2 UG1.R14
N32559918: RG78.2 UG1.AL20
N32621251: RG28.2 RG29.2 UG1.AU30
N32676252: TV35.1(TP-1) UG1.AA30
N32706715: CG135.1 RG81.2 RG82.1
N32743557: TV16.1(TP-1) UG1.AW42
N32770979: PR812.1 PR813.2 PU800.13
N32822458: PC5027.1 PU509.16 PU509.17
N32822470: PC818.2 PR5012.2 PR5015.1 PU509.14
N32822602: PR5012.1 PR5014.2 PR5017.2
N32822744: PR5033.1 PR5034.2 PU509.13
N32822911: PC590.1 PR5007.1 PR5008.1 PU509.11
N32822969: PC593.1 PR5010.2
N32835753: RG60.2 UG1.Y31
N32835959: RG61.2 UG1.P15
N32838652: CG133.1 RG65.2 RG66.1
N33042292: PC8222.1 PQ8202.2 PR8213.2
N33058126: PQ8202.1 PR8214.1
N33364358: RV260.2 RV535.1
N33364367: RV533.2 UV23.4
N33364369: CV22.1 RV534.1 RV535.2 RV537.1 UV23.3
N33587541: PC217.1 PQ202.2 PR212.2
N33587555: PQ202.1 PR213.2
N33647933: PC6029.2 PR6020.1 PR6083.2 PU8201.36
N33647937: PC6029.1 PR6022.2 PR6083.1 PU8201.35
N33651095: PC6216.1 PL6200.1 PU6201.12 PU6201.13 PU6201.14 PU6201.15 PU6201.16 PU6201.17 PU6201.18
N33651113: PC6215.1 PR6210.2
N33651117: PU6201.8 PU6201.9 PU6201.10 PU6201.11
N33651127: PC6215.2 PU6201.27 PU6201.29
N33651207: PC6205.2 PR6209.2 PU6201.6
N33651327: PR6210.1 PU6201.30
N33651387: PC6216.2 PR6211.1
N33654422: PU6301.8 PU6301.9 PU6301.10 PU6301.11
N33654426: PC6315.1 PR6310.2
N33654440: PC6316.1 PL6300.1 PU6301.12 PU6301.13 PU6301.14 PU6301.15 PU6301.16 PU6301.17 PU6301.18
N33654466: PC6315.2 PU6301.27 PU6301.29
N33654550: PC6305.2 PR6309.2 PU6301.6
N33654622: PR6310.1 PU6301.30
N33654648: PC6316.2 PR6311.1
N33668338: PC1310.2 PR1307.2 PR1309.1 PU1301.7
N33730314: PC218.1 PQ202.5 PR214.2
N33730328: PQ202.4 PR215.2
N33940720: PQ707.4 PR726.1
N33941468: PQ701.4 PR725.1
N34055083: RG158.1 RG159.1 YG1.1
N35037011: CG130.1 QG2.2 RG49.2
N35037016: CG131.1 QG4.2 RG51.1
N37147447: RG170.2 RG171.2 UG2.5
N39112837: CV1058.1 U1.47
N39112883: CV1057.1 U1.48
N39112974: CV1059.1 U1.44
N39113020: CV1060.1 U1.45
N39113066: CV1061.1 U1.41
N39113112: CV1062.1 U1.42
N39113201: CV1063.1 U1.38
N39113246: CV1064.1 U1.39
N39116567: RV193.2 U1.36
N39344573: RV1307.2 RV1309.1 U1302.2
N40160711: R183.2 UG3.4
N40259586: RT108.1 RT109.2 UT4.D6
N40301337: QG505.5 QG505.6 RG513.2
N40301360: QG505.3 RG514.2
N40305020: QG507.5 QG507.6 RG515.2
N40305043: QG507.3 RG516.2
N41521526: CE51.1 QE2.2 RE85.1
N44255477: RG5.1 UG1.AW24
N44255479: RG6.1 UG1.AV24
N44258253: RG3.1 UG1.AK30
N44270546: RG23.1 UG1.AV43
N44270552: RG22.2 UG1.AV41
N44285633: RG43.1 UG1.V14
N44433082: RG150.1 UG1.AW18
N44433084: RG151.1 UG1.AT19
N44433090: RG149.1 UG1.AV18
N44451988: RG18.1 UG1.AP24
N44451992: RG19.1 UG1.AR24
N44452100: RG46.1 UG1.AY24
N44473342: RG44.2 UG1.AT36
N44473345: RG45.2 UG1.AV36
N46084233: QX2.2 RX2.1
N72585933: PC211.1 PR202.2
N121507165: CPU1.BR25 RH57.2
N121507167: CPU1.BP25 RH58.2
N121507169: CPU1.BT29 RH166.2
N124752685: CH101.2 RH211.1
N124753277: CH100.2 RH212.1
N125073340: CPU1.A33 T1.1(TP-1)
N198830997: RV23.2 UV21.48
N212152397: JRTC1.1 PR2.2
N213961754: PC14.2 PQ8.2 PR28.2
N401547420: T64.1(TP-1) UT4.B2
N401547610: T121.1(TP-1) UT4.E10
N427456051: PC6017.2 PR6050.1
N427458001: PC6028.2 PR6077.1
N429247870: TV13.1(TP-1) UG1.AM29
N429252370: TV14.1(TP-1) UG1.AN29
N429294591: QG4.1 RG48.2
N429942030: C2507.1 U17.10
N429942496: C2506.1 U17.12
N4015486424: T65.1(TP-1) UT4.C2
N4015486425: T114.1(TP-1) UT4.D10
N4015486426: T120.1(TP-1) UT4.G11
N4015486429: T122.1(TP-1) UT4.G10
N4015486430: T70.1(TP-1) UT4.D7
N4015486431: T71.1(TP-1) UT4.H6
N4015486463: T62.1(TP-1) UT4.F4
N4015486464: T63.1(TP-1) UT4.G4
N4274545242: PR6047.1 PU8201.46
N4274545247: PR6072.1 PU8201.20

Pads without a net: CPU1 A27 AA14 AD2 AD4 AE1 AE5 AE9 AE10 AE11 AE29 AF10 AF29 AF30 AF31 AF32 AF33 AF34 AG13 AG14 AG31 AG32 AG33 AG34 AG35 AG36 AH13 AH14 AH29 AH30 AH31 AH32 AH35 AH36 AJ8 AJ10 AJ11 AJ13 AJ14 AK3 AL1 AL2 AL3 AM10 AM11 AT3 AT5 AT7 AT11 AT13 AU13 AW7 AW8 AW9 AW10 AW11 AW13 AY1 AY2 AY3 AY4 AY5 AY7 AY8 AY9 AY10 AY11 AY13 B27 B30 B33 B34 B36 B38 BA1 BA2 BA3 BA4 BA5 BH30 BJ17 BJ19 BJ20 BJ21 BJ23 BJ26 BJ27 BJ28 BJ35 BJ36 BK17 BK19 BK20 BK21 BK23 BK26 BK27 BK28 BL14 BL15 BL16 BL17 BL18 BL19 BL20 BL21 BL22 BL23 BL24 BL25 BL26 BL27 BL28 BL31 BL34 BM14 BM15 BM16 BM17 BM22 BM24 BM30 BM31 BN1 BN15 BN16 BN17 BN33 BN35 BP1 BP13 BP15 BP16 BP17 BR15 BR16 BR17 BR31 BR35 BT15 BT16 BT17 BT30 C30 C33 C34 C38 D1 D34 E1 E2 E30 E33 F30 F33 G3 G13 H24 J3 J24 N29 R14; FD1 1; FD2 1; FD3 1; FD4 1; FD5 1; FD6 1; JDIMM1 87 88 91 92 95 97 100 101 104 105 134 162 165; JDIMM2 87 88 91 92 95 97 100 101 104 105 134 162 165; JHDD 7 8 10 11 14 17; JHDMI 14; JIO 2 9; JKB2 1 2; JKBBL 17 18 19 20; JSSD1 5 6 7 8 10 11 13 17 19 20 22 23 24 25 26 28 30 32 34 36 40 42 44 46 48 54 56 58 67; JSSD2 6 8 10 20 22 24 26 28 30 32 34 36 40 42 44 46 48 54 56 58 67; JSSD3 6 8 10 20 22 24 26 28 30 32 34 36 40 42 44 46 48 54 56 58 67; JTP 8 9 10; JWLAN 6 8 9 10 11 12 13 14 15 16 17 19 20 21 22 23 24 26 28 34 36 38 40 47 50 51 52 53 54 56 57 58 59 60 62 63 65; PD1 3; PD3 3; PU502 6 25 27; PU503 6 25 27; PU504 6 25 27; PU507 6 25 27; PU509 10 12; PU510 6 25 27; PU700 13 14; PU800 9 10 12; PU802 1 4 7; PU1300 5; PU1301 1 5; PU6102 1 28 32; PU6201 1 28 32; PU6202 1 28 32; PU6301 1 28 32; PU6400 1 28 32; PU8200 6; PU8201 14 18 49; QE56 3 4 5; U1 2 4 9 10 12 25 26 28 29 37; U1302 3 7; U2407 8 11; UA1 4 8 47 48 49 50; UA4 13 31 32 35 36; UC1 1; UE3 12 13 19 20 21 22 28 29; UE4 12 13 19 20 21 22 28 29; UE5 37; UE6 13 23; UE8 12 13 22 28 29; UE10 13 21; UG1 AA37 AA38 AA39 AA41 AA42 AA43 AC37 AC38 AC39 AC42 AC43 AD33 AD34 AD38 AD39 AD41 AD42 AD43 AE37 AE38 AE39 AE41 AE42 AE43 AF31 AF37 AF38 AF39 AG9 AG13 AG33 AG34 AL27 AM27 AN21 AP21 AR19 AR21 AR23 AR25 AT23 AT25 AU20 AU21 AU26 AU35 AV21 AV23 AV25 AV26 AV35 AW20 AW21 AW23 AW25 AW40 AY26 AY27 AY29 AY30 BA19 BA20 BB19 BB20 BB21 BB25 BB26 BB27 BB29 BB30 BB32 BC19 BC20 BC21 BC25 BC26 BC27 BC29 BC30 BC32 J27 K14 N27 P10 W35 W42 W43 Y38 Y39 Y41 Y42 Y43; UG3 6; UG13 A5 U5; UG14 A5 U5; UG15 A5 U5; UG16 A5 U5; UG17 A5 U5; UG18 A5 U5; UG19 A5 U5; UG20 A5 U5; UH1 A16 A21 A39 AA44 AA45 AB13 AB33 AB35 AB36 AB39 AB43 AB44 AC43 AD2 AD3 AD38 AE17 AE44 AE45 AF17 AF41 AG14 AG15 AG39 AG44 AH43 AH44 AJ7 AJ8 AJ11 AJ13 AJ33 AJ35 AJ38 AJ42 AK44 AL27 AL39 AL42 AM43 AM44 AN17 AN24 AN29 AN36 AN42 AR15 AR17 AR19 AR22 AR27 AR29 AR38 AT27 AT31 AT42 AT43 AV2 AV3 AV4 AV13 AV15 AV19 AW2 AW17 AW31 AW33 AW35 B15 B16 B19 B20 B21 B23 B24 B39 BA4 BA33 BA35 BA40 BA41 BB17 BB31 BB33 BB36 BB38 BB41 BC8 BC15 BC18 BC22 BC23 BC26 BC32 BC33 BC35 BC36 BC38 BD1 BD14 BD17 BD18 BD21 BD23 BD24 BD27 BD33 BD34 BD35 BD36 BD38 BD39 BE2 BE5 BE6 BE34 BE39 C15 C19 C20 C23 C24 E17 E20 E41 F41 G15 G17 G19 H15 K13 K15 K17 K22 K24 L17 L22 L24 M44 M45 N2 N3 N29 N31 N42 N43 N44 P1 P2 P3 P24 P27 P29 P31 P44 R2 R3 R4 R11 R13 R24 R27 R36 R39 R41 R42 R43 R44 T44 T45 U2 U3 U13 U35 U36 U39 U41 U42 U43 V1 V2 V44 W2 W3 W7 W10 W11 W13 W39 W43 W44 Y5 Y41 Y43; UL1 24 25 26 28 40; UM4 7 8; UM8 10 11 12 13 15 16 17 18 21 22 23 28 29 30 31 32 33 34 35; US1 2 3; UT1 A7 A9 A11 A13 A23 B7 B9 B11 B13 B23 D19 E18 E19 J1 J2 L1 L2 N1 N2 R1 R2 V18 W16 W19 Y16 Y19; UT4 A9 B9; UU1 9; UU5 1; UV3 9 10 11 12 13 14; UV21 22 23 24 25; UV22 12 13 14

## Via types
v1: diameter 0.457, hole 0.203, TOP to BOTTOM, 11067 vias
v2: diameter 0.305, hole 0.152, TOP to BOTTOM, 1009 vias
v3: diameter 0.508, hole 0.254, TOP to BOTTOM, 112 vias
v4: diameter 0.406, hole 0.203, TOP to BOTTOM, 116 vias

## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point)
1.2V_B+: length 29
  IN3 w0.254: v1(97.42,42.64) 98.18,42.64 102.21,38.61 102.21,31.2 100.82,29.81 92.4,29.81 89.92,32.29 v1(89.92,32.8)
  BOTTOM w0.254: v1(97.42,42.64) 97.37,42.69 PR206.1
  vias: v2(88.02,33.94)
3/5V_B+: length 3.3
  IN1 w0.508: v1(54.49,43.22) 54.49,41.81 54.27,41.6 v1(54.27,40.99)
  BOTTOM w0.203: v1(54.49,43.22) 54.49,43.41 54.26,43.63 PU100.12
  vias: v1(51.76,40.93) v1(51.76,40.29) v1(51.76,39.66) v1(52.4,40.93) v1(52.4,40.29) v1(52.4,39.66) v1(53.03,40.93) v1(53.03,40.29) v1(53.03,39.66) v1(53.67,40.93) v1(53.67,40.29) v1(53.67,39.66) v1(54.3,40.29) v1(54.3,39.66) v1(54.94,40.86) v1(54.94,40.23) v1(54.94,39.59) v2(56.21,39.72)
3V_EN: length 8.1
  TOP w0.254: v1(57.02,46.42) 56.97,46.47 56.97,48.23 v2(57.48,48.74) 58.11,49.37 59.4,49.37 59.65,49.12 PR100.1
  BOTTOM w0.203: v1(57.02,46.42) 56.95,46.49 56.95,46.51 56.5,46.95 56.12,46.95 55.87,46.71 55.87,46.63 55.72,46.48 PU100.6
3V_F383_ON: length 236.7
  TOP w0.107: v2(309.11,25.09) RE83.1
  TOP w0.203: RE83.1 308.35,23.2 v1(308.35,22.64) 308.35,22.34 308.23,22.21 UE5.128
  IN2 w0.254: v1(308.35,22.64) 306.42,20.71 302.95,20.71 301.47,19.23 298.03,19.23 296.68,20.58 288.41,20.58 283.36,25.63 280.1,25.63 277.77,27.96 270.64,27.96 268.71,29.9 268.71,30.99 263.47,36.23 240.18,36.23 239.25,37.16 233.18,37.16 232.41,37.93 224.6,37.93 223.71,38.82 219.38,38.82 219.24,38.95 218.77,38.95 218.29,39.44 217.52,39.44 217.2,39.77 216.42,39.77 215.77,40.41 214.81,40.41 214.5,40.1 213.11,40.1 212.85,40.35 212.23,40.35 210.96,39.09 207.26,39.09 207.19,39.02 205.29,39.02 205.23,39.09 203.67,39.09 203.4,39.36 196.13,39.36 195.56,38.79 193.01,38.79 192.03,37.81 192.03,34.83 191.08,33.88 183.16,33.88 181.89,32.61 117.1,32.61 117.06,32.65 112.76,32.65 110.56,30.45 107.26,30.45 103.51,26.7 99.23,26.7 98.75,26.23 98.75,25.18 99.53,24.4 v1(100.1,24.4)
  BOTTOM w0.254: UE9.4 99.48,24.13 99.75,24.4 v1(100.1,24.4)
3VS: length 0.8
  BOTTOM w0.107: 69.02,14.26 69.03,14.27 v2(69.03,15.07)
3VS_GATE: length 2.9
  BOTTOM w0.203: U17.5 65.09,15.75 65.39,16.05 C258.1 R174.2
5V_EN: length 12.3
  TOP w0.254: v1(51.82,47.16) 54.99,47.16 57.58,49.75 60.27,49.75 v2(60.46,49.56) 60.57,49.46 PR112.1
  BOTTOM w0.203: v1(51.82,47.16) 51.82,46.68 52.03,46.48 PU100.20
5VS:
  vias: v2(56.65,13.37)
5VS_GATE: length 3.3
  BOTTOM w0.107: v2(62.53,17.38) 62.77,17.38 63.23,16.92 R182.2
  BOTTOM w0.203: U17.3 64.29,15.62 63.48,16.43 R182.2
+0.6VS: length 100.4
  IN2 w1.524: 178.38,51.66 178.38,52.29 181.43,55.34 181.43,58.52 179.86,60.09 112.72,60.09 112.71,60.08 107.5,60.08 106.8,60.78 101.96,60.78 94.69,53.5 93.9,53.5 93.78,53.48 93.29,52.99
  vias: v1(91.7,52.1) v1(91.7,51.47) v1(92.4,52.1) v1(178.19,40.86) v1(178.32,50.4) v1(178.32,49.75) v1(178.51,41.37) v1(178.81,50.07) v4(181,40.3)
+0.6VSP: length 2.1
  BOTTOM w0.102: v2(90.74,51.21) 91.41,50.54 PC206.1
+0.9V_CIO: length 12.6
  IN2 w0.381: v1(179.35,163.16) 179.27,163.07 179.27,162.91 178.89,162.53 178.89,161.79 179.24,161.43 179.24,160.98 179.22,160.96 179.22,160.83 177.49,159.1 177.49,158.66 175.2,156.36 175.2,155.72 174.7,155.23 v1(174.7,154.78)
  BOTTOM w0.254: v1(174.7,154.78) 174.44,154.53 v2(174.44,154.21) 174.44,153.89 174.81,153.52 CT78.1
  vias: v1(180.65,163.81)
+0.9V_DP:
  vias: v1(175.33,154.74) v1(175.93,154.74) v1(178.7,165.11) v1(178.7,164.46) v1(180.65,165.11) v1(180.65,162.51) v1(181.3,162.51) v2(175.84,154.08)
+0.9V_LVR_OUT:
  vias: v1(180.65,166.41) v1(180.65,165.76) v1(183.24,166.41) v2(182.95,167.8)
+0.9V_PCIE:
  vias: v1(181.96,165.1) v1(182.6,165.1) v1(183.27,165.1) v1(183.9,165.1) v1(187.84,157.89) v1(187.78,156.73) v2(187.97,157.32)
+0.9V_SVR:
  vias: v1(171.71,172.94) v1(172.35,172.94) v1(172.98,172.94) v1(180,165.76) v1(180.66,167.7) v1(181.3,168.36) v1(181.3,167.7) v1(181.96,167.7) v2(180.73,168.31)
+0.9V_USB: length 1.6
  BOTTOM w0.102: v1(187.1,156.73) v2(187.1,157.55)
  BOTTOM w0.203: v1(182.6,163.16) 183.17,162.59 CT77.1
+1.2V_DDR: length 115
  TOP w0.381: CH197.1 125.57,76.54 125.58,76.56 UC1.5
  TOP w0.508: 129.1,75.85 129.07,75.89 CH197.1
  BOTTOM w0.203: v1(154.32,99.25) CPU1.AG9 ; CPU1.AJ12 151.87,100.75 v1(151.58,100.46) 151.21,100.1 CPU1.AL11 ; v1(159.81,100.46) 159.52,100.75 CPU1.Y12 ; CPU1.K6 167.2,97.03 166.76,97.03 166.56,96.84 CPU1.L6
  BOTTOM w0.254: v1(161.93,96.51) 162.25,96.84 CPU1.T6 ; v1(154.38,96.5) 154.49,96.5 CPU1.AF6 ; v1(154.38,96.5) 154.69,96.19 CPU1.AF5 ; v1(154.38,96.5) 154.07,96.19 CPU1.AG5 ; CPU1.AY6 143.99,96.84 v1(144.33,96.5) 144.67,96.84 CPU1.AW6 ; v1(146.84,96.47) 146.92,96.47 CPU1.AR6 CPU1.AP6 148.38,97.1 CPU1.AP7 ; v1(167.91,100.44) 167.81,100.44 CPU1.K12 167.3,100.95 166.87,100.95 CPU1.L12 ; CPU1.AR12 147.33,100.75 v1(147.01,100.42) 146.68,100.75 CPU1.AT12 ; CPU1.AA6 159.02,96.76 v1(159.42,96.36) 159.85,96.8 CPU1.W6 ; CPU1.J5 168.32,96.19 v1(168.64,96.5) 168.3,96.84 CPU1.J6 CPU1.K6 ; v1(155.29,101.04) 155.58,100.75 CPU1.AE12
  BOTTOM w0.305: JDIMM2.12 114.44,40.12 v1(114.57,40.25) ; JDIMM2.153 151.69,48.14 151.26,48.58 v1(150.17,48.58) 150.2,48.56 JDIMM2.147 ; JDIMM1.241 173.69,61.07 173.31,61.46 v1(173.07,61.46) ; JDIMM2.148 150.44,38.05 150.1,37.71 v1(149.93,37.71) ; JDIMM2.75 130.19,48.28 v1(130.34,48.43) ; JDIMM1.112 139.44,50.3 140.02,49.72 v1(140.32,49.72) ; JDIMM1.75 130.19,61.16 v1(130.04,61.31) ; JDIMM1.148 150.44,50.71 v1(150.19,50.45) ; JDIMM1.96 135.44,50.17 135.77,49.84 v1(135.96,49.84) ; v1(139.88,61.97) 140.09,61.97 140.69,61.36 JDIMM1.117 ; JDIMM2.111 139.2,47.2 139.2,48.53 139.73,49.06 v1(140.32,49.06) ; v1(119.69,48.45) JDIMM2.33 ; v1(167.53,49.79) 167.97,49.79 168.44,50.26 JDIMM1.220 ; JDIMM2.96 135.44,40.11 v1(135.26,40.29) ; JDIMM1.12 114.44,50.73 v1(114.66,50.52) ; JDIMM1.142 146.94,50.8 v1(146.63,50.48) ; v1(152.22,50.51) 151.94,50.78 JDIMM1.154 ; JDIMM1.124 142.44,50.75 v1(142.13,50.44) ; v1(124.73,50.48) 124.94,50.7 JDIMM1.54 ; v1(157.81,41.18) 157.95,41.04 157.95,39 JDIMM2.178 ; v1(142.13,48.49) 142.19,48.42 JDIMM2.123 ; v1(164,49.17) 163.19,48.37 JDIMM2.199 ; v1(168.55,37.71) 168.44,37.81 JDIMM2.220 ; JDIMM2.117 140.69,48.09 v1(140.32,48.46) ; JDIMM1.118 140.94,50.58 140.76,50.39 v1(140.32,50.39) ; JDIMM2.129 143.69,48.28 142.86,49.12 v1(142.12,49.12) ; JDIMM2.160 153.44,38.09 153.09,37.73 v1(151.64,37.73) 151.94,38.03 JDIMM2.154 ; JDIMM2.241 173.69,48.14 v1(173.31,48.53) ; v1(140.53,37.69) 140.94,38.1 JDIMM2.118 ; v1(145.75,37.71) 145.75,37.82 145.44,38.13 JDIMM2.136 ; JDIMM1.33 119.69,61.07 v1(119.53,61.24) ; JDIMM2.141 146.69,45.94 v1(146.76,45.88) ; v1(147.06,37.71) 146.95,37.82 146.95,39 JDIMM2.142 ; JDIMM2.54 124.94,40.2 v1(125.1,40.35) ; JDIMM1.160 153.44,50.96 152.39,49.91 v1(152.21,49.91) ; v1(142.25,37.69) 142.44,37.89 JDIMM2.124 ; JDIMM2.159 153.2,48.23 153.51,48.55 v1(153.77,48.55) 154.2,48.12 JDIMM2.163 ; JDIMM1.130 143.94,50.56 144.59,49.91 v1(145.62,49.91) 145.62,50.76 145.44,50.93 JDIMM1.136 ; v1(139.44,37.69) JDIMM2.112 ; JDIMM1.123 142.19,61.3 v1(142.14,61.36) ; JDIMM1.199 163.19,61.52 163.81,62.14 v1(164.54,62.14) ; JDIMM1.178 157.94,53.24 v1(158.07,53.37) ; CPU1.T6 CPU1.R6 ; v1(144.26,37.71) 143.95,38.02 143.95,39 JDIMM2.130 ; JDIMM1.141 146.69,61.22 145.58,62.33 v1(144.48,62.33) ; JDIMM1.135 145.19,61.06 144.93,61.33 144.55,61.33 v1(144.48,61.39) 144.1,61.39 143.72,61.01 143.69,61.01 JDIMM1.129 ; JDIMM2.135 145.2,48.36 145.41,48.58 v1(145.62,48.58)
  vias: v1(99.41,26.12) v1(99.41,25.48) v1(100.05,26.12) v1(100.05,25.48) v1(100.19,34.18) v1(100.17,33.52) v1(100.17,32.89) v1(100.17,32.25) v1(100.17,31.62) v1(100.75,33.84) v1(100.75,33.2) v1(100.75,32.57) v1(100.75,31.93) v1(100.76,31.32) v1(100.68,26.12) v1(100.68,25.48) v1(101.32,26.12) v1(101.32,25.48) v1(101.38,33.84) v1(101.38,33.2) v1(101.38,32.57) v1(101.38,31.93) v1(101.38,31.3) v1(101.95,26.12) v1(101.93,25.5) v1(108.14,39.63) v1(108.14,38.99) v1(108.14,38.36) v1(108.14,37.72) v1(108.14,37.09) v1(108.72,39.97) v1(108.71,39.31) v1(108.71,38.68) v1(108.71,38.04) v1(108.71,37.41) v1(108.71,36.77) v1(109.28,39.63) v1(109.28,38.99) v1(109.28,38.36) v1(109.28,37.72) v1(109.28,37.09) v1(109.85,39.31) v1(109.85,38.68) v1(109.85,38.04) v1(109.85,37.41) v1(109.85,36.77) v1(110.42,39.63) v1(110.42,38.99) v1(110.42,38.36) v1(110.42,37.72) v1(110.42,37.09) v1(128.62,96.46) v1(128.82,97.06) v1(139.88,62.61) v1(139.88,61.34) v1(142.14,62.63) v1(142.14,61.99) v1(150.82,61.26) v1(153.29,61.35) v4(136.79,80.23)
+1.2V_HDMI: length 20.8
  TOP w0.107: v1(219.87,149.59) 219.87,148.96 v2(219.58,148.67)
  IN3 w0.457: v1(221.75,160.5) 221.75,158.66 v1(222.42,157.98)
  BOTTOM w0.203: U1.15 v1(222.42,157.98) ; v1(222.42,156.74) 222.38,156.78 U1.18 ; CV444.1 214.22,156.19 214.81,156.78 U1.43 ; U1.27 219.96,153.05 220.8,152.22 CV441.1 ; U1.30 218.76,153.04 219.12,152.69 219.12,152.37 CV442.1 ; CV440.1 220.92,160.94 220.92,160.64 220.36,160.09 U1.11 ; CV443.1 214.07,157.98 U1.46
  BOTTOM w0.33: v1(214.19,156.83) 214.19,156.82 213.65,156.27 CV444.1
  BOTTOM w0.508: v1(221.75,160.5) 221.17,161.08 CV440.1 ; v1(221.94,152.13) 221.41,151.59 CV441.1 ; CV442.1 v1(219.9,152.35) ; CV443.1 v1(213.66,159.04)
  vias: v1(219.24,149.59)
+1.2V_VCCPLL_OC: length 11.1
  TOP w0.508: v1(131.25,102.79) 131.58,102.79 v2(132.29,102.07) 133.49,102.07 134.19,102.77 134.83,102.77 135.53,102.07 136.29,102.07 137.26,101.1 v1(137.86,101.1) ; RH530.1 v1(160.75,100.5)
  BOTTOM w0.203: v1(137.86,101.1) 137.73,101.1 CPU1.BH13
  BOTTOM w0.305: CPU1.G11 169.08,100.21 v1(168.76,99.87)
  BOTTOM w0.508: C11.1 130.64,102.79 v1(131.25,102.79)
+1.2VP: length 53.5
  IN3 w0.254: v1(96.47,30.64) 98.74,30.64 99.69,31.59 99.69,38.72 96.15,42.26 96.15,48.28 v1(95.83,48.6) 94.99,48.6 93.42,47.02 v1(93.42,46.45)
  IN3 w0.508: v1(96.85,31.15) 98.29,31.15 99.18,32.04 99.18,38.4 95.45,42.13 95.45,44.8 94.5,45.75 92.21,45.75 91.92,46.04 90.81,46.04 90.31,45.53 v1(90.31,44.48)
  BOTTOM w0.203: v1(90.31,44.48) 90.39,44.4 PU201.19 ; PU201.5 93.47,46.4 v1(93.42,46.45)
  BOTTOM w0.254: v1(95.83,48.6) 94.66,48.6 PR205.2
  vias: v1(94.08,27.39) v1(94.08,26.75) v1(94.08,26.12) v1(94.08,25.48) v1(94.71,27.39) v1(94.71,26.75) v1(94.71,26.12) v1(94.71,25.48) v1(95.35,27.39) v1(95.35,26.75) v1(95.35,26.12) v1(95.35,25.48) v1(95.98,27.39) v1(95.98,26.75) v1(95.98,26.12) v1(95.98,25.48) v1(96.62,27.39) v1(96.62,26.75) v1(96.62,26.12) v1(96.62,25.48) v2(94.75,24.54)
+1.5V_MEM_GFX: length 519.2
  TOP w0.254: CG101.1 230.07,108.1 v1(229.62,107.65) ; v1(226.17,104.6) 226.62,105.05 CG100.1 ; v1(249.07,103.4) 248.62,103.85 CG62.1 ; CG63.1 247.02,105.05 v1(247.47,104.6) ; CG60.1 245.42,102.65 v1(245.87,102.2) ; CG58.1 227.95,102.38 v1(227.77,102.2) ; CG44.1 245.61,107.32 v1(245.38,107.08)
  TOP w0.3: v1(250.67,134.8) 250.82,134.65 CG221.1 ; v1(236.67,134.8) 236.72,134.75 CG199.1 ; CG89.1 254.01,108.2 v1(252.37,108.2) ; CG194.1 243.51,134.8 v1(243.07,134.8) ; CG220.1 253.82,134.75 v1(253.87,134.8) ; v1(229.07,135.6) 229.16,135.51 CG160.1 ; v1(234.27,135.6) 234.36,135.69 CG190.1 234.92,136.25 v1(235.07,136.4) ; v1(247.47,134.8) 247.26,134.59 CG211.1 ; CG192.1 239.69,134.62 v1(239.87,134.8)
  TOP w0.305: RG104.2 247.39,135.68 v1(247.47,135.6)
  TOP w0.381: RG52.2 RG53.2 224.35,140.4 v1(224.35,140.4) ; CG261.1 276.59,103.35 v1(276.52,103.41) ; v1(211.87,134.8) 211.6,134.8 CG159.1 ; RG89.2 219.14,139.94 v1(219.47,139.6) ; RG63.1 252.94,113.57 v1(252.37,113) ; CG157.1 208.86,140.59 v1(208.67,140.4) ; CG283.1 277.32,87.04 v1(277.32,87.81) ; CG166.1 222.82,134.65 v1(222.67,134.8) ; CG259.1 279.33,111.8 v1(279.72,111.41) ; CG90.1 246.47,106.4 v1(245.87,105.8) 245.48,105.41 CG102.1 ; CG53.1 246.13,95.26 v1(245.87,95) ; v1(230.82,109.25) 231.45,108.62 RG64.1 ; v1(246.47,108.25) 246.47,108.38 CG54.1 ; v1(243.07,139.6) 243.17,139.5 CG197.1 ; CG59.1 227.44,105.47 v1(227.77,105.8) ; CG163.1 209.75,136.25 209.06,136.94 v1(208.8,136.94) ; v1(223.47,141.67) CG152.1 ; v1(237.72,141.6) 237.5,141.83 236.9,141.83 236.69,142.04 CG202.1 236.6,141.96 CG203.1 ; v1(247.47,143.6) 247.43,143.56 CG212.1 ; CG245.1 281.76,125.85 v1(281.32,125.41) ; v1(224.15,134.91) CG176.1 ; CG172.1 229.13,133.26 v1(229.07,133.2) ; CG287.1 280.03,93.72 v1(280.52,94.21) ; v1(240.42,107.65) 240.22,107.65 RG62.1 ; CG178.1 208.72,142.85 v1(208.67,142.8) ; CG191.1 243.3,143.37 v1(243.07,143.6) ; CG69.1 244.65,89.83 v1(245.12,90.3) ; v1(279.72,125.41) 280.36,126.05 CG238.1 ; RG55.2 RG56.2 ; v1(280.52,91.01) 280.52,91.18 279.99,91.71 CG284.1 ; CG52.1 248.03,92.04 v1(247.47,92.6) ; v1(235.07,138.8) 235.03,138.84 CG200.1 ; CG167.1 226.65,132.42 v1(226.67,132.4) ; v1(243.07,142) 243.3,142.23 CG201.1 ; v1(276.52,89.41) 276.66,89.27 CG285.1 ; RG54.2 239.69,140.58 v1(239.87,140.4) ; CG177.1 225.28,134.8 v1(225.87,134.8) ; v1(224.57,107) 225.25,106.32 CG61.1 ; CG174.1 208.61,134.74 v1(208.67,134.8) ; v1(233.47,139.6) 233.21,139.87 CG195.1 ; v1(278.12,91.01) 278.15,91.04 CG282.1 ; RG83.1 246.33,101.74 v1(245.87,102.2) ; v1(249.07,90.2) 248.81,90.46 CG88.1 ; v1(278.12,94.21) 278.25,94.08 CG278.1 ; v1(252.72,141.2) CG210.1 ; CG198.1 233.46,143.61 v1(233.47,143.6) ; CG171.1 218.58,145.49 v1(218.66,145.57) ; v1(251.59,144.22) CG217.1 ; v1(249.07,138.8) 249.25,138.98 CG208.1 ; CG99.1 228.09,106.51 v1(228.42,106.84) 228.42,106.92 228.8,107.31 CG55.1
  TOP w0.4: v1(245.87,91.4) 246.36,91.89 RG84.1
  TOP w0.457: v1(279.72,97.41) 279.21,97.93 CG275.1 ; v1(281.32,97.41) 281.32,97.48 280.98,97.82 CG279.1
  TOP w0.508: v1(235.41,146.73) CG185.1 ; CG257.1 277.41,111.5 v1(277.32,111.41) ; v1(225.42,147.4) 225.68,147.14 226.42,147.14 CV37.2 ; v1(277,107.73) 277.42,107.3 RG72.2 RG73.2 ; CG255.1 276.53,109.82 v1(276.52,109.81) ; CG193.1 CG189.1 v1(238.58,143.21) ; RG71.2 274.29,127.26 v1(274.14,127.41) ; v1(253.87,140.4) 253.7,140.4 253.24,139.94 RG55.2 ; v1(222.53,145.53) 222.46,145.6 CG165.1 ; v1(279.72,115.81) 279.79,115.74 CG236.1 ; v1(242.34,145.67) CG204.1 ; v1(275.72,89.41) 275.72,91.28 276.3,91.85 CG272.1 ; v1(229.07,143.6) 229.12,143.55 CG154.1 ; v1(278.12,115.81) 278.12,115.6 277.75,115.22 CG240.1 CG239.1 ; CG286.1 276.55,95.78 v1(276.52,95.81) ; CG250.1 279.54,107.44 v1(279.78,107.68) ; v1(282.12,108.21) 281.89,107.98 CG247.1 ; v1(281.32,111.41) 281.11,111.62 CG249.1 ; v1(215.07,143.6) 215.11,143.64 CG150.1 ; CG243.1 276.61,115.1 277.32,115.8 v1(277.32,115.81) ; RG127.1 CG227.1 277.46,100.96 277.46,101.68 v1(277.32,101.81) ; v1(276.52,75.41) 276.69,75.24 CG297.1 ; v1(273.32,83.41) 273.57,83.66 273.57,84.3 274.28,85.01 RG130.2 ; RG58.2 RG57.2 210.47,139.24 211.62,140.4 v1(211.87,140.4) ; v1(281.31,72.17) 281.2,72.05 CG292.1 ; CG156.1 215.12,139.55 v1(215.07,139.6) ; v1(234.52,146.73) RG113.1 ; v1(238.14,146.73) RG109.1 ; v1(225.87,141.2) 225.68,141.01 CG170.1 ; RG54.2 RG59.2 ; CG242.1 277.59,126.92 v1(278.08,127.41) ; v1(269.32,87.81) 269.32,87.32 268.99,86.99 CG126.1 ; RG74.2 RG75.2 274.86,99.17 273.32,97.63 v1(273.32,97.41) ; RG77.2 RG76.2 276.49,77.32 v1(276.49,77.81) ; v1(237.76,143.25) CG188.1 ; v1(210.63,142.78) CG179.1 ; v1(281.32,83.41) 281.32,83.52 281.83,84.03 282.54,84.03 282.9,83.67 CG303.1 ; v1(281.32,115.81) 281.32,115.8 281.76,115.37 CG230.1 280.82,114.9 CG244.1 ; RG116.2 v1(274.2,113.01) ; v1(278.39,70.05) 278.57,70.23 RG141.1 CG269.1 ; CG155.1 215.9,134.99 215.26,134.99 v1(215.07,134.8) ; CG151.1 219.26,143.6 v1(219.47,143.6) ; v1(239.03,146.73) CG181.1 ; v1(208.67,132.4) 208.84,132.57 CG147.1 ; v1(225.87,142.8) 225.99,142.92 CG169.1 ; v1(279.72,101.81) 279.76,101.78 CG262.1 ; v1(229.07,139.6) 229.08,139.6 230.2,140.72 CG143.1 RG99.1 ; CG253.1 280.36,105.72 279.78,105.14 CG254.1 v1(279.78,104.17) ; v1(207.84,145.45) 207.52,145.13 CG161.1 ; CG263.1 280.41,108.32 v1(280.52,108.21) ; RG80.1 257.44,90.9 257.95,90.39 257.95,88 v1(257.86,87.92) ; v1(215.02,145.46) CG173.1 ; CG252.1 281.57,101.57 v1(281.32,101.81) ; RG70.2 276.01,127.26 276.03,127.24 CG231.1 276.86,127.24 v1(277.23,127.6)
  BOTTOM w0.109: v1(265.08,125.47) v2(264.36,125.47)
  BOTTOM w0.254: UG20.D14 271.32,72.41
  BOTTOM w0.3: v1(272.52,94.21) UG19.N10 ; UG13.B12 v1(207.07,143.6) ; UG14.T3 v1(221.07,143.6) ; v1(233.47,143.6) UG15.B14 ; v1(205.47,143.6) UG13.B14 ; v1(219.47,143.6) UG14.T1 ; v1(272.52,80.21) UG20.E5 ; UG17.T14 v1(269.32,125.41) ; v1(269.32,111.41) UG18.B1
  BOTTOM w0.305: UG20.G14 v1(273.32,73.81) 272.92,73.41 UG20.F14 ; v1(281.32,89.41) 280.92,89.01 UG19.B3 ; UG17.L4 v1(274.12,117.41) UG17.K3 ; UG18.L2 v1(277.32,110.61) UG18.M3 ; UG20.L13 276.92,74.21 v1(277.32,74.61) 277.72,75.01 UG20.M12 ; UG13.F12 v1(207.07,139.6) UG13.G11 ; UG20.E10 272.12,76.61 v1(272.52,77.01) ; v1(243.07,135.6) 243.47,136 UG15.L1 ; UG18.P3 v1(279.72,109.81) ; v1(281.32,83.41) 280.92,83.81 UG20.T1 ; UG19.G11 v1(276.52,95.81) UG19.H12 ; v1(281.32,97.41) 280.92,97.81 UG19.B14 ; UG20.D3 v1(270.92,81.81) ; UG17.E10 v1(278.12,122.21) ; v1(249.07,131.6) 248.67,132 UG16.B3 ; UG17.M12 272.92,124.21 v1(273.32,124.61) UG17.L13 ; UG19.K12 v1(274.12,95.81) 273.72,95.41 UG19.L11 ; UG17.C10 v1(280.52,122.21) ; UG19.D12 v1(279.72,95.81) 279.32,95.41 UG19.D11 ; UG16.P1 v1(247.47,142) ; UG16.G2 247.87,136 v1(248.27,135.6) UG16.F3 ; UG17.P12 v1(270.92,123.81) UG17.P11 ; UG13.L11 v1(207.07,135.6) UG13.M12 ; UG17.F12 v1(277.32,124.61) UG17.G13 ; UG20.B12 269.72,75.01 v1(269.32,75.41) ; UG16.L4 v1(249.07,138.8) UG16.K3 ; UG18.K3 v1(276.52,109.81) UG18.L4 ; UG17.F1 277.72,115.41 v1(278.12,115.81) ; UG15.B12 v1(235.07,143.6) ; UG20.G1 v1(273.32,83.41) ; v1(213.47,143.6) 213.87,143.2 UG13.B3 ; UG17.F14 v1(277.32,125.41) 276.92,125.81 UG17.G14 ; UG16.L13 256.67,139.2 v1(256.27,139.6) UG16.M12 ; UG15.L11 v1(235.07,136.4) UG15.K12 ; UG16.G4 v1(249.07,136.4) 248.67,136.8 UG16.H3 ; UG19.B12 v1(281.32,95.81) ; v1(277.32,87.81) 276.92,87.41 UG19.G1 ; UG14.L11 v1(227.47,138.8) 227.87,138.4 UG14.K12 ; UG16.D14 257.47,133.6 v1(257.07,133.2) ; v1(247.47,131.6) 247.07,132 UG16.B1 ; UG18.G1 v1(273.32,111.41) ; UG16.R10 v1(253.87,142.8) ; UG20.D1 v1(270.92,83.41) ; UG17.G1 276.92,115.41 v1(277.32,115.81) ; UG13.P14 205.07,133.6 v1(205.47,133.2) ; v1(213.47,131.6) 213.87,132 UG13.T3 ; v1(281.32,73.81) 280.92,73.41 UG20.T14 ; UG17.C5 280.12,118.61 v1(280.52,119.01) ; UG15.H12 234.67,138.4 v1(235.07,138.8) UG15.G11 ; v1(247.47,134.8) 247.07,135.2 UG16.F1 ; UG18.G13 v1(273.32,102.61) UG18.F12 ; v1(240.67,132.4) 240.27,132.8 UG15.R5 ; UG15.E5 v1(239.87,140.4) ; v1(257.07,135.6) 257.47,136 UG16.G14 ; UG15.L14 233.07,136 v1(233.47,135.6) UG15.M14 ; UG19.M1 272.92,87.41 v1(273.32,87.81) UG19.L1 ; UG13.T12 206.67,132 v1(207.07,131.6) ; UG20.L11 276.92,75.81 v1(276.52,75.41) ; v1(243.07,143.6) 243.47,143.2 UG15.B1 ; v1(222.67,142.8) 222.27,142.4 UG14.R5 ; UG16.M1 v1(247.47,140.4) ; UG14.B3 220.67,132 v1(221.07,131.6) ; UG14.P11 227.07,141.6 v1(227.47,142) 227.87,141.6 UG14.P12 ; UG16.L11 v1(255.47,138.8) 255.87,138.4 UG16.K12 ; v1(270.92,73.81) UG20.D14 ; UG19.M12 272.92,96.21 v1(273.32,96.61) UG19.L13 ; v1(243.07,140.4) 243.47,140 UG15.F1 ; v1(249.07,143.6) UG16.T3 ; v1(275.72,74.61) 276.12,75.01 UG20.K12 ; UG13.L1 215.47,136 v1(215.07,135.6) ; UG17.K12 v1(274.12,123.81) 273.72,123.41 UG17.L11 ; UG15.L4 241.07,136 v1(241.47,136.4) 241.87,136.8 UG15.K3 ; UG14.L1 v1(219.47,139.6) UG14.M1 ; v1(281.32,125.41) 280.92,125.81 UG17.B14 ; UG15.G1 243.47,139.2 v1(243.07,139.6) ; UG17.B3 280.92,117.01 v1(281.32,117.41) ; UG15.D14 v1(233.47,142) ; UG14.T12 227.87,143.2 v1(227.47,143.6) ; UG18.P12 279.32,103.01 v1(279.72,103.41) UG18.P11 ; v1(279.72,87.81) 279.32,87.41 UG19.D1 ; UG18.D12 v1(270.92,103.41) 271.32,103.81 UG18.D11 ; UG14.P14 229.47,141.6 v1(229.07,142) ; UG14.F12 227.87,135.2 v1(228.27,135.6) 228.67,136 UG14.G13 ; UG14.L14 229.47,139.2 v1(229.07,139.6) 229.47,140 UG14.M14 ; v1(279.72,73.81) 279.32,73.41 UG20.P14 ; UG13.N5 v1(211.87,134.8) ; UG14.B12 227.87,132 v1(227.47,131.6) ; v1(270.12,118.21) 270.52,118.61 UG17.R5 ; UG18.F3 272.92,110.21 v1(273.32,110.61) UG18.G2 ; UG20.F3 272.92,82.21 v1(273.32,82.61) UG20.G2 ; v1(277.32,111.41) 276.92,111.81 UG18.L1 ; UG20.F12 v1(273.32,74.61) UG20.G13 ; v1(279.72,89.41) 279.32,89.01 UG19.D3 ; UG16.D11 v1(255.47,133.2) 255.87,133.6 UG16.D12 ; UG16.T12 255.87,143.2 v1(255.47,143.6) ; v1(213.47,133.2) 213.87,133.6 UG13.P3 ; UG19.R10 v1(270.12,95.01) ; v1(279.72,117.41) 279.32,117.01 UG17.D3 ; v1(269.32,101.81) 269.72,101.41 UG18.B14 ; UG20.C5 v1(270.12,81.01) ; UG14.K3 220.67,138.4 v1(221.07,138.8) UG14.L4 ; UG19.C10 v1(280.52,94.21) ; UG15.N10 236.27,134.4 v1(236.67,134.8) ; UG13.M3 213.87,135.2 v1(214.27,135.6) 214.67,136 UG13.L2 ; UG16.N10 v1(253.87,140.4) ; UG17.H12 v1(276.52,123.81) UG17.G11 ; UG17.P3 v1(270.92,117.41) ; UG14.E5 222.27,134.4 v1(222.67,134.8) ; UG20.R5 v1(280.52,80.21) ; UG15.M3 241.87,135.2 v1(242.27,135.6) 242.67,136 UG15.L2 ; UG16.H12 255.87,136.8 v1(255.47,136.4) 255.07,136 UG16.G11 ; UG13.G13 v1(206.27,138.8) UG13.H12 ; v1(281.32,111.41) 280.92,111.81 UG18.T1 ; v1(280.52,77.01) 280.12,76.61 UG20.R10 ; v1(241.47,142) 241.87,141.6 UG15.D3 ; UG14.D11 v1(227.47,133.2) 227.87,133.6 UG14.D12 ; UG17.D11 279.32,123.41 v1(279.72,123.81) UG17.D12 ; UG16.L14 257.47,139.2 v1(257.07,139.6) 257.47,140 UG16.M14 ; UG19.L14 v1(273.32,97.41) 272.92,97.81 UG19.M14 ; UG17.L2 v1(273.32,116.61) UG17.M3 ; UG13.P12 206.67,133.6 v1(207.07,133.2) 207.47,133.6 UG13.P11 ; UG13.N10 208.27,134.4 v1(208.67,134.8) ; v1(279.72,83.41) 279.32,83.81 UG20.P1 ; UG19.B1 280.92,87.41 v1(281.32,87.81) ; UG18.M1 277.72,111.81 v1(278.12,111.41) ; UG20.N10 v1(278.12,77.01) ; UG15.D1 243.47,141.6 v1(243.07,142) ; UG14.P3 v1(221.07,142) ; v1(215.07,139.6) 215.47,139.2 UG13.G1 ; UG13.D14 v1(205.47,142) ; UG14.F3 v1(220.27,135.6) 219.87,136 UG14.G2 ; v1(269.32,89.41) 269.72,89.01 UG19.T3 ; UG14.G14 229.47,136 v1(229.07,135.6) UG14.F14 ; UG13.R10 208.27,132.8 v1(208.67,132.4) ; UG13.B1 215.47,143.2 v1(215.07,143.6) ; UG19.P12 v1(270.92,95.81) UG19.P11 ; UG14.N10 v1(225.87,141.2) ; UG18.M12 277.72,103.01 v1(277.32,102.61) 276.92,102.21 UG18.L13 ; UG15.F3 v1(242.27,139.6) 242.67,139.2 UG15.G2 ; UG13.M14 205.07,135.2 v1(205.47,134.8) ; UG20.P11 v1(279.72,75.41) 279.32,75.01 UG20.P12 ; UG13.R5 212.27,132.8 v1(211.87,132.4) ; v1(281.32,75.41) 280.92,75.01 UG20.T12 ; v1(208.67,140.4) UG13.E10 ; UG13.G14 v1(205.47,139.6) UG13.F14 ; UG14.D14 229.47,133.6 v1(229.07,133.2) ; UG18.L11 276.92,103.81 v1(276.52,103.41) ; v1(255.47,131.6) 255.87,132 UG16.B12 ; UG13.D12 v1(207.07,142) UG13.D11 ; v1(243.07,134.8) 243.47,135.2 UG15.M1 ; v1(219.47,131.6) 219.07,132 UG14.B1 ; UG14.M3 v1(220.27,139.6) UG14.L2 ; UG18.N5 v1(278.12,108.21) ; UG13.L4 213.07,136 v1(213.47,136.4) 213.87,136.8 UG13.K3 ; v1(272.52,122.21) UG17.N10 ; UG20.B14 269.72,73.41 v1(269.32,73.81) ; UG19.G13 276.92,97.01 v1(277.32,96.61) UG19.F12 ; UG15.H3 241.87,138.4 v1(241.47,138.8) UG15.G4 ; v1(249.87,132.4) 250.27,132.8 UG16.C5 ; UG18.M14 v1(277.32,101.81) 276.92,101.41 UG18.L14 ; UG17.L14 v1(273.32,125.41) ; v1(219.47,133.2) 219.07,133.6 UG14.D1 ; UG16.F12 255.87,135.2 v1(256.27,135.6) 256.67,136 UG16.G13 ; UG13.C10 208.27,142.4 v1(208.67,142.8) ; v1(243.07,131.6) 243.47,132 UG15.T1 ; UG18.F1 v1(272.52,111.41) ; v1(272.52,119.01) 272.12,118.61 UG17.N5 ; UG17.P1 v1(270.92,115.81) ; UG14.G11 227.07,136 v1(227.47,136.4) 227.87,136.8 UG14.H12 ; v1(236.67,142.8) 236.27,142.4 UG15.C10 ; UG15.E10 v1(236.67,140.4) ; v1(247.47,135.6) 247.07,136 UG16.G1 ; v1(219.47,135.6) 219.07,136 UG14.G1 ; UG20.T3 v1(281.32,81.81) ; UG19.E5 v1(278.12,91.01) ; v1(272.52,91.01) 272.12,90.61 UG19.N5 ; UG18.F14 272.92,101.41 v1(273.32,101.81) UG18.G14 ; UG19.K3 v1(274.12,89.41) UG19.L4 ; v1(279.72,111.41) 279.32,111.81 UG18.P1 ; UG20.M3 v1(277.32,82.61) 276.92,83.01 UG20.L2 ; UG15.M12 v1(234.27,135.6) 233.87,136 UG15.L13 ; UG18.G11 v1(274.12,103.41) UG18.H12 ; v1(269.32,115.81) 269.72,115.41 UG17.T1 ; UG13.K12 v1(206.27,136.4) UG13.L13 v1(205.47,135.6) 205.07,136 UG13.L14 ; v1(250.67,134.8) 250.27,134.4 UG16.E5 ; v1(215.07,131.6) 215.47,132 UG13.T1 ; UG19.F1 277.72,87.41 v1(278.12,87.81) ; UG15.P11 235.47,133.6 v1(235.07,133.2) 234.67,133.6 UG15.P12 ; UG19.L2 v1(273.32,88.61) UG19.M3 ; UG20.P3 v1(279.72,81.81) ; UG20.M1 277.72,83.81 v1(278.12,83.41) ; UG18.B3 v1(269.32,109.81) ; UG14.B14 229.47,132 v1(229.07,131.6) ; UG15.P3 241.87,133.6 v1(241.47,133.2) ; v1(205.47,131.6) 205.07,132 UG13.T14 ; v1(250.67,142.8) 250.27,142.4 UG16.R5 ; UG15.D12 v1(235.07,142) UG15.D11 ; v1(233.47,133.2) 233.07,133.6 UG15.P14 ; UG16.P12 255.87,141.6 v1(255.47,142) UG16.P11 ; v1(270.12,76.21) 270.52,76.61 UG20.C10 ; v1(257.07,134.8) 257.47,135.2 UG16.F14 ; UG13.M1 215.47,135.2 v1(215.07,134.8) ; UG15.P1 243.47,133.6 v1(243.07,133.2) ; UG20.G4 273.72,81.41 v1(274.12,81.81) UG20.H3 ; UG13.E5 v1(211.87,140.4) ; UG14.P1 v1(219.47,142) ; v1(257.07,143.6) 257.47,143.2 UG16.T14 ; UG17.D14 279.32,125.81 v1(279.72,125.41) ; v1(226.67,132.4) 226.27,132.8 UG14.C10 ; UG19.G14 276.92,97.81 v1(277.32,97.41) UG19.F14 ; UG16.E10 v1(253.87,134.8) ; UG17.B1 280.92,115.41 v1(281.32,115.81) ; UG15.R10 v1(235.87,133.2) ; v1(270.12,90.21) 270.52,90.61 UG19.R5 270.77,90.86 270.77,91.19 ; UG14.F1 219.07,135.2 v1(219.47,134.8) ; v1(215.07,133.2) 215.47,133.6 UG13.P1 ; v1(281.32,103.41) 280.92,103.01 UG18.T12 ; v1(269.32,103.41) 269.72,103.01 UG18.B12 ; v1(279.72,101.81) 279.32,101.41 UG18.P14 ; UG16.M3 v1(248.27,139.6) UG16.L2 ; UG19.G4 276.92,89.81 v1(276.52,89.41) ; v1(280.52,105.01) 280.12,104.61 UG18.R10 ; UG18.T3 v1(281.32,109.81) ; UG18.D3 v1(270.92,109.81) ; v1(229.07,143.6) 229.47,143.2 UG14.T14 ; UG18.T14 280.92,101.41 v1(281.32,101.81) ; v1(269.32,87.81) 269.72,87.41 UG19.T1 ; UG19.G2 276.92,88.21 v1(277.32,88.61) 277.72,89.01 UG19.F3 ; UG20.L1 276.92,83.81 v1(277.32,83.41) ; UG19.D14 279.32,97.81 v1(279.72,97.41) ; UG19.T12 v1(269.32,95.81) ; v1(279.72,115.81) 279.32,115.41 UG17.D1 ; UG13.F1 215.47,140 v1(215.07,140.4) ; v1(215.07,142) 215.32,141.75 UG13.D1 ; UG14.D3 220.67,133.6 v1(221.07,133.2) ; UG14.H3 220.67,136.8 v1(221.07,136.4) UG14.G4 ; UG14.E10 v1(225.87,134.8) ; UG20.B3 v1(269.32,81.81) ; v1(241.47,131.6) 241.87,132 UG15.T3 ; UG18.D14 v1(270.92,101.81) ; UG19.P1 v1(270.92,87.81) ; UG15.F12 v1(234.27,139.6) UG15.G13 ; UG20.B1 v1(269.32,83.41) ; UG18.C5 v1(270.12,109.01) ; v1(235.07,131.6) 234.67,132 UG15.T12 ; v1(270.12,104.21) 270.52,104.61 UG18.C10 ; UG13.G4 213.07,139.2 v1(213.47,139.6) 213.87,140 UG13.F3 ; v1(272.52,105.01) 272.12,104.61 UG18.E10 ; UG17.M1 v1(272.52,115.81) ; UG17.M14 v1(272.52,125.41) ; UG13.D3 v1(213.47,142) ; UG17.P14 v1(270.92,125.41) ; v1(247.47,143.6) UG16.T1 ; v1(280.52,91.01) 280.12,90.61 UG19.C5 ; UG20.M14 v1(277.32,73.81) 276.92,73.41 UG20.L14 ; v1(221.87,132.4) 222.27,132.8 UG14.C5 ; UG19.P14 v1(270.92,97.41) ; UG16.P14 257.47,141.6 v1(257.07,142) ; UG18.N10 v1(278.12,105.01) ; UG17.F3 277.72,117.01 v1(277.32,116.61) 276.92,116.21 UG17.G2 ; UG17.T3 269.72,117.01 v1(269.32,117.41) ; UG16.D1 247.07,133.6 v1(247.47,133.2) ; v1(241.47,143.6) 241.87,143.2 UG15.B3 ; UG20.D12 v1(270.92,75.41) 271.32,75.81 UG20.D11 ; UG15.F14 v1(233.47,139.6) UG15.G14 ; UG18.D1 v1(270.92,111.41) ; UG15.N5 v1(239.87,134.8) ; UG14.M12 v1(228.27,139.6) 228.67,139.2 UG14.L13 ; UG16.D3 248.67,133.6 v1(249.07,133.2) ; UG17.T12 v1(269.32,123.81) ; UG18.H3 v1(274.12,109.81) 273.72,109.41 UG18.G4 ; UG20.G11 v1(274.12,75.41) UG20.H12 ; UG17.B12 v1(281.32,123.81) ; UG17.R10 v1(270.12,123.01) ; UG15.T14 233.07,132 v1(233.47,131.6) ; UG19.P3 v1(270.92,89.41) ; UG18.R5 v1(280.52,108.21) ; UG16.P3 v1(249.07,142) ; UG20.K3 v1(276.52,81.81) UG20.L4 ; UG13.H3 213.87,138.4 v1(214.27,138.8) 214.67,139.2 UG13.G2 ; UG15.C5 v1(239.87,142.8) ; UG19.T14 v1(269.32,97.41) ; UG17.G4 276.92,117.81 v1(276.52,117.41) 276.12,117.01 UG17.H3 ; UG19.E10 v1(278.12,94.21) ; UG16.L1 v1(247.47,139.6) ; UG16.N5 v1(250.67,140.4) ; UG18.E5 v1(272.52,108.21) ; v1(257.07,131.6) 257.47,132 UG16.B14 ; UG14.N5 v1(222.67,140.4) ; UG13.C5 v1(211.87,142.8) ; v1(254.67,132.4) 254.27,132.8 UG16.C10 ; UG20.N5 v1(278.12,80.21) ; UG20.F1 v1(272.52,83.41) ; UG17.E5 v1(278.12,119.01) ; UG14.R10 v1(225.87,142.8) ; UG17.L1 v1(273.32,115.81)
  BOTTOM w0.381: UG1.N25 233.71,107.2 v1(233.22,107.69) ; UG18.K12 276.12,103.01 v1(275.72,102.61) ; UG19.H3 v1(275.72,89.41)
  BOTTOM w0.4: UG1.J18 241.47,110.85 v1(241.62,110.85) ; UG1.G15 243.87,112.45 v1(244.02,112.45) ; UG1.AF9 249.07,93.95 v1(249.07,93.8) ; UG1.M12 v1(246.47,108.25) ; v1(243.98,107.67) 243.51,107.2 UG1.N15 ; UG1.P35 224.57,106.85 v1(224.57,107) ; v1(226.02,112.45) 226.17,112.45 UG1.G33 ; UG1.G11 247.38,112.36 v1(247.6,112.36) ; v1(245.22,110.85) 245.07,110.85 UG1.J14 ; v1(239.22,111.66) 239.48,111.66 UG1.G19 ; v1(228.42,110.85) 228.57,110.85 UG1.J30 ; UG1.W31 227.97,101.85 227.77,102.05 v1(227.77,102.2) ; v1(221.27,108.2) 221.27,108.05 UG1.M39 ; v1(251.22,114.15) 251.07,114.15 UG1.E6 ; v1(242.82,87.95) 242.67,87.95 UG1.AN17 ; UG1.N19 240.27,107.65 v1(240.42,107.65) ; UG1.AK9 249.07,90.35 v1(249.07,90.2) ; UG1.AU11 247.47,84.75 v1(247.62,84.75) ; v1(245.87,95) 245.87,95.15 UG1.AE13 ; v1(246.42,83.05) 246.27,83.05 UG1.AW12 ; UG1.L17 242.67,109.25 v1(242.82,109.25) ; UG1.Y11 247.47,100.85 v1(247.47,101) ; UG1.P30 228.58,106.84 v1(228.42,106.84) ; UG1.M5 252.37,108.05 v1(252.37,108.2) ; v1(252.37,113) 252.37,112.85 UG1.F5 ; v1(242.82,83.05) 242.67,83.05 UG1.AW17 ; UG1.U5 251.47,103.55 v1(251.47,103.4) ; UG1.G29 229.77,112.45 v1(229.62,112.45) ; UG1.W13 245.87,102.05 v1(245.87,102.2) ; v1(247.47,98.6) 248.02,98.6 UG1.AC9 ; v1(244.02,89.55) 243.87,89.55 UG1.AL15 ; v1(236.82,109.25) 236.82,109.8 UG1.J23 ; UG1.AR18 241.47,86.35 v1(241.62,86.35) ; v1(227.77,105.8) 227.77,105.65 UG1.R31 ; v1(247.47,96.2) 247.47,96.35 UG1.AD11 ; v1(250.67,91.4) 250.67,91.55 UG1.AJ7 ; UG1.U11 247.47,104.45 v1(247.47,104.6) ; UG1.AJ13 245.87,91.55 v1(245.87,91.4) ; v1(250.67,87.8) 250.67,87.95 UG1.AN7 ; UG1.G25 234.17,111.65 v1(234.42,111.65) ; v1(241.62,113.25) 241.77,113.25 UG1.E17 ; UG1.P14 244.98,106.4 245.38,106.8 v1(245.38,107.08) ; v1(244.02,84.75) 243.87,84.75 UG1.AU15 ; v1(251.47,93.8) 251.47,93.65 UG1.AG5 ; v1(239.22,114.15) 239.07,114.15 UG1.E20 ; UG1.AL19 240.27,89.55 v1(240.42,89.55) ; UG1.R37 222.97,105.65 v1(222.97,105.8) ; UG1.N29 229.77,107.65 v1(229.62,107.65) ; v1(230.82,109.25) 230.97,109.25 UG1.L27 ; UG1.R13 245.87,105.65 v1(245.87,105.8) ; v1(239.22,87.95) 239.07,87.95 UG1.AN20 ; UG1.Y33 226.17,100.85 v1(226.17,101) ; UG1.V9 249.07,103.25 v1(249.07,103.4) ; v1(245.22,86.35) 245.07,86.35 UG1.AR14 ; v1(224.57,103.4) 224.57,103.25 UG1.V35 ; UG1.L24 234.57,109.25 v1(234.42,109.25) ; v1(221.27,104.6) 221.27,104.45 UG1.U39 ; v1(252.37,89) 252.37,89.15 UG1.AM5 ; v1(239.22,109.25) 239.07,109.25 UG1.L20 ; UG1.L37 222.97,109.25 v1(222.97,109.4) ; UG1.AG11 247.47,92.75 v1(247.47,92.6) ; UG1.J26 232.17,110.85 v1(232.02,110.85) ; v1(249.87,96.2) 249.87,95.95 UG1.AE7 ; UG1.W7 249.87,101.25 v1(249.87,101) ; UG1.E32 227.37,114.15 v1(227.22,114.15) ; v1(245.12,90.3) UG1.AK14 ; v1(250.67,105.8) 250.67,105.65 UG1.R7 ; UG1.E27 231.87,113.25 v1(232.02,113.25) ; UG1.E12 246.27,114.15 v1(246.42,114.15) ; UG1.U33 226.41,104.21 226.17,104.45 v1(226.17,104.6)
  BOTTOM w0.508: RG137.1 CG265.1 265.79,73.83 CG290.1 265.78,72.97 266.88,71.87 v1(268.53,71.87) ; v1(264.99,101.65) 265.2,101.86 CG248.1 265.79,101.86 CG222.1 RG123.1 ; CG128.1 CG127.1 259.45,87.41 258.94,87.92 v1(257.86,87.92) ; CG175.1 218.84,129.08 CG162.1 218.9,128.78 219.41,128.28 220.34,128.28 v1(220.67,128.61) ; CG280.1 v1(283.22,97.44) ; CG241.1 283.26,117.76 v1(283.17,117.85) ; v1(218.66,145.57) CG146.1 ; CG149.1 206.87,127.12 v1(206.38,127.6) ; v1(252.95,145.55) RG108.1 ; v1(272.59,129.77) CG226.1 ; v1(261.37,136.51) RG112.1 ; v1(257.63,129.58) CG209.1 ; CG139.1 207.03,128.11 206.83,128.11 206.51,128.43 v1(206.45,128.43) ; CG129.1 225.77,120.51 v1(226.83,121.57) ; CG158.1 203.09,140.42 v1(203.34,140.18) ; 270.77,91.19 270.77,91.47 270.26,91.98 268.68,91.98 267.78,91.08 266.15,91.08 265.79,91.44 CG264.1 RG136.1 ; CG246.1 v1(283.23,102.08) ; CV36.2 232.89,146.87 v1(233.02,146.74) ; CG301.1 CG299.1 v1(283.84,84.8) ; CG288.1 v1(283.23,88.55) ; v1(203.37,134.14) 202.33,134.14 201.8,134.67 CG142.1 RG98.1 ; v1(259.15,143.99) 259.39,143.75 CG216.1 ; CG168.1 203.58,143.62 v1(204.16,143.03) ; CG251.1 v1(283.23,104.62) ; CG206.1 259.58,142.74 v1(259.24,142.4) ; CG291.1 270.47,71.29 271.32,72.15 271.32,72.41 ; CG304.1 v1(283.84,78.65) ; v1(270.56,127.64) CG233.1 ; v1(224.1,127.28) 223.66,127.72 CG164.1 CG138.1 ; CG300.1 280.41,71.27 v1(281.31,72.17) ; CG258.1 v1(283.23,103.35) ; CG3000.1 285.17,72.65 285.17,72.65 283.87,72.65 v1(283.84,72.68) CG296.1 CG293.1 ; RG122.1 CG223.1 v1(265.08,125.47) ; v1(259.23,141.09) CG207.1 ; CG260.1 v1(283.22,109.82) ; CG274.1 v1(283.23,90.84) ; CG305.1 277.88,71.09 v1(277.69,70.9) ; CG289.1 v1(283.18,77.44) ; v1(261.37,135.63) CG184.1 ; CG148.1 RG95.1 v1(211.77,128.01) ; v1(283.07,119.35) CG234.1 ; CG213.1 CG215.1 259.84,134.26 260.43,134.84 v1(261.12,134.84) ; CG277.1 v1(283.23,94.14) ; v1(285.29,124.51) CG237.1 ; v1(283.09,120.81) CG235.1 ; v1(273.55,129.77) RG126.1 ; CG180.1 256.11,127.67 v1(255.77,127.33) ; v1(259.23,140.07) CG218.1 ; CG256.1 v1(283.23,101.12) ; CG295.1 v1(283.84,75.03) ; v1(283.23,95.47) CG268.1 RG140.1 ; v1(223.39,145.53) RG94.1 ; v1(271.58,127.64) CG232.1 ; CG298.1 CG302.1 283.84,80.55 v1(283.35,80.05) ; CG276.1 v1(283.84,86.46) ; v1(261.37,129) 260.35,129 259.84,129.51 CG214.1 CG219.1 ; CG281.1 v1(283.23,91.73) ; CG273.1 v1(283.22,89.44) ; v1(251.14,145.4) CG196.1 ; v1(248.76,145.53) CG205.1 ; CG294.1 v1(272.92,71.85) ; v1(222.53,145.53) CG153.1
  vias: v1(205.47,137.2) v1(207.07,138.8) v1(207.07,136.4) v1(212.67,137.2) v1(214.27,139.6) v1(221.07,139.6) v1(221.87,138) v1(225.87,137.2) v1(227.47,139.6) v1(240.67,138) v1(249.07,138) v1(250.67,144.4) v1(254.67,137.2) v1(256.09,146.4) v1(256.09,145.7) v1(256.73,147.03) v1(256.73,146.4) v1(256.73,145.7) v1(257.07,141.2) v1(257.31,147.03) v1(257.31,146.4) v1(257.31,145.7) v1(257.9,147.03) v1(257.9,146.4) v1(257.9,145.7) v1(258.48,147.03) v1(258.48,146.4) v1(258.48,145.7) v1(259.06,147.03) v1(259.06,146.4) v1(259.06,145.7) v1(259.65,147.03) v1(259.65,146.4) v1(259.65,145.7) v1(260.23,147.03) v1(260.23,146.4) v1(260.23,145.7) v1(260.82,147.03) v1(260.82,146.4) v1(260.82,145.7) v1(261.4,147.03) v1(261.4,146.4) v1(261.4,145.7) v1(261.98,147.03) v1(261.98,146.4) v1(261.98,145.7) v1(262.57,147.03) v1(262.57,146.4) v1(262.57,145.7) v1(263.15,147.03) v1(263.15,146.4) v1(263.15,145.7) v1(263.74,147.03) v1(263.74,146.4) v1(263.74,145.7) v1(264.32,147.03) v1(264.32,146.4) v1(264.32,145.7)
