# Allegro board LAD752PR10-0816.brd (continued)
## Placement (name value [footprint] x y rotation side) (continued)
T44  PAD~D  [TPC12]  132.22 94.2 0 top
T49  PAD~D  [TPC12]  200.61 41.24 0 top
T50  PAD~D  [TPC12]  200.22 39.59 0 top
T62  PAD~D  [TPC12]  200.66 162.68 0 top
T63  PAD~D  [TPC12]  199.65 163.48 0 top
T64  PAD~D  [TPC12]  196.86 159.23 180 bottom
T65  PAD~D  [TPC12]  195.53 159.54 180 bottom
T66  PAD~D  [TPC12]  133.74 115.41 0 top
T67  PAD~D  [TPC12]  135.14 115.48 0 top
T68  PAD~D  [TPC12]  136.72 103.11 0 top
T69  PAD~D  [TPC12]  137.51 102.06 0 top
T70  PAD~D  [TPC12]  201.24 161.51 0 top
T71  PAD~D  [TPC12]  200.8 164.69 0 top
T73  PAD~D  [TPC12]  136.85 104.43 0 top
T74  PAD~D  [TPC12]  135.34 104.56 0 top
T75  PAD~D  [TPC12]  135.87 110.52 0 top
T76  PAD~D  [TPC12]  137.04 109.38 0 top
T81  PAD~D  [TPC12]  136.03 114.4 0 top
T82  PAD~D  [TPC12]  137.23 115.16 0 top
T85  PAD~D  [TPC12]  175.08 90.21 180 bottom
T88  PAD~D  [TPC12]  135.07 94.27 0 top
T89  PAD~D  [TPC12]  173.76 90.14 180 bottom
T112  PAD~D  [TPC12]  128.79 111.67 180 bottom
T113  PAD~D  [TPC12]  130.12 111.41 180 bottom
T114  PAD~D  [TPC12]  203.21 162.21 0 top
T120  PAD~D  [TPC12]  203.15 163.67 0 top
T121  PAD~D  [TPC12]  204.58 162.55 180 bottom
T122  PAD~D  [TPC12]  204.87 164.12 180 bottom
TC24  PAD~D  [TPC12]  28.9 8.8 270 bottom
TL1  MHPC_NS692417  [MHPC_NS692417_24P]  242.26 150.7 90 bottom
TV1  PAD~D  [TPC12]  220.8 103.92 90 top
TV2  PAD~D  [TPC12]  227.02 97.89 90 top
TV3  PAD~D  [TPC12]  229.71 97.06 90 top
TV4  PAD~D  [TPC12]  227.38 95.62 90 top
TV5  PAD~D  [TPC12]  228.67 95.66 90 top
TV6  PAD~D  [TPC12]  214.96 110.01 90 top
TV7  PAD~D  [TPC12]  215.59 113.82 90 top
TV8  PAD~D  [TPC12]  237.37 88.81 0 top
TV9  PAD~D  [TPC12]  238.71 88.42 0 top
TV13  PAD~D  [TPC12]  228.94 88.54 90 top
TV14  PAD~D  [TPC12]  229.15 87.27 90 top
TV15  PAD~D  [TPC12]  227.08 90.77 0 top
TV16  PAD~D  [TPC12]  218.83 83.92 90 top
TV35  PAD~D  [TPC12]  228.16 101.57 90 top
TV38  PAD~D  [TPC12]  225.05 94.52 0 top
TV39  PAD~D  [TPC12]  230.13 86.24 0 top
TV40  PAD~D  [TPC12]  226.07 93.16 0 top
TV41  PAD~D  [TPC12]  226.07 95.98 0 top
TV43  PAD~D  [TPC12]  225.75 90.52 0 top
TV47  PAD~D  [TPC12]  233.88 84.04 0 top
TV48  PAD~D  [TPC12]  228.01 84.91 0 top
TV49  PAD~D  [TPC12]  228.81 85.92 0 top
TV50  PAD~D  [TPC12]  226.6 83.71 0 top
TV51  PAD~D  [TPC12]  226.51 85.19 0 top
U1  PS8409QFN48GTR2-A1 QFN 48P_6X6  [PS8409QFN48GTR2-A0_QFN48_6X6]  216.36 159.63 270 bottom
U16  -  [AOZ1334DI-02_DFN8-7_3X3]  317.79 53.83 180 top
U17  AOZ1331_SON14_2X3  [TPS22966DPUR_SON14_2X3]  63.49 15.1 0 bottom
U18  -  [SY6288C20AAC_SOT23-5]  201.42 62.14 90 top
U19  -  [AOZ1334DI-01_DFN8-7_3X3]  176.95 78.54 0 top
U20  -  [AOZ1334DI-01_DFN8-7_3X3]  180.57 78.54 0 top
U1302  -  [RT9041E-15GQW_WDFN8_2X2]  216.45 148.97 270 bottom
U2407  -  [F75305M_MSOP10]  185.19 51.67 0 bottom
UA1  ALC3266-CG_QFN56_7X7  [ALC3266-CG_QFN56_7X7-S]  35.77 33.11 180 bottom
UA2  MAX9892ERT+T_UCSP6~D  [MAX9892ERTLFT_UCSP_6P]  22.55 28.73 270 top
UA3  MAX9892ERT+T_UCSP6~D  [MAX9892ERTLFT_UCSP_6P]  19.75 23.2 270 top
UA4  ALC1309-CG_QFN56_7X7  [ALC1309-CG_QFN56_7X7-S]  37.6 7.21 180 top
UC1  -  [74AUP1G07GW_TSSOP5]  125.58 79.24 180 top
UE1  C8051F383-GQ_LQFP32_7X7  [C8051F347-GQ_LQFP32_7X7]  313.8 9.2 0 top
UE2  EN25Q80A-100HIP_SO8  [EN25F80-75HCP_SO8]  102.97 18.56 270 bottom
UE3  TLC59116FIRHBR_VQFN32_5X5  [TLC59116FIRHBR_VQFN32_5X5-S]  220.31 159.13 180 top
UE4  TLC59116FIRHBR_VQFN32_5X5  [TLC59116FIRHBR_VQFN32_5X5-S]  185.3 21.69 270 top
UE5  -  [KB9022QD_LQFP128_14X14]  305.54 23.84 270 top
UE6  KC3810_QFN24_4X4  [KC3810_QFN24_4X4-S]  330.04 40.73 0 top
UE8  TLC59116FIRHBR_VQFN32_5X5  [TLC59116FIRHBR_VQFN32_5X5-S]  289.71 45.85 0 bottom
UE9  -  [SY6288C20AAC_SOT23-5]  101.38 21.37 180 bottom
UE10  KC3810_QFN24_4X4  [KC3810_QFN24_4X4-S]  307.05 48.86 0 top
UE12  -  [SY6288D20AAC_SOT23-5]  148.06 163.59 90 top
UG1  216-0886-R16M-E1-70_BGA1401~D  [216-0886-R16M-E1-70_BGA_1401P]  255.52 117.3 180 bottom
UG2  -  [MC74VHC1G08DFT2G_SC70-5]  209.59 118.44 0 bottom
UG3  -  [ADM1032ARMZ-1RL_MSOP8]  206.42 110.73 180 bottom
UG4  -  [MC74VHC1G09DFT2G_SC70-5]  212.38 118.42 0 bottom
UG13  H5GQ1H24BFR-T2C_BGA170  [H5GQ1H24AFR-T2L_BGA_170P]  215.47 144 180 bottom
UG14  H5GQ1H24BFR-T2C_BGA170  [H5GQ1H24AFR-T2L_BGA_170P]  219.07 131.2 0 bottom
UG15  H5GQ1H24AFR-T2L_BGA170  [H5GQ1H24AFR-T2L_BGA_170P]  243.47 144 180 bottom
UG16  H5GQ1H24AFR-T2L_BGA170  [H5GQ1H24AFR-T2L_BGA_170P]  247.07 131.2 0 bottom
UG17  H5GQ1H24AFR-T2L_BGA170  [H5GQ1H24AFR-T2L_BGA_170P]  281.72 115.41 90 bottom
UG18  H5GQ1H24AFR-T2L_BGA170  [H5GQ1H24AFR-T2L_BGA_170P]  268.92 111.81 270 bottom
UG19  H5GQ1H24AFR-T2L_BGA170  [H5GQ1H24AFR-T2L_BGA_170P]  281.72 87.41 90 bottom
UG20  H5GQ1H24AFR-T2L_BGA170  [H5GQ1H24AFR-T2L_BGA_170P]  268.92 83.81 270 bottom
UH1  SKL-H-PCH_BGA837  [SKY-S-PCH_BGA_837P-T]  194.76 39.41 90 bottom
UH3  -  [TC7SH08FU_SSOP5]  215.42 23.88 180 top
UH4  -  [W25Q128FVSIQ_SO8]  220.23 14.12 90 bottom
UH5  M25P20-VMN6TPB  [M25P40-VMN6TP_SO8]  206.09 69.98 0 bottom
UL1  S IC E2400-BL3A-R QFN 40P E-LAN CTRL  [E2201-BL3A-R_QFN40_5X5-S]  234.29 155.91 0 bottom
UL2  -  [SY6288D20AAC_SOT23-5]  228.02 150.24 270 bottom
UM3  -  [TC7SH08FU_SSOP5]  161.12 172.58 180 bottom
UM4  PI6CEQ20200LIEX  [PI6CEQ20200LIEX_TSSOP20]  171.19 153.98 180 bottom
UM7  TC7SH08FU_SSOP5~D  [TC7SH08FU_SSOP5]  149.61 174.46 0 bottom
UM8  DS80PCI402SQNOPB_WQFN54_10X5P5  [DS80PCI402_WQFN54_10X5P5-S]  136.11 153.38 180 bottom
US1  KXCNL-1010_LGA16_3X3  [LNG3DMTR_LGA16_3X3]  182.4 69.1 0 top
UT1  ALPINE-RIDGE_BGA337  [ALPINE-RIDGE_BGA_337P]  175.92 169.84 0 top
UT2  -  [W25Q80DVSSIG_SO8]  190.18 159.63 0 bottom
UT4  TPS65982_BGA96  [TPS65982_BGA_96P]  198.16 160.07 0 bottom
UU1  TPS2546RTER_QFN16_3X3  [TPS2540RTER_QFN16_3X3-S]  21.58 43.11 0 top
UU3  -  [SY6288C20AAC_SOT23-5]  264.43 23.67 180 bottom
UU5  TC7SZ14FU_SSOP5~D  [TC7SZ14FU_SSOP5]  30.04 43.81 90 top
UU7  TPS25810RVCR_QFN20_4X3  [TPS25810RVCR_QFN20_4X3-S]  19.42 53.63 270 bottom
UV3  -  [SN74CBT3257CPWR_TSSOP16]  231.7 157.58 180 bottom
UV17  -  [SY6288C20AAC_SOT23-5]  163.65 166.59 0 bottom
UV21  PS8331BQFN60GTR-A2 QFN  [PS8331BQFN60GTR-A0_QFN60_5X9-S]  185.1 112.14 90 bottom
UV22  -  [SN74CBT3257CPWR_TSSOP16]  190.48 88.82 90 bottom
UV23  -  [TLV3201AIDCKR_SC70-5]  212.37 108.53 180 bottom
UX1  TC7SH08FU_SSOP5~D  [TC7SH08FU_SSOP5]  224.09 162.14 270 top
UX2  TC7SH08FU_SSOP5~D  [TC7SH08FU_SSOP5]  211.7 158.71 270 bottom
UZ21  -  [APE8937GN2_DFN8_2X2]  129.1 97.8 180 bottom
YG1  X_7XA0000004_4P  [X_7X48000025_4P]  211.35 81.95 90 bottom
YH1  32.768KHZ_X1A000141000300  [Y_CM31532768DZFT_2P]  222.2 38.02 270 bottom
YH2  24MHZ_12PF_7V24000020  [Y_X3G024000DC1H_4P]  192.97 46.45 0 bottom
YL1  25MHZ_12PF_7V25000012  [Y_FSX3M-25PM20FDO_4P]  238.33 159.29 180 bottom
YT1  25MHZ_12PF_7V25000012  [Y_7V25000012_4P]  194.14 167.98 180 top

## Library data of the parts
C2-C4 C6 C7 C10 C11 C29 C256 C258 C260 C263 C265 C266 C268 C270 C617 C618 C620-C625 C627-C630 C632-C640 C2498-C2500 C2502-C2511 C2516 C2518-C2525 CA1 CA2 CA4 CA6 CA8 CA10-CA13 CA15 CA16 CA18-CA21 CA23-CA28 CA30 CA34-CA41 CA45 CA46 CA53 CA54 CA56-CA60 CA62-CA66 CA71 CA74 CA77 CA78 CA80 CA81 CA83-CA85 CA87-CA92 CA254-CA257 CD1-CD4 CD12 CD16 CD18-CD22 CD29-CD32 CD34 CD69 CD74-CD83 CD91 CD92 CE1 CE3 CE4 CE6 CE7 CE9 CE13-CE20 CE24 CE25 CE27-CE36 CE38 CE40-CE46 CE51 CE55-CE65 CE79 CE81 CE82 CE84-CE87 CE168 CG33 CG41-CG43 CG50 CG51 CG76-CG78 CG86 CG87 CG94 CG95 CG106-CG108 CG110-CG113 CG125 CG130-CG145 CG147-CG162 CG164-CG187 CG189-CG204 CG206-CG229 CG231-CG246 CG248-CG271 CG273-CG288 CG290-CG306 CH3 CH4 CH45-CH50 CH70 CH80 CH82 CH100 CH101 CH105-CH110 CH173-CH176 CH179 CH180 CH183 CH185-CH195 CH197 CH200 CI38 CI39 CL1-CL9 CL11-CL13 CL16-CL21 CL23-CL25 CL27-CL29 CL31-CL39 CL41-CL44 CM9 CM10 CM13 CM15-CM18 CM20 CM21 CM23 CM30 CM32-CM36 CM70 CM98 CM99 CN9 CN23-CN25 CS5-CS7 CS16 CT37 CT38 CT50-CT53 CT81 CT82 CT88 CT94-CT97 CT101 CT103 CT104 CU7 CU12 CU13 CU16-CU21 CU26 CU28-CU31 CU34 CU35 CU38 CU39 CU45-CU48 CV9 CV15 CV17 CV19 CV20 CV22 CV34 CV36 CV37 CV67 CV372-CV375 CV436-CV447 CV484 CV651 CV1056 CX1 CX2 PC1-PC4 PC6-PC9 PC11-PC13 PC100 PC103 PC105 PC106 PC118 PC119 PC200 PC201 PC208 PC210 PC211 PC213 PC214 PC216-PC218 PC300-PC302 PC309-PC311 PC500-PC503 PC505-PC538 PC540 PC546 PC547 PC549 PC554 PC555 PC557 PC562 PC563 PC566 PC571-PC573 PC578 PC579 PC581 PC582 PC588-PC590 PC594 PC701-PC704 PC708 PC709 PC715-PC724 PC726 PC727 PC801-PC803 PC806 PC809 PC811 PC818 PC1019 PC1036-PC1041 PC1045-PC1096 PC1112-PC1122 PC1301 PC1311 PC5002 PC5005-PC5011 PC5013-PC5027 PC6003-PC6011 PC6014-PC6029 PC6107-PC6110 PC6128 PC6207-PC6210 PC6216 PC6219-PC6222 PC6228 PC6307-PC6310 PC6316 PC6402-PC6405 PC6411 PC8201 PC8202 PC8205 PC8210 PC8211 PC8215-PC8222 = C_0402
C257 C261 C262 C264 C267 C269 C2512-C2515 CA3 CA5 CA7 CA9 CA14 CA17 CA29 CA31-CA33 CA52 CA55 CA61 CA67-CA70 CA79 CA82 CD5-CD10 CD13-CD15 CD17 CD23-CD28 CD35 CD70-CD73 CD84-CD90 CE22 CF4 CG17 CG29 CG30 CG32 CG35 CG124 CG146 CG163 CG188 CG205 CG230 CG247 CG272 CG289 CH52 CH53 CH102-CH104 CH118-CH128 CL14 CL15 CL22 CM12 CM14 CM19 CM29 CM31 CS1 CS2 CT73-CT75 CT90-CT93 CT98-CT100 CT106 CU3 CU11 CU27 CU32 CU33 CU42 CU44 CV14 CV18 CV1068 CV1312-CV1314 PC10 PC14 PC101 PC109-PC112 PC204 PC207 PC212 PC305 PC308 PC504 PC541 PC548 PC550 PC556 PC558 PC564 PC567 PC570 PC574 PC580 PC586 PC587 PC591 PC593 PC596-PC599 PC707 PC710 PC711 PC725 PC804 PC805 PC807 PC808 PC810 PC812-PC816 PC819 PC820 PC1003 PC1004 PC1006 PC1011-PC1016 PC1020-PC1035 PC1300 PC1302-PC1310 PC1312-PC1315 PC5003 PC6000-PC6002 PC6012 PC6013 PC6117 PC6118 PC6127 PC6205 PC6206 PC6215 PC6217 PC6218 PC6227 PC6305 PC6306 PC6315 PC6400 PC6401 PC6410 PC6505-PC6507 PC8200 PC8206 PC8213 = C_0603
C631 CU6 CU40 = C_B15G
C1240-C1242 CE80 CF5 CG79-CG82 CG109 CG126-CG129 CH129-CH132 CH177 CH178 CH181 CH182 CH184 CL40 CM11 CU2 CU10 CU37 CV5 CV10 CV21 PC102 PC104 PC113 PC114 PC202 PC203 PC205 PC206 PC303 PC304 PC543-PC545 PC551-PC553 PC559-PC561 PC565 PC568 PC569 PC575-PC577 PC583-PC585 PC592 PC705 PC706 PC712-PC714 PC800 PC1005 PC1018 PC6111-PC6114 PC6211-PC6214 PC6223-PC6226 PC6311-PC6314 PC6406-PC6409 PC6501-PC6504 PC6510-PC6541 PC8203 PC8204 PC8212 PC8214 PC8226 = C_0805
CA42-CA44 CA48 CA50 CA51 CC1-CC24 CG1-CG16 CG18-CG28 CG31 CG34 CG44-CG49 CG52-CG75 CG83-CG85 CG88-CG93 CG96-CG105 CG114-CG123 CH201-CH221 CM62-CM69 CT1-CT16 CT18 CT21 CT23-CT36 CT39-CT49 CT54-CT72 CT77-CT80 CT83-CT86 CT102 CT108-CT113 CV1-CV4 CV6-CV8 CV11-CV13 CV23-CV33 CV35 CV416-CV435 CV1057-CV1064 CV1069 PC1042-PC1044 PC1097-PC1111 PC1123-PC1238 = C_0201
CA47 CA49 = C_D2E
CD11 CD33 CG3000 PC1000 PC1008 PC1010 = C_EEFSS0D221R
CL30 = C_1808
CLRP1 = SHORTPADS: User Part Number: PART#
CPU1 = SKL-H_BGA_1440P-T
DA1 = BAT54C-7-F_SOT23-3
DA2 DA3 = BAT54AW_SOT323-3
DA4-DA8 = AZ5125-02SPR7G_SOT23-3
DE1 DF1 DF2 DG1 DU6 DU8 = SDMK0340L-7-F_SOD323-2
DE2-DE4 DH1 DV1 = RB751V-40_SOD323-2
DS1 DT1 = SDM10U45-7_SOD523-2
DT2-DT9 DT11-DT14 = ESD108-B1-CSP0201_WLL-2-1-2
DT10 DU2 DU12 DU13 = TVWDF1004AD0_DFN9
DT15 = PESD24VS2UT_SOT23-3
DU1 DU11 = L30ESDL5V0C3-2_SOT23-3
DU20 DU21 DV4 DV14 = PSOT24C_SOT23-3
DV2 = PESD5V0U2BT_SOT23-3
FD1-FD6 = FIDUCIAL_C40M80
FV2 FV3 = F_SPR-P110
H1 H2 H4 H5 H7 = H_3P8
H3 H11 = H_3P6
H6 H8-H10 H12 H14-H22 = H_3P0
H13 = H_3P6X4P2
H23 = H_4P1X3P6
J1 J4-J6 PJP801 PJP803 PJP1300-PJP1303 = JUMP_43X79
JACK1 JACK2 = YUQIU_PJ741-F07J1BE-C_6P-T
JCDRA = TE_2260531-1_46P-T
JDIMM1 = DEREN_40-42271-26001RHF_260P-T
JDIMM2 = DEREN_40-42261-26001RHF_260P-T
JDP = ACON_MAR2F-20K1800_20P
JEC = ACES_50521-0084N-P01_8P
JEDP = ACES_50473-0400M-P01_40P
JELC = AMPHE_G846A06201EU_6P-T
JFAN1 JFAN2 = ACES_50278-00401-001_4P
JHDD = STARC_111H30-000000-G4-R_30P
JHDMI = ACON_HMRA3-AK1L0C_19P
JIO = ACES_50473-0300M-P01_30P
JKB = ACES_50552-03001-P01_30P
JKB2 = ACES_50611-0100N-001_10P
JKB3 JPWR = ACES_87153-06411_6P
JKBBL = ACES_50552-02001-P01_20P
JLAN = SANTA_130456-512_13P
JLOGO = ACES_87212-1600L_16P
JP1 JP2 PJP202 PJP203 PJP301 PJP504 PJP800 PJP802 PJP8200 = JUMP_43X39
JP3 PJP100-PJP102 PJP104 PJP200 PJP201 PJP300 PJP302 PJP505 PJP8201 PJP8202 = JUMP_43X118
JPCMC = INTEL_CMC_PRIMARY_36P-T
JRTC1 = ACES_50271-00201-001_2P
JSPK = ACES_50278-00601-001_6P-T
JSSD1-JSSD3 = LCN_DAN05-67406-0103_75P-T
JTOBII = ACES_50450-0067N-P01_6P
JTP = ACES_51522-01601-P01_16P
JTRONL JTRONR = ACES_50450-0127N-001_12P
JUSB1 = SDAN_608015-010232_10P
JUSBC1 JUSBC2 = JAE_DX07S024JJ5_24P-T
JWDB = ACES_50207-00471-P01_4P-T
JWLAN = LCN_DAN05-67306-0102_67P
LA3-LA5 LL1 = MURAT_BLM15AG121SN1D_L0402_2P
LA6 = MURAT_BLM15BB221SN1D_2P
LA7 LA8 LA11 LA12 = MURAT_BLM15BD601SN1D_2P
LA9 LA10 = KC_FBMA-L10-160808-800LMT_2P
LA50-LA53 = MURAT_BLM15PX121SN1D_2P
LE1 LE2 = KC_FBMA-L11-160808-800LMT_2P
LE3 = INPAQ_MCM1012B900F06BP_4P-NPM
LG1 PH1 PH500-PH504 PH6000 PH6001 PR2-PR4 PR6 PR8 PR9 PR12-PR14 PR16 PR19 PR21-PR26 PR28 PR101-PR107 PR113 PR115 PR116 PR201 PR205-PR207 PR209 PR210 PR212-PR215 PR301 PR303 PR306-PR308 PR500-PR503 PR505 PR508 PR512-PR519 PR521 PR522 PR524 PR525 PR527-PR551 PR553 PR558-PR562 PR568-PR572 PR578-PR582 PR587-PR589 PR596-PR599 PR700 PR701 PR709-PR711 PR714-PR716 PR718 PR719 PR722-PR726 PR728-PR734 PR801 PR802 PR804 PR805 PR808 PR810-PR813 PR1300 PR1302-PR1305 PR1307-PR1309 PR5004 PR5008 PR5011 PR5012 PR5014-PR5016 PR5019-PR5033 PR6001 PR6002 PR6004-PR6006 PR6009 PR6012 PR6013 PR6015-PR6017 PR6019-PR6029 PR6031 PR6033 PR6037 PR6042 PR6043 PR6045 PR6047 PR6049 PR6050 PR6052 PR6054 PR6055 PR6057-PR6061 PR6063-PR6067 PR6069 PR6070 PR6072-PR6075 PR6077-PR6080 PR6082-PR6087 PR6089 PR8201-PR8203 PR8206 PR8208 PR8209 PR8211-PR8216 R144-R147 R150 R154 R174 R179-R183 R307 R325 R367 RA2 RA9 RA10 RA13 RA15 RA16 RA18 RA22 RA24 RA27 RA29-RA37 RA42 RA43 RA50 RA53 RA58 RA59 RA61-RA67 RA70 RA73-RA82 RC2 RC9 RC30 RC35 RC62 RC63 RC65 RC66 RC348 RC353-RC355 RD1-RD6 RD28-RD31 RD35 RD38-RD40 RE1 RE2 RE7-RE17 RE20 RE21 RE23 RE25-RE32 RE37 RE40 RE42-RE44 RE63 RE64 RE66 RE70 RE74-RE76 RE79 RE83-RE85 RE89 RE91 RE100-RE102 RE154-RE158 RE160-RE167 RE530 RE636 RE639 RE642-RE645 RE647-RE652 RF1-RF6 RG1-RG3 RG5 RG6 RG12 RG13 RG17-RG20 RG22-RG30 RG38-RG47 RG49-RG143 RG152 RG170 RG171 RG499 RG513-RG516 RG620 RG621 RH1 RH2 RH4 RH5 RH9 RH16 RH38 RH39 RH57-RH59 RH70-RH75 RH78 RH79 RH83-RH85 RH88-RH90 RH104 RH109 RH111 RH130 RH135 RH148-RH156 RH158 RH163-RH167 RH184-RH188 RH192 RH193 RH196 RH197 RH199 RH201 RH203 RH206 RH207 RH209-RH212 RH453 RH455 RH460-RH463 RH466 RH469 RH472 RH484 RH485 RH489 RH493-RH497 RH501 RH502 RH506 RH512 RH515-RH521 RH524 RH525 RH530 RH531 RH533 RH545 RH571 RH580 RH581 RH584 RH585 RH588 RH589 RL1-RL5 RL8-RL15 RM5 RM6 RM17 RM18 RM20 RM21 RM25 RM27-RM29 RM31 RM38 RM41 RM42 RM61 RM91-RM94 RM96 RN5 RN16 RT5 RT19 RT25 RT48-RT51 RT75 RT108 RT109 RU1-RU7 RU14-RU21 RU23 RV9 RV12 RV13 RV18-RV26 RV45 RV193 RV197-RV200 RV202-RV204 RV260 RV500-RV503 RV533-RV537 RV618 RV619 RV622-RV635 RV638-RV643 RV645 RV646 RV655 RV658 RV659 RV1307 RV1309 RX2 RX4-RX8 = R_0402
LM1 LT2 LT3 LU3-LU5 LU7-LU11 LV2 = INPAQ_MCM1012B900F06BP_4P
LT1 = MAG_MND-04ABIR60M-XGL_2P
LV3-LV6 = INPAQ_HCM1012GH900BP_4P-NPM
PBATT1 = ACES_50290-01201-P01_12P-T
PC108 PC115-PC117 PC209 PC215 PC306 PC307 PC1001 PC1002 PC1007 PC1009 PC1017 PC6508 PC6509 PC6542-PC6549 PC8207 PC8208 = C_D2
PC539 PC542 PC6129 PC6131 = C_ECST250ADA101MF611
PD1 = TP0610K-T1-E3_SOT23-3
PD2 PD3 = TVNST52302AB0_SOT523-3
PD5 PD100 = BAS40CW_SOT323-3
PD101 = LL4148_LL34-2
PD700 = BAT54CW_SOT323-3
PJPDC1 = ACES_50290-01301-P01_13P-T
PL1 PL3-PL5 = CHENG_SMB3025500YA_2P
PL2 = MURAT_BLM15HG601SN1D_2P
PL100 PL701 = L_5X5X3_M_2P
PL101 PL102 PL700 = CYNTE_PCMB104T-2R2MS_2P
PL201 PL300 PL8200 PL8201 = L_7X7X3_M_2P
PL500 PL6102 = KC_FBMA-L11-453215800LMA90T_2P
PL501-PL503 PL505 PL506 = CYNTE_PCME064T-R15MS0R667_2P
PL508 = CYNTE_PCMB053T-R47MS_2P
PL509 = CYNTE_PCMB042T-1R0MS_2P
PL800 = CYNTE_PCME051E-1R0MS_2P
PL801 = TOKO_1239AS-H-1R0M-P2_2P
PL6101 PL6200 PL6201 PL6300 PL6400 = L_7X7X4_M
PQ2 = RHU002N06_SOT323-3
PQ3 QV1 = SI3457CDV-T1-GE3_TSOP6
PQ4 PQ8 PQ700 PQ705 PQ8202 Q2410 QS3 QV95 = SSM3K7002FU_SC70-3
PQ7 = FDV301N_NL_SOT23-3
PQ100 PQ102 = AON7518_DFN8-5
PQ101 PQ103 = AON7534_DFN3X3-8-5
PQ200 PQ300 = AON7408L_DFN8-5
PQ201 PQ301 = AON7506_DFN33-8-5
PQ202 PQ710 QG505 QG507 = 2N7002DW-7-F_SOT363-6
PQ701-PQ703 PQ707 PQ708 = MDU1512RH_POWERDFN56-8-5
PQ704 = AON6414AL_DFN8-5
PQ706 = MDV1525URH_PDFN33-8-5
PQ8200 PQ8201 = FDMS3660S_POWER56-8-7
PR17 PR100 PR112 PR114 PR208 PR211 PR300 PR504 PR506 PR507 PR509-PR511 PR520 PR523 PR526 PR552 PR556 PR563 PR566 PR573 PR576 PR585 PR590 PR591 PR594 PR703 PR704 PR717 PR720 PR721 PR727 PR807 PR1301 PR5001 PR5006 PR5007 PR5017 PR5018 PR5034 PR6007 PR6008 PR6010 PR6011 PR6018 PR6039 PR6041 PR6056 PR6071 PR6081 PR6088 PR6090 R184 R185 RA51 RA55 RA56 RE78 RT53 RT97 RV47 RV81 = R0402_0OHM
PR108 PR109 PR200 PR203 PR204 PR302 PR554 PR557 PR564 PR567 PR574 PR577 PR583 PR586 PR592 PR595 PR705 PR706 PR708 PR803 PR806 PR809 PR5003 PR5005 PR5010 PR6000 PR6003 PR6040 PR6044 PR6046 PR6048 PR6068 PR6112 PR6113 PR6209 PR6210 PR6212 PR6213 PR6309 PR6310 PR6400 PR6401 PR8200 PR8205 PR8207 RA5 RA69 RG48 RH6 RH7 = R_0603
PR110 PR111 PR202 PR305 PR555 PR565 PR575 PR584 PR593 PR707 PR713 PR5002 PR5009 PR8204 PR8210 = R_1206
PR702 = R_2512_4P
PR712 = R_1206_4P-D
PR6114 PR6211 PR6214 PR6311 PR6402 RA57 RA60 RA83 RH12 RT95 RU12 = R_0805
PT1-PT6 T1 T2 T7 T9 T41 T43 T44 T49 T50 T62-T71 T73-T76 T81 T82 T85 T88 T89 T112-T114 T120-T122 TC24 TV1-TV9 TV13-TV16 TV35 TV38-TV41 TV43 TV47-TV51 = TPC12
PU100 = TPS51225CRUKR_QFN20_3X3-S
PU201 = RT8207PGQW_WQFN20_3X3-S
PU300 = TPS51212DSCR_SON10_3X3-S
PU500 = ISL95855HRTZ-T_TQFN48_6X6-S
PU502-PU504 PU507 PU510 = SIC632CDT1GE3_POWERPAK31_5X5
PU509 PU800 = SY8286RAC_QFN20_3X3
PU511 = SIC531CDT1GE3_POWERPAK22_4X3
PU700 = BQ24780RUYR_WQFN28_4X4-S
PU802 = RT8061AZQW_WDFN10_3X3
PU1300 PU1301 = RT9059GSP_SO8
PU6102 PU6201 PU6202 PU6301 PU6400 = NCP81382MNTXG_QFN38_4X6
PU8200 = RT8812AGQW_WQFN20_3X3-S
PU8201 = NCP81022MNTXG_QFN52_6X6
Q7-Q9 = DMN65D8LDW-7_SOT363-6
Q28 Q29 Q34 QE1 QE3 QE4 QE13 QE21 QE22 QE49-QE53 QE57 QH5 QM2 = DMN66D0LDW-7_SOT363-6
Q2407 Q2408 Q2411 QX2 QX3 = MMST3904-7-F_SOT323-3
Q2409 = SI3456DDV-T1-GE3_TSOP6
QE2 QE5 QU1 QV2 = 2N7002W-T-R7_SOT323-3
QE8 QM1 QM3 = SI2301CDS-T1-GE3_SOT23-3
QE29 QE39-QE48 = MMDT3904-7-F_SOT363-6
QE54-QE56 = BC857BS_SOT363-6
QG1 = 2N7002KDWH_SOT363-6
QG2 = AO3413_SOT23-3
QG3 QG4 QL3 = 2N7002K_SOT23-3
R2 RA1 RA3 RA4 RA6-RA8 RA11 RA68 RE24 = R0603_0OHM
R363-R366 RA12 RA17 RA21 RA26 RA28 RA40 RA41 RA44 RA45 RA52 RA85 RE300 RE396-RE401 RE449 RE451-RE529 RE630-RE635 RE637 RE638 RE640 RE641 RE646 RG7 RG8 RG144-RG151 RG153-RG169 RG396 RG397 RG400-RG403 RH21-RH30 RH537 RH558 RH656 RH657 RM14 RM23 RM26 RM62 RM64 RM66 RM70 RM72 RM75 RM76 RM79 RM81 RM82 RM84-RM87 RN15 RN17 RS1-RS3 RT2-RT4 RT6-RT9 RT11 RT12 RT14 RT16-RT18 RT20-RT24 RT26-RT47 RT57-RT73 RT76-RT80 RT83 RT86 RT94 RT102 RT107 RU24-RU26 RV1 RV8 RV10 RV15-RV17 RV600 RV669 RV670 = R_0201
RA19 RA25 RA38 RA39 RA46 RA47 RA84 RS8 RT1 RT10 RT13 RT15 RT74 RT98-RT101 = R0201_0OHM
RE90 RP2 RP3 RP5 RPH5 RPH6 RPT1 = RP_0804_8P4R
SW1 = SW_TST71-N-220-T170-S017_2P
TL1 = MHPC_NS692417_24P
U1 = PS8409QFN48GTR2-A0_QFN48_6X6
U16 = AOZ1334DI-02_DFN8-7_3X3
U17 = TPS22966DPUR_SON14_2X3
U18 UE9 UU3 UV17 = SY6288C20AAC_SOT23-5
U19 U20 = AOZ1334DI-01_DFN8-7_3X3
U1302 = RT9041E-15GQW_WDFN8_2X2
U2407 = F75305M_MSOP10
UA1 = ALC3266-CG_QFN56_7X7-S
UA2 UA3 = MAX9892ERTLFT_UCSP_6P
UA4 = ALC1309-CG_QFN56_7X7-S
UC1 = 74AUP1G07GW_TSSOP5
UE1 = C8051F347-GQ_LQFP32_7X7
UE2 = EN25F80-75HCP_SO8
UE3 UE4 UE8 = TLC59116FIRHBR_VQFN32_5X5-S
UE5 = KB9022QD_LQFP128_14X14
UE6 UE10 = KC3810_QFN24_4X4-S
UE12 UL2 = SY6288D20AAC_SOT23-5
UG1 = 216-0886-R16M-E1-70_BGA_1401P
UG2 = MC74VHC1G08DFT2G_SC70-5
UG3 = ADM1032ARMZ-1RL_MSOP8
UG4 = MC74VHC1G09DFT2G_SC70-5
UG13-UG20 = H5GQ1H24AFR-T2L_BGA_170P
UH1 = SKY-S-PCH_BGA_837P-T
UH3 UM3 UM7 UX1 UX2 = TC7SH08FU_SSOP5
UH4 = W25Q128FVSIQ_SO8
UH5 = M25P40-VMN6TP_SO8
UL1 = E2201-BL3A-R_QFN40_5X5-S
UM4 = PI6CEQ20200LIEX_TSSOP20
UM8 = DS80PCI402_WQFN54_10X5P5-S
US1 = LNG3DMTR_LGA16_3X3
UT1 = ALPINE-RIDGE_BGA_337P
UT2 = W25Q80DVSSIG_SO8
UT4 = TPS65982_BGA_96P
UU1 = TPS2540RTER_QFN16_3X3-S
UU5 = TC7SZ14FU_SSOP5
UU7 = TPS25810RVCR_QFN20_4X3-S
UV3 UV22 = SN74CBT3257CPWR_TSSOP16
UV21 = PS8331BQFN60GTR-A0_QFN60_5X9-S
UV23 = TLV3201AIDCKR_SC70-5
UZ21 = APE8937GN2_DFN8_2X2
YG1 = X_7X48000025_4P
YH1 = Y_CM31532768DZFT_2P
YH2 = Y_X3G024000DC1H_4P
YL1 = Y_FSX3M-25PM20FDO_4P
YT1 = Y_7V25000012_4P

## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated)
2N7002DW-7-F_SOT363-6
  oval 0.432x0.61 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.9) 5(0.65,1.9) 6(0,1.9)
2N7002K_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
2N7002KDWH_SOT363-6
  oval 0.356x0.889 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.6) 5(0.65,1.6) 6(0,1.6)
2N7002W-T-R7_SOT323-3
  oval 0.813x0.914 smd: 1(0,0) 2(0.65,1.6) 3(-0.65,1.6)
74AUP1G07GW_TSSOP5
  oval 0.381x1.346 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.79) 5(0,1.79)
216-0886-R16M-E1-70_BGA_1401P
  round 0.635 smd: A2(1,0) A3(2,0) A41(35.4,0) A42(36.4,0) AY2(0.9,-34.9) AY3(1.8,-34.9) AY41(35.6,-34.9) AY42(36.5,-34.9) B1(0,-1) B2(1,-1) B4(2.5,-0.9) B40(34.9,-0.9) B42(36.4,-1) B43(37.4,-1) BA1(0,-35.4) BA4(2.5,-35.6) BA40(34.9,-35.6) BA43(37.4,-35.4) BB1(0,-36.4) BB2(1,-36.4) BB4(2.5,-36.5) BB40(34.9,-36.5) BB42(36.4,-36.4) BB43(37.4,-36.4) BC2(1,-37.4) BC3(2,-37.4) BC41(35.4,-37.4) BC42(36.4,-37.4) C1(0,-2) C4(2.5,-1.8) C40(34.9,-1.8) C43(37.4,-2) D2(0.9,-2.5) D3(1.8,-2.5) D41(35.6,-2.5) D42(36.5,-2.5)
  round 0.508 smd: A5(3.7,0) A6(4.9,0) A8(6.1,0) A9(7.3,0) A11(8.5,0) A12(9.7,0) A14(10.9,0) A15(12.1,0) A17(13.3,0) A18(14.5,0) A19(15.7,0) A20(16.9,0) A21(18.1,0) A23(19.3,0) A24(20.5,0) A25(21.7,0) A26(22.9,0) A27(24.1,0) A29(25.3,0) A30(26.5,0) A32(27.7,0) A33(28.9,0) A35(30.1,0) A36(31.3,0) A38(32.5,0) A39(33.7,0) AA1(0,-18.1) AA2(0.9,-18.1) AA3(1.8,-18.1) AA4(2.7,-18.1) AA5(3.6,-18.1) AA6(4.5,-18.1) AA7(5.3,-18.1) AA8(6.1,-18.1) AA9(6.9,-18.1) AA10(7.7,-18.1) AA11(8.5,-18.1) AA12(9.3,-18.1) AA13(10.1,-18.1) AA14(10.9,-18.1) AA15(11.7,-17.7) AA16(12.7,-17.7) AA17(13.7,-17.7) AA18(14.7,-17.7) AA19(15.7,-17.7) AA20(16.7,-17.7) AA21(17.7,-17.7) AA22(18.7,-17.7) AA23(19.7,-17.7) AA24(20.7,-17.7) AA25(21.7,-17.7) AA26(22.7,-17.7) AA27(23.7,-17.7) AA28(24.7,-17.7) AA29(25.7,-17.7) AA30(26.5,-18.1) AA31(27.3,-18.1) AA32(28.1,-18.1) AA33(28.9,-18.1) AA34(29.7,-18.1) AA35(30.5,-18.1) AA36(31.3,-18.1) AA37(32.1,-18.1) AA38(32.9,-18.1) AA39(33.8,-18.1) AA40(34.7,-18.1) AA41(35.6,-18.1) AA42(36.5,-18.1) AA43(37.4,-18.1) AB15(11.7,-18.7) AB16(12.7,-18.7) AB17(13.7,-18.7) AB18(14.7,-18.7) AB19(15.7,-18.7) AB20(16.7,-18.7) AB21(17.7,-18.7) AB22(18.7,-18.7) AB23(19.7,-18.7) AB24(20.7,-18.7) AB25(21.7,-18.7) AB26(22.7,-18.7) AB27(23.7,-18.7) AB28(24.7,-18.7) AB29(25.7,-18.7) AC1(0,-19.3) AC2(0.9,-19.3) AC3(1.8,-19.3) AC4(2.7,-19.3) AC5(3.6,-19.3) AC6(4.5,-19.3) AC7(5.3,-19.3) AC8(6.1,-19.3) AC9(6.9,-19.3) AC10(7.7,-19.3) AC11(8.5,-19.3) AC12(9.3,-19.3) AC13(10.1,-19.3) AC14(10.9,-19.3) AC15(11.7,-19.7) AC16(12.7,-19.7) AC17(13.7,-19.7) AC18(14.7,-19.7) AC19(15.7,-19.7) AC20(16.7,-19.7) AC21(17.7,-19.7) AC22(18.7,-19.7) AC23(19.7,-19.7) AC24(20.7,-19.7) AC25(21.7,-19.7) AC26(22.7,-19.7) AC27(23.7,-19.7) AC28(24.7,-19.7) AC29(25.7,-19.7) AC30(26.5,-19.3) AC31(27.3,-19.3) AC32(28.1,-19.3) AC33(28.9,-19.3) AC34(29.7,-19.3) AC35(30.5,-19.3) AC36(31.3,-19.3) AC37(32.1,-19.3) AC38(32.9,-19.3) AC39(33.8,-19.3) AC40(34.7,-19.3) AC41(35.6,-19.3) AC42(36.5,-19.3) AC43(37.4,-19.3) AD1(0,-20.5) AD2(0.9,-20.5) AD3(1.8,-20.5) AD4(2.7,-20.5) AD5(3.6,-20.5) AD6(4.5,-20.5) AD7(5.3,-20.5) AD8(6.1,-20.5) AD9(6.9,-20.5) AD10(7.7,-20.5) AD11(8.5,-20.5) AD12(9.3,-20.5) AD13(10.1,-20.5) AD14(10.9,-20.5) AD15(11.7,-20.7) AD16(12.7,-20.7) AD17(13.7,-20.7) AD18(14.7,-20.7) AD19(15.7,-20.7) AD20(16.7,-20.7) AD21(17.7,-20.7) AD22(18.7,-20.7) AD23(19.7,-20.7) AD24(20.7,-20.7) AD25(21.7,-20.7) AD26(22.7,-20.7) AD27(23.7,-20.7) AD28(24.7,-20.7) AD29(25.7,-20.7) AD30(26.5,-20.5) AD31(27.3,-20.5) AD32(28.1,-20.5) AD33(28.9,-20.5) AD34(29.7,-20.5) AD35(30.5,-20.5) AD36(31.3,-20.5) AD37(32.1,-20.5) AD38(32.9,-20.5) AD39(33.8,-20.5) AD40(34.7,-20.5) AD41(35.6,-20.5) AD42(36.5,-20.5) AD43(37.4,-20.5) AE1(0,-21.7) AE2(0.9,-21.7) AE3(1.8,-21.7) AE4(2.7,-21.7) AE5(3.6,-21.7) AE6(4.5,-21.7) AE7(5.3,-21.7) AE8(6.1,-21.7) AE9(6.9,-21.7) AE10(7.7,-21.7) AE11(8.5,-21.7) AE12(9.3,-21.7) AE13(10.1,-21.7) AE14(10.9,-21.7) AE15(11.7,-21.7) AE16(12.7,-21.7) AE17(13.7,-21.7) AE18(14.7,-21.7) AE19(15.7,-21.7) AE20(16.7,-21.7) AE21(17.7,-21.7) AE22(18.7,-21.7) AE23(19.7,-21.7) AE24(20.7,-21.7) AE25(21.7,-21.7) AE26(22.7,-21.7) AE27(23.7,-21.7) AE28(24.7,-21.7) AE29(25.7,-21.7) AE30(26.5,-21.7) AE31(27.3,-21.7) AE32(28.1,-21.7) AE33(28.9,-21.7) AE34(29.7,-21.7) AE35(30.5,-21.7) AE36(31.3,-21.7) AE37(32.1,-21.7) AE38(32.9,-21.7) AE39(33.8,-21.7) AE40(34.7,-21.7) AE41(35.6,-21.7) AE42(36.5,-21.7) AE43(37.4,-21.7) AF1(0,-22.9) AF2(0.9,-22.9) AF3(1.8,-22.9) AF4(2.7,-22.9) AF5(3.6,-22.9) AF6(4.5,-22.9) AF7(5.3,-22.9) AF8(6.1,-22.9) AF9(6.9,-22.9) AF10(7.7,-22.9) AF11(8.5,-22.9) AF12(9.3,-22.9) AF13(10.1,-22.9) AF14(10.9,-22.9) AF15(11.7,-22.7) AF16(12.7,-22.7) AF17(13.7,-22.7) AF18(14.7,-22.7) AF19(15.7,-22.7) AF20(16.7,-22.7) AF21(17.7,-22.7) AF22(18.7,-22.7) AF23(19.7,-22.7) AF24(20.7,-22.7) AF25(21.7,-22.7) AF26(22.7,-22.7) AF27(23.7,-22.7) AF28(24.7,-22.7) AF29(25.7,-22.7) AF30(26.5,-22.9) AF31(27.3,-22.9) AF32(28.1,-22.9) AF33(28.9,-22.9) AF34(29.7,-22.9) AF35(30.5,-22.9) AF36(31.3,-22.9) AF37(32.1,-22.9) AF38(32.9,-22.9) AF39(33.8,-22.9) AF40(34.7,-22.9) AF41(35.6,-22.9) AF42(36.5,-22.9) AF43(37.4,-22.9) AG1(0,-24.1) AG2(0.9,-24.1) AG3(1.8,-24.1) AG4(2.7,-24.1) AG5(3.6,-24.1) AG6(4.5,-24.1) AG7(5.3,-24.1) AG8(6.1,-24.1) AG9(6.9,-24.1) AG10(7.7,-24.1) AG11(8.5,-24.1) AG12(9.3,-24.1) AG13(10.1,-24.1) AG14(10.9,-24.1) AG15(11.7,-23.7) AG16(12.7,-23.7) AG17(13.7,-23.7) AG18(14.7,-23.7) AG19(15.7,-23.7) AG20(16.7,-23.7) AG21(17.7,-23.7) AG22(18.7,-23.7) AG23(19.7,-23.7) AG24(20.7,-23.7) AG25(21.7,-23.7) AG26(22.7,-23.7) AG27(23.7,-23.7) AG28(24.7,-23.7) AG29(25.7,-23.7) AG30(26.5,-24.1) AG31(27.3,-24.1) AG32(28.1,-24.1) AG33(28.9,-24.1) AG34(29.7,-24.1) AG35(30.5,-24.1) AG36(31.3,-24.1) AG37(32.1,-24.1) AG38(32.9,-24.1) AG39(33.8,-24.1) AG40(34.7,-24.1) AG41(35.6,-24.1) AG42(36.5,-24.1) AG43(37.4,-24.1) AH15(11.7,-24.7) AH16(12.7,-24.7) AH17(13.7,-24.7) AH18(14.7,-24.7) AH19(15.7,-24.7) AH20(16.7,-24.7) AH21(17.7,-24.7) AH22(18.7,-24.7) AH23(19.7,-24.7) AH24(20.7,-24.7) AH25(21.7,-24.7) AH26(22.7,-24.7) AH27(23.7,-24.7) AH28(24.7,-24.7) AH29(25.7,-24.7) AJ1(0,-25.3) AJ2(0.9,-25.3) AJ3(1.8,-25.3) AJ4(2.7,-25.3) AJ5(3.6,-25.3) AJ6(4.5,-25.3) AJ7(5.3,-25.3) AJ8(6.1,-25.3) AJ9(6.9,-25.3) AJ10(7.7,-25.3) AJ11(8.5,-25.3) AJ12(9.3,-25.3) AJ13(10.1,-25.3) AJ14(10.9,-25.3) AJ15(11.7,-25.7) AJ16(12.7,-25.7) AJ17(13.7,-25.7) AJ18(14.7,-25.7) AJ19(15.7,-25.7) AJ20(16.7,-25.7) AJ21(17.7,-25.7) AJ22(18.7,-25.7) AJ23(19.7,-25.7) AJ24(20.7,-25.7) AJ25(21.7,-25.7) AJ26(22.7,-25.7) AJ27(23.7,-25.7) AJ28(24.7,-25.7) AJ29(25.7,-25.7) AJ30(26.5,-25.3) AJ31(27.3,-25.3) AJ32(28.1,-25.3) AJ33(28.9,-25.3) AJ34(29.7,-25.3) AJ35(30.5,-25.3) AJ36(31.3,-25.3) AJ37(32.1,-25.3) AJ38(32.9,-25.3) AJ39(33.8,-25.3) AJ40(34.7,-25.3) AJ41(35.6,-25.3) AJ42(36.5,-25.3) AJ43(37.4,-25.3) AK1(0,-26.5) AK2(0.9,-26.5) AK3(1.8,-26.5) AK4(2.7,-26.5) AK5(3.6,-26.5) AK6(4.5,-26.5) AK7(5.3,-26.5) AK8(6.1,-26.5) AK9(6.9,-26.5) AK10(7.7,-26.5) AK11(8.5,-26.5) AK12(9.3,-26.5) AK14(10.9,-26.5) AK15(12.1,-26.5) AK17(13.3,-26.5) AK18(14.5,-26.5) AK19(15.7,-26.5) AK20(16.9,-26.5) AK21(18.1,-26.5) AK23(19.3,-26.5) AK24(20.5,-26.5) AK25(21.7,-26.5) AK26(22.9,-26.5) AK27(24.1,-26.5) AK29(25.3,-26.5) AK30(26.5,-26.5) AK32(28.1,-26.5) AK33(28.9,-26.5) AK34(29.7,-26.5) AK35(30.5,-26.5) AK36(31.3,-26.5) AK37(32.1,-26.5) AK38(32.9,-26.5) AK39(33.8,-26.5) AK40(34.7,-26.5) AK41(35.6,-26.5) AK42(36.5,-26.5) AK43(37.4,-26.5) AL15(12.1,-27.3) AL17(13.3,-27.3) AL18(14.5,-27.3) AL19(15.7,-27.3) AL20(16.9,-27.3) AL21(18.1,-27.3) AL23(19.3,-27.3) AL24(20.5,-27.3) AL25(21.7,-27.3) AL26(22.9,-27.3) AL27(24.1,-27.3) AL29(25.3,-27.3) AM1(0,-27.7) AM2(0.9,-27.7) AM3(1.8,-27.7) AM4(2.7,-27.7) AM5(3.6,-27.7) AM6(4.5,-27.7) AM7(5.3,-27.7) AM8(6.1,-27.7) AM9(6.9,-27.7) AM10(7.7,-27.7) AM11(8.5,-27.7) AM12(9.5,-27.9) AM14(10.9,-28.1) AM15(12.1,-28.1) AM17(13.3,-28.1) AM18(14.5,-28.1) AM19(15.7,-28.1) AM20(16.9,-28.1) AM21(18.1,-28.1) AM23(19.3,-28.1) AM24(20.5,-28.1) AM25(21.7,-28.1) AM26(22.9,-28.1) AM27(24.1,-28.1) AM29(25.3,-28.1) AM30(26.5,-28.1) AM32(27.9,-27.9) AM33(28.9,-27.7) AM34(29.7,-27.7) AM35(30.5,-27.7) AM36(31.3,-27.7) AM37(32.1,-27.7) AM38(32.9,-27.7) AM39(33.8,-27.7) AM40(34.7,-27.7) AM41(35.6,-27.7) AM42(36.5,-27.7) AM43(37.4,-27.7) AN1(0,-28.9) AN2(0.9,-28.9) AN3(1.8,-28.9) AN4(2.7,-28.9) AN5(3.6,-28.9) AN6(4.5,-28.9) AN7(5.3,-28.9) AN8(6.1,-28.9) AN9(6.9,-28.9) AN11(8.5,-28.9) AN12(9.7,-28.9) AN14(10.9,-28.9) AN15(12.1,-28.9) AN17(13.3,-28.9) AN18(14.5,-28.9) AN19(15.7,-28.9) AN20(16.9,-28.9) AN21(18.1,-28.9) AN23(19.3,-28.9) AN24(20.5,-28.9) AN25(21.7,-28.9) AN26(22.9,-28.9) AN27(24.1,-28.9) AN29(25.3,-28.9) AN30(26.5,-28.9) AN32(27.7,-28.9) AN33(28.9,-28.9) AN35(30.5,-28.9) AN36(31.3,-28.9) AN37(32.1,-28.9) AN38(32.9,-28.9) AN39(33.8,-28.9) AN40(34.7,-28.9) AN41(35.6,-28.9) AN42(36.5,-28.9) AN43(37.4,-28.9) AP12(9.7,-29.7) AP14(10.9,-29.7) AP15(12.1,-29.7) AP17(13.3,-29.7) AP18(14.5,-29.7) AP19(15.7,-29.7) AP20(16.9,-29.7) AP21(18.1,-29.7) AP23(19.3,-29.7) AP24(20.5,-29.7) AP25(21.7,-29.7) AP26(22.9,-29.7) AP27(24.1,-29.7) AP29(25.3,-29.7) AP30(26.5,-29.7) AP32(27.7,-29.7) AR1(0,-30.1) AR2(0.9,-30.1) AR3(1.8,-30.1) AR4(2.7,-30.1) AR5(3.6,-30.1) AR6(4.5,-30.1) AR7(5.3,-30.1) AR8(6.1,-30.1) AR9(7.1,-30.3) AR11(8.5,-30.5) AR12(9.7,-30.5) AR14(10.9,-30.5) AR15(12.1,-30.5) AR17(13.3,-30.5) AR18(14.5,-30.5) AR19(15.7,-30.5) AR20(16.9,-30.5) AR21(18.1,-30.5) AR23(19.3,-30.5) AR24(20.5,-30.5) AR25(21.7,-30.5) AR26(22.9,-30.5) AR27(24.1,-30.5) AR29(25.3,-30.5) AR30(26.5,-30.5) AR32(27.7,-30.5) AR33(28.9,-30.5) AR35(30.3,-30.3) AR36(31.3,-30.1) AR37(32.1,-30.1) AR38(32.9,-30.1) AR39(33.8,-30.1) AR40(34.7,-30.1) AR41(35.6,-30.1) AR42(36.5,-30.1) AR43(37.4,-30.1) AT1(0,-31.3) AT2(0.9,-31.3) AT3(1.8,-31.3) AT4(2.7,-31.3) AT5(3.6,-31.3) AT6(4.5,-31.3) AT8(6.1,-31.3) AT9(7.3,-31.3) AT11(8.5,-31.3) AT12(9.7,-31.3) AT14(10.9,-31.3) AT15(12.1,-31.3) AT17(13.3,-31.3) AT18(14.5,-31.3) AT19(15.7,-31.3) AT20(16.9,-31.3) AT21(18.1,-31.3) AT23(19.3,-31.3) AT24(20.5,-31.3) AT25(21.7,-31.3) AT26(22.9,-31.3) AT27(24.1,-31.3) AT29(25.3,-31.3) AT30(26.5,-31.3) AT32(27.7,-31.3) AT33(28.9,-31.3) AT35(30.1,-31.3) AT36(31.3,-31.3) AT38(32.9,-31.3) AT39(33.8,-31.3) AT40(34.7,-31.3) AT41(35.6,-31.3) AT42(36.5,-31.3) AT43(37.4,-31.3) AU9(7.3,-32.1) AU11(8.5,-32.1) AU12(9.7,-32.1) AU14(10.9,-32.1) AU15(12.1,-32.1) AU17(13.3,-32.1) AU18(14.5,-32.1) AU19(15.7,-32.1) AU20(16.9,-32.1) AU21(18.1,-32.1) AU23(19.3,-32.1) AU24(20.5,-32.1) AU25(21.7,-32.1) AU26(22.9,-32.1) AU27(24.1,-32.1) AU29(25.3,-32.1) AU30(26.5,-32.1) AU32(27.7,-32.1) AU33(28.9,-32.1) AU35(30.1,-32.1) AV1(0,-32.5) AV2(0.9,-32.5) AV3(1.8,-32.5) AV4(2.7,-32.5) AV5(3.6,-32.5) AV6(4.7,-32.7) AV8(6.1,-32.9) AV9(7.3,-32.9) AV11(8.5,-32.9) AV12(9.7,-32.9) AV14(10.9,-32.9) AV15(12.1,-32.9) AV17(13.3,-32.9) AV18(14.5,-32.9) AV19(15.7,-32.9) AV20(16.9,-32.9) AV21(18.1,-32.9) AV23(19.3,-32.9) AV24(20.5,-32.9) AV25(21.7,-32.9) AV26(22.9,-32.9) AV27(24.1,-32.9) AV29(25.3,-32.9) AV30(26.5,-32.9) AV32(27.7,-32.9) AV33(28.9,-32.9) AV35(30.1,-32.9) AV36(31.3,-32.9) AV38(32.7,-32.7) AV39(33.8,-32.5) AV40(34.7,-32.5) AV41(35.6,-32.5) AV42(36.5,-32.5) AV43(37.4,-32.5) AW1(0,-33.7) AW2(0.9,-33.7) AW3(1.8,-33.7) AW4(2.7,-33.7) AW5(3.65,-33.75) AW6(4.9,-33.8) AW8(6.1,-33.8) AW9(7.3,-33.8) AW11(8.5,-33.8) AW12(9.7,-33.8) AW14(10.9,-33.8) AW15(12.1,-33.8) AW17(13.3,-33.8) AW18(14.5,-33.8) AW19(15.7,-33.8) AW20(16.9,-33.8) AW21(18.1,-33.8) AW23(19.3,-33.8) AW24(20.5,-33.8) AW25(21.7,-33.8) AW26(22.9,-33.8) AW27(24.1,-33.8) AW29(25.3,-33.8) AW30(26.5,-33.8) AW32(27.7,-33.8) AW33(28.9,-33.8) AW35(30.1,-33.8) AW36(31.3,-33.8) AW38(32.5,-33.8) AW39(33.75,-33.75) AW40(34.7,-33.7) AW41(35.6,-33.7) AW42(36.5,-33.7) AW43(37.4,-33.7) AY5(3.7,-34.7) AY6(4.9,-34.7) AY8(6.1,-34.7) AY9(7.3,-34.7) AY11(8.5,-34.7) AY12(9.7,-34.7) AY14(10.9,-34.7) AY15(12.1,-34.7) AY17(13.3,-34.7) AY18(14.5,-34.7) AY19(15.7,-34.7) AY20(16.9,-34.7) AY21(18.1,-34.7) AY23(19.3,-34.7) AY24(20.5,-34.7) AY25(21.7,-34.7) AY26(22.9,-34.7) AY27(24.1,-34.7) AY29(25.3,-34.7) AY30(26.5,-34.7) AY32(27.7,-34.7) AY33(28.9,-34.7) AY35(30.1,-34.7) AY36(31.3,-34.7) AY38(32.5,-34.7) AY39(33.7,-34.7) B5(3.7,-0.9) B6(4.9,-0.9) B8(6.1,-0.9) B9(7.3,-0.9) B11(8.5,-0.9) B12(9.7,-0.9) B14(10.9,-0.9) B15(12.1,-0.9) B17(13.3,-0.9) B18(14.5,-0.9) B19(15.7,-0.9) B20(16.9,-0.9) B21(18.1,-0.9) B23(19.3,-0.9) B24(20.5,-0.9) B25(21.7,-0.9) B26(22.9,-0.9) B27(24.1,-0.9) B29(25.3,-0.9) B30(26.5,-0.9) B32(27.7,-0.9) B33(28.9,-0.9) B35(30.1,-0.9) B36(31.3,-0.9) B38(32.5,-0.9) B39(33.7,-0.9) BA5(3.7,-35.6) BA6(4.9,-35.6) BA8(6.1,-35.6) BA9(7.3,-35.6) BA11(8.5,-35.6) BA12(9.7,-35.6) BA14(10.9,-35.6) BA15(12.1,-35.6) BA17(13.3,-35.6) BA18(14.5,-35.6) BA19(15.7,-35.6) BA20(16.9,-35.6) BA21(18.1,-35.6) BA23(19.3,-35.6) BA24(20.5,-35.6) BA25(21.7,-35.6) BA26(22.9,-35.6) BA27(24.1,-35.6) BA29(25.3,-35.6) BA30(26.5,-35.6) BA32(27.7,-35.6) BA33(28.9,-35.6) BA35(30.1,-35.6) BA36(31.3,-35.6) BA38(32.5,-35.6) BA39(33.7,-35.6) BB5(3.7,-36.5) BB6(4.9,-36.5) BB8(6.1,-36.5) BB9(7.3,-36.5) BB11(8.5,-36.5) BB12(9.7,-36.5) BB14(10.9,-36.5) BB15(12.1,-36.5) BB17(13.3,-36.5) BB18(14.5,-36.5) BB19(15.7,-36.5) BB20(16.9,-36.5) BB21(18.1,-36.5) BB23(19.3,-36.5) BB24(20.5,-36.5) BB25(21.7,-36.5) BB26(22.9,-36.5) BB27(24.1,-36.5) BB29(25.3,-36.5) BB30(26.5,-36.5) BB32(27.7,-36.5) BB33(28.9,-36.5) BB35(30.1,-36.5) BB36(31.3,-36.5) BB38(32.5,-36.5) BB39(33.7,-36.5) BC5(3.7,-37.4) BC6(4.9,-37.4) BC8(6.1,-37.4) BC9(7.3,-37.4) BC11(8.5,-37.4) BC12(9.7,-37.4) BC14(10.9,-37.4) BC15(12.1,-37.4) BC17(13.3,-37.4) BC18(14.5,-37.4) BC19(15.7,-37.4) BC20(16.9,-37.4) BC21(18.1,-37.4) BC23(19.3,-37.4) BC24(20.5,-37.4) BC25(21.7,-37.4) BC26(22.9,-37.4) BC27(24.1,-37.4) BC29(25.3,-37.4) BC30(26.5,-37.4) BC32(27.7,-37.4) BC33(28.9,-37.4) BC35(30.1,-37.4) BC36(31.3,-37.4) BC38(32.5,-37.4) BC39(33.7,-37.4) C5(3.7,-1.8) C6(4.9,-1.8) C8(6.1,-1.8) C9(7.3,-1.8) C11(8.5,-1.8) C12(9.7,-1.8) C14(10.9,-1.8) C15(12.1,-1.8) C17(13.3,-1.8) C18(14.5,-1.8) C19(15.7,-1.8) C20(16.9,-1.8) C21(18.1,-1.8) C23(19.3,-1.8) C24(20.5,-1.8) C25(21.7,-1.8) C26(22.9,-1.8) C27(24.1,-1.8) C29(25.3,-1.8) C30(26.5,-1.8) C32(27.7,-1.8) C33(28.9,-1.8) C35(30.1,-1.8) C36(31.3,-1.8) C38(32.5,-1.8) C39(33.7,-1.8) D5(3.7,-2.7) D6(4.9,-2.7) D8(6.1,-2.7) D9(7.3,-2.7) D11(8.5,-2.7) D12(9.7,-2.7) D14(10.9,-2.7) D15(12.1,-2.7) D17(13.3,-2.7) D18(14.5,-2.7) D19(15.7,-2.7) D20(16.9,-2.7) D21(18.1,-2.7) D23(19.3,-2.7) D24(20.5,-2.7) D25(21.7,-2.7) D26(22.9,-2.7) D27(24.1,-2.7) D29(25.3,-2.7) D30(26.5,-2.7) D32(27.7,-2.7) D33(28.9,-2.7) D35(30.1,-2.7) D36(31.3,-2.7) D38(32.5,-2.7) D39(33.7,-2.7) E1(0,-3.7) E2(0.9,-3.7) E3(1.8,-3.7) E4(2.7,-3.7) E5(3.65,-3.65) E6(4.9,-3.6) E8(6.1,-3.6) E9(7.3,-3.6) E11(8.5,-3.6) E12(9.7,-3.6) E14(10.9,-3.6) E15(12.1,-3.6) E17(13.3,-3.6) E18(14.5,-3.6) E19(15.7,-3.6) E20(16.9,-3.6) E21(18.1,-3.6) E23(19.3,-3.6) E24(20.5,-3.6) E25(21.7,-3.6) E26(22.9,-3.6) E27(24.1,-3.6) E29(25.3,-3.6) E30(26.5,-3.6) E32(27.7,-3.6) E33(28.9,-3.6) E35(30.1,-3.6) E36(31.3,-3.6) E38(32.5,-3.6) E39(33.75,-3.65) E40(34.7,-3.7) E41(35.6,-3.7) E42(36.5,-3.7) E43(37.4,-3.7) F1(0,-4.9) F2(0.9,-4.9) F3(1.8,-4.9) F4(2.7,-4.9) F5(3.6,-4.9) F6(4.7,-4.7) F8(6.1,-4.5) F9(7.3,-4.5) F11(8.5,-4.5) F12(9.7,-4.5) F14(10.9,-4.5) F15(12.1,-4.5) F17(13.3,-4.5) F18(14.5,-4.5) F19(15.7,-4.5) F20(16.9,-4.5) F21(18.1,-4.5) F23(19.3,-4.5) F24(20.5,-4.5) F25(21.7,-4.5) F26(22.9,-4.5) F27(24.1,-4.5) F29(25.3,-4.5) F30(26.5,-4.5) F32(27.7,-4.5) F33(28.9,-4.5) F35(30.1,-4.5) F36(31.3,-4.5) F38(32.7,-4.7) F39(33.8,-4.9) F40(34.7,-4.9) F41(35.6,-4.9) F42(36.5,-4.9) F43(37.4,-4.9) G9(7.3,-5.3) G11(8.5,-5.3) G12(9.7,-5.3) G14(10.9,-5.3) G15(12.1,-5.3) G17(13.3,-5.3) G18(14.5,-5.3) G19(15.7,-5.3) G20(16.9,-5.3) G21(18.1,-5.3) G23(19.3,-5.3) G24(20.5,-5.3) G25(21.7,-5.3) G26(22.9,-5.3) G27(24.1,-5.3) G29(25.3,-5.3) G30(26.5,-5.3) G32(27.7,-5.3) G33(28.9,-5.3) G35(30.1,-5.3) H1(0,-6.1) H2(0.9,-6.1) H3(1.8,-6.1) H4(2.7,-6.1) H5(3.6,-6.1) H6(4.5,-6.1) H8(6.1,-6.1) H9(7.3,-6.1) H11(8.5,-6.1) H12(9.7,-6.1) H14(10.9,-6.1) H15(12.1,-6.1) H17(13.3,-6.1) H18(14.5,-6.1) H19(15.7,-6.1) H20(16.9,-6.1) H21(18.1,-6.1) H23(19.3,-6.1) H24(20.5,-6.1) H25(21.7,-6.1) H26(22.9,-6.1) H27(24.1,-6.1) H29(25.3,-6.1) H30(26.5,-6.1) H32(27.7,-6.1) H33(28.9,-6.1) H35(30.1,-6.1) H36(31.3,-6.1) H38(32.9,-6.1) H39(33.8,-6.1) H40(34.7,-6.1) H41(35.6,-6.1) H42(36.5,-6.1) H43(37.4,-6.1) J1(0,-7.3) J2(0.9,-7.3) J3(1.8,-7.3) J4(2.7,-7.3) J5(3.6,-7.3) J6(4.5,-7.3) J7(5.3,-7.3) J8(6.1,-7.3) J9(7.1,-7.1) J11(8.5,-6.9) J12(9.7,-6.9) J14(10.9,-6.9) J15(12.1,-6.9) J17(13.3,-6.9) J18(14.5,-6.9) J19(15.7,-6.9) J20(16.9,-6.9) J21(18.1,-6.9) J23(19.3,-6.9) J24(20.5,-6.9) J25(21.7,-6.9) J26(22.9,-6.9) J27(24.1,-6.9) J29(25.3,-6.9) J30(26.5,-6.9) J32(27.7,-6.9) J33(28.9,-6.9) J35(30.3,-7.1) J36(31.3,-7.3) J37(32.1,-7.3) J38(32.9,-7.3) J39(33.8,-7.3) J40(34.7,-7.3) J41(35.6,-7.3) J42(36.5,-7.3) J43(37.4,-7.3) K12(9.7,-7.7) K14(10.9,-7.7) K15(12.1,-7.7) K17(13.3,-7.7) K18(14.5,-7.7) K19(15.7,-7.7) K20(16.9,-7.7) K21(18.1,-7.7) K23(19.3,-7.7) K24(20.5,-7.7) K25(21.7,-7.7) K26(22.9,-7.7) K27(24.1,-7.7) K29(25.3,-7.7) K30(26.5,-7.7) K32(27.7,-7.7) L1(0,-8.5) L2(0.9,-8.5) L3(1.8,-8.5) L4(2.7,-8.5) L5(3.6,-8.5) L6(4.5,-8.5) L7(5.3,-8.5) L8(6.1,-8.5) L9(6.9,-8.5) L11(8.5,-8.5) L12(9.7,-8.5) L14(10.9,-8.5) L15(12.1,-8.5) L17(13.3,-8.5) L18(14.5,-8.5) L19(15.7,-8.5) L20(16.9,-8.5) L21(18.1,-8.5) L23(19.3,-8.5) L24(20.5,-8.5) L25(21.7,-8.5) L26(22.9,-8.5) L27(24.1,-8.5) L29(25.3,-8.5) L30(26.5,-8.5) L32(27.7,-8.5) L33(28.9,-8.5) L35(30.5,-8.5) L36(31.3,-8.5) L37(32.1,-8.5) L38(32.9,-8.5) L39(33.8,-8.5) L40(34.7,-8.5) L41(35.6,-8.5) L42(36.5,-8.5) L43(37.4,-8.5) M1(0,-9.7) M2(0.9,-9.7) M3(1.8,-9.7) M4(2.7,-9.7) M5(3.6,-9.7) M6(4.5,-9.7) M7(5.3,-9.7) M8(6.1,-9.7) M9(6.9,-9.7) M10(7.7,-9.7) M11(8.5,-9.7) M12(9.5,-9.5) M14(10.9,-9.3) M15(12.1,-9.3) M17(13.3,-9.3) M18(14.5,-9.3) M19(15.7,-9.3) M20(16.9,-9.3) M21(18.1,-9.3) M23(19.3,-9.3) M24(20.5,-9.3) M25(21.7,-9.3) M26(22.9,-9.3) M27(24.1,-9.3) M29(25.3,-9.3) M30(26.5,-9.3) M32(27.9,-9.5) M33(28.9,-9.7) M34(29.7,-9.7) M35(30.5,-9.7) M36(31.3,-9.7) M37(32.1,-9.7) M38(32.9,-9.7) M39(33.8,-9.7) M40(34.7,-9.7) M41(35.6,-9.7) M42(36.5,-9.7) M43(37.4,-9.7) N15(12.1,-10.1) N17(13.3,-10.1) N18(14.5,-10.1) N19(15.7,-10.1) N20(16.9,-10.1) N21(18.1,-10.1) N23(19.3,-10.1) N24(20.5,-10.1) N25(21.7,-10.1) N26(22.9,-10.1) N27(24.1,-10.1) N29(25.3,-10.1) P1(0,-10.9) P2(0.9,-10.9) P3(1.8,-10.9) P4(2.7,-10.9) P5(3.6,-10.9) P6(4.5,-10.9) P7(5.3,-10.9) P8(6.1,-10.9) P9(6.9,-10.9) P10(7.7,-10.9) P11(8.5,-10.9) P12(9.3,-10.9) P14(10.9,-10.9) P15(12.1,-10.9) P17(13.3,-10.9) P18(14.5,-10.9) P19(15.7,-10.9) P20(16.9,-10.9) P21(18.1,-10.9) P23(19.3,-10.9) P24(20.5,-10.9) P25(21.7,-10.9) P26(22.9,-10.9) P27(24.1,-10.9) P29(25.3,-10.9) P30(26.5,-10.9) P32(28.1,-10.9) P33(28.9,-10.9) P34(29.7,-10.9) P35(30.5,-10.9) P36(31.3,-10.9) P37(32.1,-10.9) P38(32.9,-10.9) P39(33.8,-10.9) P40(34.7,-10.9) P41(35.6,-10.9) P42(36.5,-10.9) P43(37.4,-10.9) R1(0,-12.1) R2(0.9,-12.1) R3(1.8,-12.1) R4(2.7,-12.1) R5(3.6,-12.1) R6(4.5,-12.1) R7(5.3,-12.1) R8(6.1,-12.1) R9(6.9,-12.1) R10(7.7,-12.1) R11(8.5,-12.1) R12(9.3,-12.1) R13(10.1,-12.1) R14(10.9,-12.1) R15(11.7,-11.7) R16(12.7,-11.7) R17(13.7,-11.7) R18(14.7,-11.7) R19(15.7,-11.7) R20(16.7,-11.7) R21(17.7,-11.7) R22(18.7,-11.7) R23(19.7,-11.7) R24(20.7,-11.7) R25(21.7,-11.7) R26(22.7,-11.7) R27(23.7,-11.7) R28(24.7,-11.7) R29(25.7,-11.7) R30(26.5,-12.1) R31(27.3,-12.1) R32(28.1,-12.1) R33(28.9,-12.1) R34(29.7,-12.1) R35(30.5,-12.1) R36(31.3,-12.1) R37(32.1,-12.1) R38(32.9,-12.1) R39(33.8,-12.1) R40(34.7,-12.1) R41(35.6,-12.1) R42(36.5,-12.1) R43(37.4,-12.1) T15(11.7,-12.7) T16(12.7,-12.7) T17(13.7,-12.7) T18(14.7,-12.7) T19(15.7,-12.7) T20(16.7,-12.7) T21(17.7,-12.7) T22(18.7,-12.7) T23(19.7,-12.7) T24(20.7,-12.7) T25(21.7,-12.7) T26(22.7,-12.7) T27(23.7,-12.7) T28(24.7,-12.7) T29(25.7,-12.7) U1(0,-13.3) U2(0.9,-13.3) U3(1.8,-13.3) U4(2.7,-13.3) U5(3.6,-13.3) U6(4.5,-13.3) U7(5.3,-13.3) U8(6.1,-13.3) U9(6.9,-13.3) U10(7.7,-13.3) U11(8.5,-13.3) U12(9.3,-13.3) U13(10.1,-13.3) U14(10.9,-13.3) U15(11.7,-13.7) U16(12.7,-13.7) U17(13.7,-13.7) U18(14.7,-13.7) U19(15.7,-13.7) U20(16.7,-13.7) U21(17.7,-13.7) U22(18.7,-13.7) U23(19.7,-13.7) U24(20.7,-13.7) U25(21.7,-13.7) U26(22.7,-13.7) U27(23.7,-13.7) U28(24.7,-13.7) U29(25.7,-13.7) U30(26.5,-13.3) U31(27.3,-13.3) U32(28.1,-13.3) U33(28.9,-13.3) U34(29.7,-13.3) U35(30.5,-13.3) U36(31.3,-13.3) U37(32.1,-13.3) U38(32.9,-13.3) U39(33.8,-13.3) U40(34.7,-13.3) U41(35.6,-13.3) U42(36.5,-13.3) U43(37.4,-13.3) V1(0,-14.5) V2(0.9,-14.5) V3(1.8,-14.5) V4(2.7,-14.5) V5(3.6,-14.5) V6(4.5,-14.5) V7(5.3,-14.5) V8(6.1,-14.5) V9(6.9,-14.5) V10(7.7,-14.5) V11(8.5,-14.5) V12(9.3,-14.5) V13(10.1,-14.5) V14(10.9,-14.5) V15(11.7,-14.7) V16(12.7,-14.7) V17(13.7,-14.7) V18(14.7,-14.7) V19(15.7,-14.7) V20(16.7,-14.7) V21(17.7,-14.7) V22(18.7,-14.7) V23(19.7,-14.7) V24(20.7,-14.7) V25(21.7,-14.7) V26(22.7,-14.7) V27(23.7,-14.7) V28(24.7,-14.7) V29(25.7,-14.7) V30(26.5,-14.5) V31(27.3,-14.5) V32(28.1,-14.5) V33(28.9,-14.5) V34(29.7,-14.5) V35(30.5,-14.5) V36(31.3,-14.5) V37(32.1,-14.5) V38(32.9,-14.5) V39(33.8,-14.5) V40(34.7,-14.5) V41(35.6,-14.5) V42(36.5,-14.5) V43(37.4,-14.5) W1(0,-15.7) W2(0.9,-15.7) W3(1.8,-15.7) W4(2.7,-15.7) W5(3.6,-15.7) W6(4.5,-15.7) W7(5.3,-15.7) W8(6.1,-15.7) W9(6.9,-15.7) W10(7.7,-15.7) W11(8.5,-15.7) W12(9.3,-15.7) W13(10.1,-15.7) W14(10.9,-15.7) W15(11.7,-15.7) W16(12.7,-15.7) W17(13.7,-15.7) W18(14.7,-15.7) W19(15.7,-15.7) W20(16.7,-15.7) W21(17.7,-15.7) W22(18.7,-15.7) W23(19.7,-15.7) W24(20.7,-15.7) W25(21.7,-15.7) W26(22.7,-15.7) W27(23.7,-15.7) W28(24.7,-15.7) W29(25.7,-15.7) W30(26.5,-15.7) W31(27.3,-15.7) W32(28.1,-15.7) W33(28.9,-15.7) W34(29.7,-15.7) W35(30.5,-15.7) W36(31.3,-15.7) W37(32.1,-15.7) W38(32.9,-15.7) W39(33.8,-15.7) W40(34.7,-15.7) W41(35.6,-15.7) W42(36.5,-15.7) W43(37.4,-15.7) Y1(0,-16.9) Y2(0.9,-16.9) Y3(1.8,-16.9) Y4(2.7,-16.9) Y5(3.6,-16.9) Y6(4.5,-16.9) Y7(5.3,-16.9) Y8(6.1,-16.9) Y9(6.9,-16.9) Y10(7.7,-16.9) Y11(8.5,-16.9) Y12(9.3,-16.9) Y13(10.1,-16.9) Y14(10.9,-16.9) Y15(11.7,-16.7) Y16(12.7,-16.7) Y17(13.7,-16.7) Y18(14.7,-16.7) Y19(15.7,-16.7) Y20(16.7,-16.7) Y21(17.7,-16.7) Y22(18.7,-16.7) Y23(19.7,-16.7) Y24(20.7,-16.7) Y25(21.7,-16.7) Y26(22.7,-16.7) Y27(23.7,-16.7) Y28(24.7,-16.7) Y29(25.7,-16.7) Y30(26.5,-16.9) Y31(27.3,-16.9) Y32(28.1,-16.9) Y33(28.9,-16.9) Y34(29.7,-16.9) Y35(30.5,-16.9) Y36(31.3,-16.9) Y37(32.1,-16.9) Y38(32.9,-16.9) Y39(33.8,-16.9) Y40(34.7,-16.9) Y41(35.6,-16.9) Y42(36.5,-16.9) Y43(37.4,-16.9)
ACES_50207-00471-P01_4P-T
  oval 0.508x0.991 smd: 1(0,0) 2(-0.8,0) 3(-1.6,0) 4(-2.4,0)
  rect 1.194x1.702 smd: 5(-3.7,1.45) 6(1.3,1.45)
ACES_50271-00201-001_2P
  oval 0.787x1.6 smd: 1(0,0) 2(1.25,0)
  rect 2.108x2.997 smd: 3(-2.55,-2.9) 4(3.8,-2.9)
ACES_50278-00401-001_4P
  oval 0.787x1.905 smd: 1(0,0) 2(1.25,0) 3(2.5,0) 4(3.75,0)
  rect 1.295x3.353 smd: 5(-2.85,-4.925) 6(6.6,-4.925)
ACES_50278-00601-001_6P-T
  oval 0.787x1.905 smd: 1(0,0) 2(1.25,0) 3(2.5,0) 4(3.75,0) 5(5,0) 6(6.25,0)
  rect 1.295x3.353 smd: 7(-2.85,-4.925) 8(9.1,-4.925)
ACES_50290-01201-P01_12P-T
  rect 0.838x7.01 smd: 1(0,0) 2(1.5,0) 3(3,0) 4(4.5,0) 5(6,0) 6(7.5,0) 7(9,0) 8(10.5,0) 9(12,0) 10(13.5,0) 11(15,0) 12(16.5,0)
ACES_50290-01301-P01_13P-T
  rect 0.838x7.01 smd: 1(0,0) 2(1.5,0) 3(3,0) 4(4.5,0) 5(6,0) 6(7.5,0) 7(9,0) 8(10.5,0) 9(12,0) 10(13.5,0) 11(15,0) 12(16.5,0) 13(18,0)
ACES_50450-0067N-P01_6P
  oval 0.508x1.295 smd: 1(0,0) 2(0.8,0) 3(1.6,0) 4(2.4,0) 5(3.2,0) 6(4,0)
  rect 1.194x1.702 smd: 7(-1.3,1.3) 8(5.3,1.3)
ACES_50450-0127N-001_12P
  oval 0.508x1.295 smd: 1(0,0) 2(0.8,0) 3(1.6,0) 4(2.4,0) 5(3.2,0) 6(4,0) 7(4.8,0) 8(5.6,0) 9(6.4,0) 10(7.2,0) 11(8,0) 12(8.8,0)
  rect 1.194x1.702 smd: 13(-1.3,1.9) 14(10.1,1.9)
ACES_50473-0300M-P01_30P
  oval 0.254x1.092 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0) 9(4,0) 10(4.5,0) 11(5,0) 12(5.5,0) 13(6,0) 14(6.5,0) 15(7,0) 16(7.5,0) 17(8,0) 18(8.5,0) 19(9,0) 20(9.5,0) 21(10,0) 22(10.5,0) 23(11,0) 24(11.5,0) 25(12,0) 26(12.5,0) 27(13,0) 28(13.5,0) 29(14,0) 30(14.5,0)
  rect 0.559x1.092 smd: 31(-0.9,0) 32(15.4,0)
  rect 1.397x1.905 smd: 33(-3.1,-2.92) 34(17.6,-2.92)
ACES_50473-0400M-P01_40P
  oval 0.254x1.092 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0) 9(4,0) 10(4.5,0) 11(5,0) 12(5.5,0) 13(6,0) 14(6.5,0) 15(7,0) 16(7.5,0) 17(8,0) 18(8.5,0) 19(9,0) 20(9.5,0) 21(10,0) 22(10.5,0) 23(11,0) 24(11.5,0) 25(12,0) 26(12.5,0) 27(13,0) 28(13.5,0) 29(14,0) 30(14.5,0) 31(15,0) 32(15.5,0) 33(16,0) 34(16.5,0) 35(17,0) 36(17.5,0) 37(18,0) 38(18.5,0) 39(19,0) 40(19.5,0)
  rect 0.559x1.092 smd: 41(-0.9,0) 42(20.4,0)
  rect 1.397x1.905 smd: 43(-3.1,-2.92) 44(22.6,-2.92)
ACES_50521-0084N-P01_8P
  oval 0.305x1.092 smd: 1(0,0) 2(-0.5,0) 3(-1,0) 4(-1.5,0) 5(-2,0) 6(-2.5,0) 7(-3,0) 8(-3.5,0)
  rect 0.406x0.787 smd: 9(1,-2.65) 10(-4.5,-2.65)
ACES_50552-02001-P01_20P
  oval 0.406x1.6 smd: 1(0,0) 2(0.5,-2.4) 3(1,0) 4(1.5,-2.4) 5(2,0) 6(2.5,-2.4) 7(3,0) 8(3.5,-2.4) 9(4,0) 10(4.5,-2.4) 11(5,0) 12(5.5,-2.4) 13(6,0) 14(6.5,-2.4) 15(7,0) 16(7.5,-2.4) 17(8,0) 18(8.5,-2.4) 19(9,0) 20(9.5,-2.4)
  rect 1.702x2.896 smd: 21(-1.65,-1.2) 22(11.15,-1.2)
ACES_50552-03001-P01_30P
  oval 0.406x1.6 smd: 1(0,0) 2(0.5,-2.4) 3(1,0) 4(1.5,-2.4) 5(2,0) 6(2.5,-2.4) 7(3,0) 8(3.5,-2.4) 9(4,0) 10(4.5,-2.4) 11(5,0) 12(5.5,-2.4) 13(6,0) 14(6.5,-2.4) 15(7,0) 16(7.5,-2.4) 17(8,0) 18(8.5,-2.4) 19(9,0) 20(9.5,-2.4) 21(10,0) 22(10.5,-2.4) 23(11,0) 24(11.5,-2.4) 25(12,0) 26(12.5,-2.4) 27(13,0) 28(13.5,-2.4) 29(14,0) 30(14.5,-2.4)
  rect 1.702x2.896 smd: 31(-1.65,-1.2) 32(16.15,-1.2)
ACES_50611-0100N-001_10P
  oval 0.61x1.651 smd: 1(0,0) 3(1,0) 5(2,0) 7(3,0) 9(4,0) 11(5,0) 13(6,0) 15(7,0) 17(8,0) 19(9,0)
  oval 0.61x1.854 smd: 2(0,3.75) 4(1,3.75) 6(2,3.75) 8(3,3.75) 10(4,3.75) 12(5,3.75) 14(6,3.75) 16(7,3.75) 18(8,3.75) 20(9,3.75)
ACES_51522-01601-P01_16P
  oval 0.305x1.295 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0) 9(4,0) 10(4.5,0) 11(5,0) 12(5.5,0) 13(6,0) 14(6.5,0) 15(7,0) 16(7.5,0)
  rect 2.489x1.905 smd: 17(-2.15,-3.3) 18(9.65,-3.3)
ACES_87153-06411_6P
  oval 0.61x1.499 smd: 1(0,0) 2(0.5,3) 3(1,0) 4(1.5,3) 5(2,0) 6(2.5,3)
  rect 0.787x1.499 smd: 7(3.5,3) 8(3.5,0) 9(-1,0) 10(-1,3)
ACES_87212-1600L_16P
  oval 0.457x1.499 smd: 1(0,0) 2(1,0) 3(2,0) 4(3,0) 5(4,0) 6(5,0) 7(6,0) 8(7,0) 9(8,0) 10(9,0) 11(10,0) 12(11,0) 13(12,0) 14(13,0) 15(14,0) 16(15,0)
  rect 1.194x1.803 smd: 17(-1.3,2.55) 18(16.3,2.55)
ACON_HMRA3-AK1L0C_19P
  round 0.813 hole 0.559: 1(0,0) 2(0.5,1.55) 3(1,0) 4(1.5,1.55) 5(2,0) 6(2.5,1.55) 7(3,0) 8(3.5,1.55) 9(4,0) 10(4.5,1.55) 11(5,0) 12(5.5,1.55) 13(6,0) 14(6.5,1.55) 15(7,0) 16(7.5,1.55) 17(8,0) 18(8.5,1.55) 19(9,0)
  oval 1.499x2.21 hole 0.889x1.6: 20(-2.75,1.7) 21(-4.65,-6.5) 22(11.75,1.7) 23(13.65,-7.75)
ACON_MAR2F-20K1800_20P
  round 1.194 hole 1.194 unplated: (-6.95,-0.5) (1.55,-0.5)
  round 0.813 hole 0.508: 1(0,0) 3(-0.6,-1.2) 5(-1.1,0) 7(-1.7,-1.2) 9(-2.2,0) 11(-3.2,0) 13(-3.7,-1.2) 15(-4.3,0) 17(-4.8,-1.2) 19(-5.4,0)
  oval 0.406x1.88 smd: 2(0,-2.995) 4(-0.6,-2.995) 6(-1.2,-2.995) 8(-1.8,-2.995) 10(-2.4,-2.995) 12(-3,-2.995) 14(-3.6,-2.995) 16(-4.2,-2.995) 18(-4.8,-2.995) 20(-5.4,-2.995)
  oval 1.194x2.261 hole 0.711x1.753: 21(-8.2,2.96) 22(-8.2,-2.04) 23(2.8,2.96) 24(2.8,-2.04)
ADM1032ARMZ-1RL_MSOP8
  oval 0.381x1.575 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.95,0) 5(1.95,4.35) 6(1.3,4.35) 7(0.65,4.35) 8(0,4.35)
ALC1309-CG_QFN56_7X7-S
  oval 0.889x0.203 smd: 1(0,0) 2(0,-0.4) 3(0,-0.8) 4(0,-1.2) 5(0,-1.6) 6(0,-2) 7(0,-2.4) 8(0,-2.8) 9(0,-3.2) 10(0,-3.6) 11(0,-4) 12(0,-4.4) 13(0,-4.8) 14(0,-5.2) 29(7.1,-5.2) 30(7.1,-4.8) 31(7.1,-4.4) 32(7.1,-4) 33(7.1,-3.6) 34(7.1,-3.2) 35(7.1,-2.8) 36(7.1,-2.4) 37(7.1,-2) 38(7.1,-1.6) 39(7.1,-1.2) 40(7.1,-0.8) 41(7.1,-0.4) 42(7.1,0)
  oval 0.203x0.889 smd: 15(0.95,-6.15) 16(1.35,-6.15) 17(1.75,-6.15) 18(2.15,-6.15) 19(2.55,-6.15) 20(2.95,-6.15) 21(3.35,-6.15) 22(3.75,-6.15) 23(4.15,-6.15) 24(4.55,-6.15) 25(4.95,-6.15) 26(5.35,-6.15) 27(5.75,-6.15) 28(6.15,-6.15) 43(6.15,0.95) 44(5.75,0.95) 45(5.35,0.95) 46(4.95,0.95) 47(4.55,0.95) 48(4.15,0.95) 49(3.75,0.95) 50(3.35,0.95) 51(2.95,0.95) 52(2.55,0.95) 53(2.15,0.95) 54(1.75,0.95) 55(1.35,0.95) 56(0.95,0.95)
  rect 4.597x4.597 smd: 57(3.55,-2.6)
ALC3266-CG_QFN56_7X7-S
  oval 0.889x0.203 smd: 1(0,0) 2(0,-0.4) 3(0,-0.8) 4(0,-1.2) 5(0,-1.6) 6(0,-2) 7(0,-2.4) 8(0,-2.8) 9(0,-3.2) 10(0,-3.6) 11(0,-4) 12(0,-4.4) 13(0,-4.8) 14(0,-5.2) 29(7.1,-5.2) 30(7.1,-4.8) 31(7.1,-4.4) 32(7.1,-4) 33(7.1,-3.6) 34(7.1,-3.2) 35(7.1,-2.8) 36(7.1,-2.4) 37(7.1,-2) 38(7.1,-1.6) 39(7.1,-1.2) 40(7.1,-0.8) 41(7.1,-0.4) 42(7.1,0)
  oval 0.203x0.889 smd: 15(0.95,-6.15) 16(1.35,-6.15) 17(1.75,-6.15) 18(2.15,-6.15) 19(2.55,-6.15) 20(2.95,-6.15) 21(3.35,-6.15) 22(3.75,-6.15) 23(4.15,-6.15) 24(4.55,-6.15) 25(4.95,-6.15) 26(5.35,-6.15) 27(5.75,-6.15) 28(6.15,-6.15) 43(6.15,0.95) 44(5.75,0.95) 45(5.35,0.95) 46(4.95,0.95) 47(4.55,0.95) 48(4.15,0.95) 49(3.75,0.95) 50(3.35,0.95) 51(2.95,0.95) 52(2.55,0.95) 53(2.15,0.95) 54(1.75,0.95) 55(1.35,0.95) 56(0.95,0.95)
  rect 4.597x4.597 smd: 57(3.55,-2.6)
ALPINE-RIDGE_BGA_337P
  round 0.254 smd: A1(0,0) A23(10.12,0) AA2(0.46,-9.2) AA22(9.66,-9.2) AB2(0.46,-9.66) AB3(0.92,-9.66) AB4(1.38,-9.66) AB5(1.84,-9.66) AB6(2.3,-9.66) AB7(2.76,-9.66) AB8(3.22,-9.66) AB9(3.68,-9.66) AB10(4.14,-9.66) AB11(4.6,-9.66) AB12(5.06,-9.66) AB13(5.52,-9.66) AB14(5.98,-9.66) AB15(6.44,-9.66) AB16(6.9,-9.66) AB17(7.36,-9.66) AB18(7.82,-9.66) AB19(8.28,-9.66) AB20(8.74,-9.66) AB21(9.2,-9.66) AB22(9.66,-9.66) AC1(0,-10.12) AC23(10.12,-10.12) B2(0.46,-0.46) B3(0.92,-0.46) B4(1.38,-0.46) B5(1.84,-0.46) B6(2.3,-0.46) B7(2.76,-0.46) B8(3.22,-0.46) B9(3.68,-0.46) B10(4.14,-0.46) B11(4.6,-0.46) B12(5.06,-0.46) B13(5.52,-0.46) B14(5.98,-0.46) B15(6.44,-0.46) B16(6.9,-0.46) B17(7.36,-0.46) B18(7.82,-0.46) B19(8.28,-0.46) B20(8.74,-0.46) B21(9.2,-0.46) B22(9.66,-0.46) C2(0.46,-0.92) C22(9.66,-0.92) D2(0.46,-1.38) D4(1.16,-1.16) D5(1.81,-1.16) D6(2.46,-1.16) D8(3.11,-1.16) D9(3.76,-1.16) D11(4.41,-1.16) D12(5.06,-1.16) D13(5.71,-1.16) D15(6.36,-1.16) D16(7.01,-1.16) D18(7.66,-1.16) D19(8.31,-1.16) D20(8.96,-1.16) D22(9.66,-1.38) E2(0.46,-1.84) E4(1.16,-1.81) E5(1.81,-1.81) E6(2.46,-1.81) E8(3.11,-1.81) E9(3.76,-1.81) E11(4.41,-1.81) E12(5.06,-1.81) E13(5.71,-1.81) E15(6.36,-1.81) E16(7.01,-1.81) E18(7.66,-1.81) E19(8.31,-1.81) E20(8.96,-1.81) E22(9.66,-1.84) F2(0.46,-2.3) F4(1.16,-2.46) F5(1.81,-2.46) F6(2.46,-2.46) F8(3.11,-2.46) F9(3.76,-2.46) F11(4.41,-2.46) F12(5.06,-2.46) F13(5.71,-2.46) F15(6.36,-2.46) F16(7.01,-2.46) F18(7.66,-2.46) F19(8.31,-2.46) F20(8.96,-2.46) F22(9.66,-2.3) G2(0.46,-2.76) G22(9.66,-2.76) H2(0.46,-3.22) H4(1.16,-3.11) H5(1.81,-3.11) H6(2.46,-3.11) H8(3.11,-3.11) H9(3.76,-3.11) H11(4.41,-3.11) H12(5.06,-3.11) H13(5.71,-3.11) H15(6.36,-3.11) H16(7.01,-3.11) H18(7.66,-3.11) H19(8.31,-3.11) H20(8.96,-3.11) H22(9.66,-3.22) J2(0.46,-3.68) J4(1.16,-3.76) J5(1.81,-3.76) J6(2.46,-3.76) J8(3.11,-3.76) J9(3.76,-3.76) J11(4.41,-3.76) J12(5.06,-3.76) J13(5.71,-3.76) J15(6.36,-3.76) J16(7.01,-3.76) J18(7.66,-3.76) J19(8.31,-3.76) J20(8.96,-3.76) J22(9.66,-3.68) K2(0.46,-4.14) K22(9.66,-4.14) L2(0.46,-4.6) L4(1.16,-4.41) L5(1.81,-4.41) L6(2.46,-4.41) L8(3.11,-4.41) L9(3.76,-4.41) L11(4.41,-4.41) L12(5.06,-4.41) L13(5.71,-4.41) L15(6.36,-4.41) L16(7.01,-4.41) L18(7.66,-4.41) L19(8.31,-4.41) L20(8.96,-4.41) L22(9.66,-4.6) M2(0.46,-5.06) M4(1.16,-5.06) M5(1.81,-5.06) M6(2.46,-5.06) M8(3.11,-5.06) M9(3.76,-5.06) M11(4.41,-5.06) M12(5.06,-5.06) M13(5.71,-5.06) M15(6.36,-5.06) M16(7.01,-5.06) M18(7.66,-5.06) M19(8.31,-5.06) M20(8.96,-5.06) M22(9.66,-5.06) N2(0.46,-5.52) N4(1.16,-5.71) N5(1.81,-5.71) N6(2.46,-5.71) N8(3.11,-5.71) N9(3.76,-5.71) N11(4.41,-5.71) N12(5.06,-5.71) N13(5.71,-5.71) N15(6.36,-5.71) N16(7.01,-5.71) N18(7.66,-5.71) N19(8.31,-5.71) N20(8.96,-5.71) N22(9.66,-5.52) P2(0.46,-5.98) P22(9.66,-5.98) R2(0.46,-6.44) R4(1.16,-6.36) R5(1.81,-6.36) R6(2.46,-6.36) R8(3.11,-6.36) R9(3.76,-6.36) R11(4.41,-6.36) R12(5.06,-6.36) R13(5.71,-6.36) R15(6.36,-6.36) R16(7.01,-6.36) R18(7.66,-6.36) R19(8.31,-6.36) R20(8.96,-6.36) R22(9.66,-6.44) T2(0.46,-6.9) T4(1.16,-7.01) T5(1.81,-7.01) T6(2.46,-7.01) T8(3.11,-7.01) T9(3.76,-7.01) T11(4.41,-7.01) T12(5.06,-7.01) T13(5.71,-7.01) T15(6.36,-7.01) T16(7.01,-7.01) T18(7.66,-7.01) T19(8.31,-7.01) T20(8.96,-7.01) T22(9.66,-6.9) U2(0.46,-7.36) U22(9.66,-7.36) V2(0.46,-7.82) V4(1.16,-7.66) V5(1.81,-7.66) V6(2.46,-7.66) V8(3.11,-7.66) V9(3.76,-7.66) V11(4.41,-7.66) V12(5.06,-7.66) V13(5.71,-7.66) V15(6.36,-7.66) V16(7.01,-7.66) V18(7.66,-7.66) V19(8.31,-7.66) V20(8.96,-7.66) V22(9.66,-7.82) W2(0.46,-8.28) W4(1.16,-8.31) W5(1.81,-8.31) W6(2.46,-8.31) W8(3.11,-8.31) W9(3.76,-8.31) W11(4.41,-8.31) W12(5.06,-8.31) W13(5.71,-8.31) W15(6.36,-8.31) W16(7.01,-8.31) W18(7.66,-8.31) W19(8.31,-8.31) W20(8.96,-8.31) W22(9.66,-8.28) Y2(0.46,-8.74) Y4(1.16,-8.96) Y5(1.81,-8.96) Y6(2.46,-8.96) Y8(3.11,-8.96) Y9(3.76,-8.96) Y11(4.41,-8.96) Y12(5.06,-8.96) Y13(5.71,-8.96) Y15(6.36,-8.96) Y16(7.01,-8.96) Y18(7.66,-8.96) Y19(8.31,-8.96) Y20(8.96,-8.96) Y22(9.66,-8.74)
  oval 0.178x0.33 smd: A2(0.46,0) A3(0.92,0) A4(1.38,0) A5(1.84,0) A6(2.3,0) A7(2.76,0) A8(3.22,0) A9(3.68,0) A10(4.14,0) A11(4.6,0) A12(5.06,0) A13(5.52,0) A14(5.98,0) A15(6.44,0) A16(6.9,0) A17(7.36,0) A18(7.82,0) A19(8.28,0) A20(8.74,0) A21(9.2,0) A22(9.66,0) AC2(0.46,-10.12) AC3(0.92,-10.12) AC4(1.38,-10.12) AC5(1.84,-10.12) AC6(2.3,-10.12) AC7(2.76,-10.12) AC8(3.22,-10.12) AC9(3.68,-10.12) AC10(4.14,-10.12) AC11(4.6,-10.12) AC12(5.06,-10.12) AC13(5.52,-10.12) AC14(5.98,-10.12) AC15(6.44,-10.12) AC16(6.9,-10.12) AC17(7.36,-10.12) AC18(7.82,-10.12) AC19(8.28,-10.12) AC20(8.74,-10.12) AC21(9.2,-10.12) AC22(9.66,-10.12)
  oval 0.33x0.178 smd: AA1(0,-9.2) AA23(10.12,-9.2) AB1(0,-9.66) AB23(10.12,-9.66) B1(0,-0.46) B23(10.12,-0.46) C1(0,-0.92) C23(10.12,-0.92) D1(0,-1.38) D23(10.12,-1.38) E1(0,-1.84) E23(10.12,-1.84) F1(0,-2.3) F23(10.12,-2.3) G1(0,-2.76) G23(10.12,-2.76) H1(0,-3.22) H23(10.12,-3.22) J1(0,-3.68) J23(10.12,-3.68) K1(0,-4.14) K23(10.12,-4.14) L1(0,-4.6) L23(10.12,-4.6) M1(0,-5.06) M23(10.12,-5.06) N1(0,-5.52) N23(10.12,-5.52) P1(0,-5.98) P23(10.12,-5.98) R1(0,-6.44) R23(10.12,-6.44) T1(0,-6.9) T23(10.12,-6.9) U1(0,-7.36) U23(10.12,-7.36) V1(0,-7.82) V23(10.12,-7.82) W1(0,-8.28) W23(10.12,-8.28) Y1(0,-8.74) Y23(10.12,-8.74)
